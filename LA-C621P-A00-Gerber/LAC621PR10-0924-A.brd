# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
THERMATRIP3#: length 10.5
  TOP w0.102: UE2.A2 272.25,58.04 v2(272.71,58.5) ; RE301.1 278.09,54.7 276.91,55.88 274.64,55.88 v2(274.46,55.71)
  IN3 w0.122: v2(272.71,58.5) 273.57,57.64 273.57,56.04 273.9,55.71 v2(274.46,55.71)
THSEL_STRAP: length 5.9
  TOP w0.102: RE78.1 263.36,68.23 v2(263.23,68.1) ; UE2.B29 264.4,65.3 v2(263.75,64.64)
  BOTTOM w0.102: v2(263.23,68.1) 263.28,68.05 263.28,65.08 263.72,64.64 v2(263.75,64.64)
TOUCH_SCREEN_DET#: length 128
  IN1 w0.076: 166.98,60.89 166.78,61.09 166.39,61.09 166.36,61.06
  IN1 w0.089: v2(170.29,54.33) 169.19,54.33 167.07,56.45 167.07,60.8 166.98,60.89 ; 166.36,61.06 165.88,60.58 165.25,60.58 164.96,60.86 164.67,60.86 164.04,61.49 163.21,61.49 163.13,61.57 161.54,61.57 160.93,60.96 155.51,60.96 154.98,60.43 153.48,60.43 153,60.91 145.84,60.91 145.72,61.03 145.38,61.03 145.3,60.94 139.1,60.94 138.16,61.88 138.16,62.06 138.16,62.9 137.25,63.82 132.6,63.82 132.5,63.82 131.97,64.35 130.33,65.99 130.33,65.99 129.44,66.89 129.44,68.98 129.44,71.25 129.98,71.8 129.98,72.66 129.98,73.62 128.32,75.28 121.33,75.28 118.8,77.8 118.8,82.78 118.24,83.34 117.11,83.34 116.42,82.66 116.42,79.19 115.8,78.57 108.21,78.57 107.45,79.33 100.92,79.33 98.34,81.91 98.34,82.69 98.06,82.97 97.53,82.97 97.25,82.69 97.25,82.29 94.79,79.83 91.19,79.83 90.41,80.61 90.41,81.62 88.86,83.17 85.36,83.17 83.72,84.81 v2(81.95,84.81)
  BOTTOM w0.076: v2(170.29,54.33) 170.5,54.54 170.5,55.07 170.46,55.1 170.46,55.34 170.52,55.4 170.52,55.58 170.7,55.76 UC1.AY5
  BOTTOM w0.102: RV623.2 82.76,84 v2(81.95,84.81) 81.95,85.79 81.75,85.99 JEDP1.32
TOUCH_SCREEN_PD#: length 130.1
  TOP w0.102: v2(181.69,72.8) 181.69,73.66 181.64,73.71 180.85,73.71 177.51,77.06 177.51,77.79 175.37,79.92 175.37,80.91 v2(175.81,81.35)
  IN2 w0.122: v2(95.03,85.2) 95.38,84.85 95.79,84.85 95.96,84.68 97.66,84.68 98.29,85.3 101.36,85.3 101.7,84.96 101.99,84.67 105.48,84.67 106.02,85.21 106.13,85.21 107.32,86.4 113.74,86.4 114.43,85.72 115.19,85.72 115.87,86.4 119.8,86.4 122.44,89.04 129.83,89.04 130.87,90.08 132.02,90.08 132.83,90.9 134.76,90.9 136.37,92.51 146.43,92.51 147.26,93.34 147.26,93.77 149.27,95.77 v2(149.8,95.77)
  IN3 w0.122: v2(177.19,89.41) 176.59,90.01 173.68,90.01 171.27,92.43 171.27,93.96 170.62,94.61 170.62,95.07 169.58,96.11 158.12,96.11 157.51,96.72 150.87,96.72 149.92,95.77 v2(149.8,95.77)
  BOTTOM w0.102: v2(177.19,89.41) 177.55,89.04 177.55,85.44 177.85,85.14 177.85,84.27 176.57,82.98 176.57,82.45 175.91,81.8 175.91,81.45 v2(175.81,81.35) 175.41,80.95 175.41,79.75 173.98,78.32 170.88,78.32 169.83,77.27 UC1.A7 ; JEDP1.5 95.25,85.93 95.03,85.71 v2(95.03,85.2) ; v2(181.69,72.8) 182.55,71.93 183.34,71.93 183.87,71.41 183.87,70.12 183.38,69.63 183.38,68.72 183.18,68.52 RPC5.6
TOUCHPAD_INTR#: length 93
  TOP w0.102: v2(222.21,31.91) 222.3,31.82 222.3,30.64 222.19,30.53 222.19,29.32 222.34,29.16 222.34,27.99 v3(222.25,27.91) 222.25,27.43 221.68,26.85 217.73,26.85 216,28.58 215.2,29.39 213.82,30.76 212.3,32.28 JKBTP1.16 ; RC272.2 182.63,46.6 181.41,46.6 180.37,47.64 179.28,47.64 v2(176.29,50.64)
  IN1 w0.089: v2(214.55,38.53) 214.52,38.56 213.3,38.56 211.29,36.55 190.33,36.55 184.3,42.59 181.85,42.59 176.48,47.97 176.48,50.45 v2(176.29,50.64)
  IN4 w0.089: v2(214.55,38.53) 214.55,38.49 216.49,36.54 216.49,36.1 217.43,35.15 217.43,34.9 218.48,33.84 218.97,33.84 220.45,32.36 221.76,32.36 v2(222.21,31.91)
  BOTTOM w0.076: 174.58,53.67 174.2,54.05 171.66,54.05 171.16,54.55 171.16,54.82 UC1.BA5
  BOTTOM w0.102: v2(176.29,50.64) 176.29,51.96 174.58,53.67
TP_LAN_JTAG_TCK: length 4.1
  TOP w0.102: RL2.2 268.49,87.02 268.49,87.86 v3(268.33,88.02) 267.62,88.73 UL1.35
TP_LAN_JTAG_TDI: length 4.1
  TOP w0.102: T88.1 268.6,85.46 268.03,86.02 268.03,86.51 267.8,86.74 267.8,87.23 267.5,87.53 UL1.32
TP_LAN_JTAG_TDO: length 2.9
  TOP w0.102: UL1.34 267.48,88.33 268.26,87.55 268.26,86.93 268.6,86.59 T89.1
TP_LAN_JTAG_TMS: length 4.2
  TOP w0.102: UL1.33 267.48,87.93 268.03,87.38 268.03,86.83 268.26,86.6 268.26,86.17 269.31,85.12 RL1.2
TPM_GPIO4: length 4.9
  TOP w0.102: UZ12.13 192.71,67.67 193.01,67.96 194.65,67.96 v3(195.29,67.32) RZ110.2
TPM_LPM#: length 10.7
  TOP w0.102: QZ9.1 195.27,63.47 194.35,63.47 193.87,62.98 193.87,62.14 193.72,61.99 RZ111.1 192.97,62.66 v2(192.97,63.08) ; v2(188.76,64.05) 188.9,64.18 UZ12.3
  IN1 w0.089: v2(188.76,64.05) 189.5,64.05 190.47,63.08 v2(192.97,63.08)
TPM_PIRQ#: length 32.9
  TOP w0.102: RZ69.2 194,75.23 194.4,74.82 194.4,73.93 193.84,73.37 193.84,72.48 192.59,71.22 v3(191.91,71.22) 191.72,71.22 191.1,71.85 v2(190.54,71.85) 190.54,71.75 190.9,71.39 UZ12.18
  IN3 w0.122: v2(174.7,71.17) 181.37,71.17 182.85,69.69 182.85,69.04 184,67.88 185.39,67.88 185.82,68.32 185.82,68.62 186.1,68.9 187.06,68.9 190.01,71.85 v2(190.54,71.85)
  BOTTOM w0.076: v2(174.7,71.17) 174.06,71.17 173.6,70.7 172.43,70.7 172.14,71 UC1.M3
TRST#_XDP: length 17.3
  TOP w0.102: v2(96,48.7) 96,49.81 v3(95.87,49.94) 95.69,50.11 93.24,50.11 92.61,49.48 JXDP1.54 ; UC8.12 100.17,44.61 100.03,44.76 99.53,44.76 98.59,43.82 98.34,43.82 v2(97.77,43.24)
  IN2 w0.122: v2(97.77,43.24) 94.63,46.38 94.63,47.79 95.08,48.24 95.54,48.24 v2(96,48.7)
TS_EN: length 133.4
  TOP w0.102: QV7.2 95.9,94.35 94.55,93 v3(94.55,91.76) 94.55,88.37 96.79,86.14 96.79,85.05 97.24,84.6 98.2,84.6 98.59,84.99 101.34,84.99 101.49,84.84 105.47,84.84 106.6,85.97 110.15,85.97 110.68,85.44 114.27,85.44 v2(114.79,84.92) ; v2(170.26,59.25) 169.89,59.62 169.89,60.09 170.12,60.33 170.75,60.33 172.53,58.55 178.76,58.55 179.03,58.28 185.6,58.28 185.8,58.08 186.29,58.08 186.55,58.34 RC282.2
  IN1 w0.076: 167.8,60.89 167.45,61.24 167.45,61.67 167.2,61.92 166.63,61.92 166.37,61.66 165.76,61.66 ; 163.21,61.88 162.58,62.51 162.48,62.51
  IN1 w0.089: v2(114.79,84.92) 115.26,85.39 117.81,85.39 119.02,84.18 119.02,77.89 121.42,75.49 128.41,75.49 130.2,73.71 130.2,73.53 130.2,72.58 130.2,72.57 130.2,71.71 129.65,71.16 129.65,70.7 129.65,69.07 129.65,69.06 129.65,66.98 130.42,66.21 132.59,64.04 137.3,64.04 138.38,62.96 138.38,62.49 139.63,61.24 152.97,61.24 153.17,61.04 155.26,61.04 155.38,61.17 160.31,61.17 161.1,61.95 161.58,61.95 162.14,62.51 162.48,62.51 ; 163.21,61.88 163.33,61.76 164.16,61.76 164.69,61.22 165.22,61.22 165.66,61.66 165.76,61.66 ; v2(170.26,59.25) 169.87,59.64 169.12,59.64 168.85,59.37 168.85,56.95 168.74,56.85 168.24,56.85 167.96,57.12 167.96,60.73 167.8,60.89
  BOTTOM w0.076: v2(170.26,59.25) 170.34,59.25 170.5,59.41 UC1.AP5
UART0_TXD: length 101.9
  TOP w0.102: v2(238.9,86.68) 238.9,86.53 236.86,84.48 235.99,84.48 232.45,80.94 232.45,80.18 231.11,78.83 230.64,78.83 229.35,77.55 229.35,76.09 228.97,75.71 227.09,75.71 v2(226.86,75.94) ; RE306.1 251.76,93.54 251.15,93.54 v3(250.97,93.72) 250.94,93.74 v2(250.94,95.22)
  IN1 w0.076: 175.79,67.33 v2(174.31,65.85)
  IN1 w0.089: v2(250.94,95.22) 250.56,94.83 249.91,94.83 248.71,96.03 244.8,96.03 244.4,95.63 242.67,95.63 240.55,93.51 239.08,93.51 238.01,92.45 238.01,87.57 v2(238.9,86.68) ; 175.79,67.33 176.67,68.22 184.85,68.22 185.08,67.99 185.51,67.99 185.79,68.27 185.79,68.75 186.34,69.29 187.41,69.29 187.55,69.43 189.68,69.43 191.53,71.29 193.16,71.29 197.25,75.38 198.79,75.38 200.06,76.64 220.26,76.64 221.43,75.48 226.41,75.48 v2(226.86,75.94)
  BOTTOM w0.076: UC1.AB2 172.93,65.69 173.2,65.96 174.2,65.96 v2(174.31,65.85)
UIM_CLK: length 66.1
  TOP w0.102: v3(276.67,70.06) 278.35,71.74 279.52,71.74 v2(280.05,72.27)
  IN2 w0.122: v2(286.51,79.96) 286.51,77.58 282.14,73.21 281.72,73.21 281.72,73.21 280.81,73.21 280.05,72.44 v2(280.05,72.27)
  BOTTOM w0.102: JNGFF2.24 242.22,69.8 243.29,70.87 246.8,70.87 248.8,72.88 254.21,72.88 257.06,75.72 258.58,75.72 259.09,75.21 263.16,75.21 265.24,73.13 271.02,73.13 272.98,71.18 276.17,71.18 277.85,72.85 279.82,72.85 280.05,72.63 v2(280.05,72.27) ; v2(286.51,79.96) 286.38,80.09 285.9,80.09 CZ66.1 285.43,80.57 286.84,80.57 287.88,80.58 288.33,81.03 JSIM1.3
UIM_DATA: length 77.5
  TOP w0.102: v2(279.32,72.29) 278.22,72.29 v3(277.51,71.58)
  IN2 w0.122: v2(303.85,81.84) 303.8,81.89 287.06,81.89 v2(286.45,81.28) 285.97,80.81 285.97,77.75 281.93,73.71 280.61,73.71 279.32,72.43 v2(279.32,72.29)
  BOTTOM w0.102: v2(279.32,72.29) 279.32,72.3 277.98,72.3 276.38,70.7 272.78,70.7 270.82,72.65 265.04,72.65 262.96,74.73 258.76,74.73 258.25,75.24 257.26,75.24 254.41,72.39 249,72.39 247,70.39 243.49,70.39 242.4,69.3 JNGFF2.26 ; v2(286.45,81.28) 286.02,81.71 CZ65.1 ; JSIM1.7 303.96,81.74 v2(303.85,81.84)
UIM_RESET: length 72.5
  TOP w0.102: v2(280.66,72.27) 280.66,71.72 280.19,71.25 278.55,71.25 276.32,69.02 v3(276.32,68.13)
  IN2 w0.122: v2(287.11,81.33) 287.04,81.26 287.04,77.4 282.35,72.71 281.51,72.71 281.1,72.71 v2(280.66,72.27)
  BOTTOM w0.102: JNGFF2.22 242.03,70.3 243.09,71.35 246.59,71.35 248.6,73.36 254.01,73.36 255.54,74.88 255.54,75.69 255.77,75.92 256.25,75.92 256.53,76.2 258.94,76.2 259.46,75.69 263.36,75.69 265.44,73.61 271.22,73.61 273.18,71.66 275.97,71.66 277.65,73.34 280.04,73.34 280.66,72.72 v2(280.66,72.27) ; JSIM1.2 289.78,83.57 289.24,83.04 285.73,83.04 CZ67.1 285.74,82.4 286.04,82.4 v2(287.11,81.33)
USB3_PRX_DTX_N1: length 152.3
  TOP w0.094: v2(284.76,61.12) 285.14,60.75 285.75,60.75 RI16.1
  IN1 w0.076: 171.68,75.13 171.67,75.13 171.61,75.13 171.47,74.98 170.62,74.98 170.57,75.04 170.04,75.04 169.51,74.5 169.16,74.5 168.92,74.27 168.92,73.31 168.71,73.09 168.53,73.09 168.51,73.07 168.47,73.07 168.34,72.95 168.34,72.82 v2(168.44,72.72)
  IN1 w0.112: 171.68,75.13 171.94,75.4 171.94,76.32 173.2,77.58 174.08,77.58 174.67,78.17 178.92,78.17 181.14,75.95 185.89,75.95 188.57,78.63 188.57,80.83 189.24,81.49 190.89,81.49 192.02,80.37 194.43,80.37 195.67,81.62 196.93,81.62 197.45,81.11 200.28,81.11 200.81,81.63 204.28,81.63 204.43,81.79 205.22,81.79 207.57,81.79 209.2,80.15 222.25,80.15 223.06,79.34 228.47,79.34 232.95,74.86 232.95,74.67 234.41,73.21 234.41,72.22 234.41,72.22 234.41,69.32 234.55,69.18 234.59,69.14 234.59,63.47 235.05,63.01 237.31,63.01 237.72,63.41 239.01,63.41 245.56,69.96 253.66,69.96 254.17,69.45 257.05,69.45 257.49,69.89 259.4,69.89 260.52,71 265.23,71 265.36,70.87 268.34,70.87 269.74,69.47 271.27,69.47 272.47,68.26 274.54,68.26 275.58,67.21 275.58,66.68 278.04,64.22 279.97,64.22 281.98,62.22 284.86,62.22 285.36,61.71 285.36,60.83 285.24,60.71 284.62,60.71 284.55,60.79 284.55,60.91 v2(284.76,61.12)
  BOTTOM w0.076: v2(168.44,72.72) 168.79,72.72 168.87,72.64 UC1.H8
USB3_PRX_DTX_N2: length 51.8
  IN2 w0.122: v2(155.44,106) 155.59,105.85 155.59,105.62 155.49,105.52 154.36,105.52 152.32,103.47 152.32,98.59 155.14,95.77 156.3,95.77 160.78,91.28 160.78,88.78 161.84,87.71 163.73,87.71 164.63,86.81 164.63,85.55 164.26,85.18 164.26,82.13 164.26,78.33 164.89,77.7 164.89,72.7 165.47,72.11 166.24,72.11 166.9,71.45 168.69,71.45 169.34,72.11 v2(169.34,72.14)
  BOTTOM w0.076: UC1.J6 169.78,71.99 169.58,72.19 169.4,72.19 v2(169.34,72.14)
  BOTTOM w0.094: JDOCK1.84 156,107.86 156.15,107.7 156.15,107.27 155.62,106.73 155.62,106.18 v2(155.44,106)
USB3_PRX_DTX_N3: length 190.8
  IN1 w0.076: v2(167.52,72.15) 167.09,72.15 165.36,70.42 165.17,70.42 165.13,70.38 165.11,70.38
  IN1 w0.112: v2(19.11,76.08) 19.15,76.04 19.15,75.1 20.68,73.57 22.64,73.57 23.08,74.01 23.08,75.29 21.93,76.44 21.93,85.13 22.71,85.91 22.71,86.87 23.4,87.56 23.4,88.42 24.1,89.11 24.95,89.11 25.95,90.11 30.69,90.11 31.01,89.79 38.9,89.79 41.36,87.33 46.95,87.33 52.55,92.92 62.93,92.92 65.55,90.31 65.56,90.31 65.69,90.18 66.82,90.18 68.01,91.37 71.26,91.37 74.61,94.72 101.61,94.72 103.03,93.3 106.04,93.3 106.33,93 110.05,93 110.61,92.44 121.55,92.44 123.33,90.66 126.88,90.66 127.2,90.35 128.67,90.35 136.13,82.89 138.15,82.89 138.38,83.12 144.65,83.12 145.71,82.07 145.71,80.67 145.31,80.28 145.31,78.13 145.68,77.76 147.21,77.76 147.89,77.07 154.9,77.07 155.1,76.87 156.34,76.87 157.16,76.05 157.16,73.41 157.8,72.77 160.18,72.77 160.97,71.98 160.97,70.9 161.5,70.38 165.11,70.38
  BOTTOM w0.076: UC1.J10 167.64,72.15 v2(167.52,72.15)
  BOTTOM w0.094: v2(19.11,76.08) 19.37,76.34 19.37,77.11 RI20.1
USB3_PRX_DTX_N4: length 123.5
  TOP w0.094: RI24.1 65.84,91.86 65.84,91.74 v2(65.62,91.52)
  IN1 w0.076: v2(167.49,74.66) 167.36,74.53 167.06,74.53 166.86,74.33 166.86,73.26 165.95,72.34 163.76,72.34 163.49,72.61 163.49,74.91 163.87,75.28 163.87,75.55 163.91,75.59 163.91,75.6
  IN1 w0.112: v2(65.62,91.52) 65.61,91.52 65.61,92.27 65.95,92.61 71.08,92.61 74.1,95.63 102.12,95.63 103.54,94.21 106.42,94.21 106.71,93.91 110.43,93.91 110.99,93.35 121.95,93.35 123.71,91.6 127.27,91.6 127.58,91.28 130.24,91.28 131.87,89.66 134.11,89.66 135.15,88.62 138.65,88.62 142.85,84.41 146.63,84.41 147.65,83.39 147.65,79.64 148.46,78.84 149.99,78.84 151.27,80.11 151.8,80.11 151.94,80.25 153.6,80.25 153.95,80.6 157.34,80.6 157.69,80.25 158.3,80.25 158.78,79.77 158.78,78.83 160.51,77.09 161.57,77.09 162.22,76.45 163.61,76.45 163.91,76.15 163.91,75.6
  BOTTOM w0.076: UC1.E10 167.72,74.44 v2(167.49,74.66)
USB3_PRX_DTX_N5: length 83.3
  TOP w0.094: RI28.1 234.05,72.39 234.05,73.22 230.88,76.4 230.88,77.28 231.15,77.56 231.45,77.56 231.69,77.33 v2(231.69,77.17)
  IN1 w0.076: 169.88,76.26 169.87,76.25 169.81,76.25 168.69,75.12 167.76,75.12 167.42,75.47 166.84,75.47 166.24,74.87 166.24,73.48 166,73.23 165.74,73.23 165.65,73.14 v2(165.65,72.93)
  IN1 w0.112: v2(231.69,77.17) 231.58,77.17 228.75,80.01 223.88,80.01 223.33,80.01 222.52,80.82 209.55,80.82 207.89,82.47 204.18,82.47 204.01,82.3 201.15,82.3 200.87,82.58 190.59,82.58 190.34,82.33 186.37,82.33 185.76,82.94 177.49,82.94 177.05,82.51 177.05,81.51 173.96,78.41 172.85,78.41 171.31,76.87 170.49,76.87 169.88,76.26
  BOTTOM w0.076: v2(165.65,72.93) 165.65,72.8 165.96,72.49 UC1.H13
USB3_PRX_DTX_P1: length 152.3
  TOP w0.094: RI15.1 285.64,60.55 285.03,60.55 v2(284.76,60.29)
  IN1 w0.076: 171.5,75.31 171.5,75.3 171.5,75.24 171.4,75.15 170.69,75.15 170.64,75.2 169.97,75.2 169.44,74.67 169.09,74.67 168.76,74.34 168.76,73.37 168.64,73.26 168.57,73.26 v2(168.39,73.43)
  IN1 w0.112: 171.5,75.31 171.7,75.5 171.7,76.42 173.1,77.82 173.97,77.82 174.57,78.41 179.02,78.41 181.24,76.2 185.79,76.2 188.33,78.74 188.33,80.93 189.14,81.74 191,81.74 192.12,80.62 194.32,80.62 195.57,81.87 197.04,81.87 197.55,81.35 200.18,81.35 200.71,81.88 204.18,81.88 204.33,82.03 205.12,82.03 207.67,82.03 209.3,80.4 222.35,80.4 223.16,79.59 228.57,79.59 233.2,74.97 233.2,74.77 234.66,73.31 234.66,72.12 234.66,69.42 234.84,69.24 234.84,63.57 235.15,63.25 237.21,63.25 237.61,63.66 238.91,63.66 245.46,70.21 253.76,70.21 254.27,69.69 256.95,69.69 257.39,70.13 259.3,70.13 260.42,71.25 265.33,71.25 265.47,71.12 268.44,71.12 269.84,69.71 271.37,69.71 272.58,68.5 274.64,68.5 275.83,67.31 275.83,66.78 278.14,64.47 280.07,64.47 282.08,62.46 284.96,62.46 285.61,61.81 285.61,60.73 285.34,60.46 284.94,60.46 v2(284.76,60.29)
  BOTTOM w0.076: v2(168.39,73.43) 168.69,73.14 UC1.G8
USB3_PRX_DTX_P2: length 51.7
  IN2 w0.122: v2(156.08,105.99) 156.02,105.99 155.83,105.79 155.83,105.53 155.58,105.28 154.46,105.28 152.55,103.38 152.55,98.69 155.24,96 156.39,96 161.01,91.38 161.01,88.87 161.94,87.94 163.82,87.94 164.86,86.91 164.86,85.45 164.49,85.08 164.49,82.23 164.49,78.43 165.12,77.8 165.12,72.79 165.57,72.34 166.33,72.34 166.99,71.68 168.59,71.68 168.87,71.96 168.87,72.36 v2(169.28,72.77)
  BOTTOM w0.076: v2(169.28,72.77) 169.56,72.49 UC1.H6
  BOTTOM w0.094: v2(156.08,105.99) 156.06,105.99 155.81,106.24 155.81,106.65 156.35,107.19 156.35,107.72 156.5,107.87 JDOCK1.86
USB3_PRX_DTX_P3: length 190.7
  IN1 w0.076: 165.11,70.62 165.13,70.62 165.17,70.58 165.29,70.58 167.02,72.31 167.15,72.31 167.52,72.68 v2(167.52,72.78)
  IN1 w0.112: 165.11,70.62 161.6,70.62 161.22,71 161.22,72.09 160.28,73.02 157.9,73.02 157.41,73.51 157.41,76.16 156.44,77.12 155.21,77.12 155.01,77.32 147.99,77.32 147.31,78 145.79,78 145.55,78.24 145.55,80.17 145.95,80.57 145.95,82.17 144.75,83.37 138.28,83.37 138.05,83.14 136.23,83.14 128.77,90.6 127.3,90.6 126.99,90.91 123.43,90.91 121.65,92.69 110.71,92.69 110.16,93.25 106.44,93.25 106.14,93.54 103.14,93.54 101.71,94.97 74.51,94.97 71.16,91.61 67.91,91.61 66.72,90.43 65.79,90.43 65.67,90.55 65.66,90.55 63.04,93.17 52.44,93.17 46.85,87.58 41.46,87.58 39,90.04 31.11,90.04 30.8,90.35 25.84,90.35 24.85,89.36 23.99,89.36 23.16,88.52 23.16,87.66 22.47,86.97 22.47,86.01 21.69,85.23 21.69,76.34 22.83,75.19 22.83,74.12 22.53,73.82 20.78,73.82 19.39,75.2 19.39,75.7 v2(19.77,76.08)
  BOTTOM w0.076: v2(167.52,72.78) 167.6,72.7 167.67,72.63 167.81,72.49 UC1.H10
  BOTTOM w0.094: RI19.1 19.56,77.14 19.56,76.29 v2(19.77,76.08)
USB3_PRX_DTX_P4: length 123.6
  TOP w0.094: v2(66.23,91.52) 66.1,91.52 66.03,91.59 66.03,91.83 66.34,92.13 RI23.1
  IN1 w0.076: 163.66,75.6 163.66,75.58 163.7,75.54 163.7,75.35 163.33,74.97 163.33,72.54 163.69,72.18 166.02,72.18 167.03,73.19 167.03,74.26 167.13,74.36 167.26,74.36 167.49,74.13 v2(167.49,74.03)
  IN1 w0.112: v2(66.23,91.52) 66.23,91.85 66.15,91.93 65.95,91.93 65.86,92.02 65.86,92.17 66.05,92.37 71.18,92.37 74.2,95.38 102.02,95.38 103.44,93.96 106.31,93.96 106.61,93.67 110.33,93.67 110.89,93.11 121.85,93.11 123.61,91.35 127.16,91.35 127.48,91.04 130.14,91.04 131.76,89.41 134.01,89.41 135.05,88.37 138.54,88.37 142.75,84.16 146.53,84.16 147.4,83.29 147.4,79.54 148.36,78.59 150.09,78.59 151.37,79.86 151.9,79.86 152.04,80 153.7,80 154.05,80.36 157.24,80.36 157.59,80 158.19,80 158.53,79.67 158.53,78.73 160.41,76.85 161.47,76.85 162.11,76.2 163.51,76.2 163.66,76.05 163.66,75.6
  BOTTOM w0.076: v2(167.49,74.03) 167.7,74.03 167.94,73.79 UC1.F10
USB3_PRX_DTX_P5: length 83.4
  TOP w0.094: RI27.1 233.86,72.39 233.86,73.14 230.68,76.32 230.68,77.36 231.07,77.75 231.75,77.75 v2(231.79,77.79)
  IN1 w0.076: 169.7,76.43 169.7,76.43 169.7,76.37 168.62,75.29 167.83,75.29 167.49,75.63 166.78,75.63 166.08,74.93 166.08,73.55 165.93,73.4 165.73,73.4 165.66,73.47 v2(165.66,73.59)
  IN1 w0.112: v2(231.79,77.79) 231.31,77.79 228.85,80.25 223.78,80.25 223.43,80.25 222.62,81.06 209.65,81.06 207.99,82.72 204.08,82.72 203.9,82.55 201.25,82.55 200.98,82.83 190.49,82.83 190.24,82.58 186.47,82.58 185.87,83.19 177.39,83.19 176.81,82.61 176.81,81.61 173.86,78.66 172.75,78.66 171.21,77.12 170.39,77.12 169.7,76.43
  BOTTOM w0.076: UC1.G13 v2(165.66,73.59)
USB3_PRX_L_DTX_N1: length 8.5
  TOP w0.094: JUSB3.5 292.19,64.04 291.68,63.53 291.36,63.53 290.95,63.12 290.9,63.12 290.48,62.7 290.48,62.65 289.54,61.71 v4(289.54,61.24) 289.54,60.66 289.62,60.57 289.62,60.4 289.56,60.33 289.47,60.33 289.26,60.53 DI4.9 DI4.1 287.72,60.53 287.65,60.47 287.53,60.47 RI16.2
USB3_PRX_L_DTX_N3: length 10.9
  BOTTOM w0.094: RI20.2 19.37,78.74 19.37,78.92 19.54,79.1 19.54,79.23 19.41,79.36 DI1.9 DI1.1 19.41,81.02 19.56,81.17 19.56,81.28 19.47,81.37 19.24,81.37 19.21,81.34 18.62,81.34 18.59,81.37 18.23,81.37 18,81.14 v4(17.32,81.14) 16.73,81.14 16.39,81.48 16.39,81.88 15.73,82.54 15.18,82.54 15.18,82.54 15.1,82.54 14.74,82.17 14.11,82.17 13.93,81.99 JUSB1.5
USB3_PRX_L_DTX_N4: length 11.9
  TOP w0.094: JUSB2.5 61.18,101.27 61.37,101.08 61.37,100.69 61.87,100.19 61.87,99.43 64.14,97.17 64.48,97.17 64.51,97.14 65.11,97.14 65.14,97.17 65.37,97.17 65.85,96.69 v4(65.85,96.16) 65.85,95.62 65.75,95.52 DI6.9 DI6.1 65.75,93.72 65.9,93.57 65.9,93.38 RI24.2
USB3_PRX_L_DTX_N5: length 6.4
  TOP w0.094: v2(235.29,70.69) 234.65,70.05 234.65,69.1 234.47,68.92 234.26,68.92 234.1,69.07 234.1,69.61 234.13,69.64 234.13,70.23 234.1,70.26 234.1,70.82 RI28.2
  BOTTOM w0.094: v2(235.29,70.69) 235.29,70.59 235.08,70.38 234.74,70.38 234.57,70.55 JNGFF2.21
USB3_PRX_L_DTX_P1: length 8.5
  TOP w0.094: RI15.2 287.21,60.41 287.31,60.41 287.5,60.21 287.59,60.21 287.77,60.03 DI4.2 DI4.8 289.27,60.03 289.38,60.14 289.64,60.14 289.82,60.32 289.82,60.65 289.73,60.74 289.73,60.91 289.76,60.95 289.76,61.54 289.73,61.57 289.73,61.63 v4(290.85,62.75) 291.44,63.34 291.94,63.34 292.19,63.09 JUSB3.6
USB3_PRX_L_DTX_P3: length 10.9
  BOTTOM w0.094: JUSB1.6 13.93,82.66 14.22,82.37 14.66,82.37 15.02,82.73 15.26,82.73 15.26,82.73 15.81,82.73 16.59,81.96 16.59,81.56 16.81,81.34 16.99,81.34 17.02,81.37 17.61,81.37 17.65,81.34 17.92,81.34 18.15,81.57 v4(18.91,81.57) 19.55,81.57 19.75,81.36 19.75,81.17 19.91,81.02 DI1.2 DI1.8 19.91,79.39 19.74,79.22 19.74,79.02 19.56,78.84 19.56,78.73 RI19.2
USB3_PRX_L_DTX_P4: length 11.9
  TOP w0.094: JUSB2.6 61.79,101.27 61.56,101.04 61.56,100.78 62.06,100.27 62.06,99.51 64.22,97.36 v4(64.81,97.36) 65.45,97.36 66.04,96.77 66.04,96.47 66.07,96.44 66.07,95.87 66.04,95.84 66.04,95.66 66.25,95.46 DI6.8 DI6.2 66.25,93.72 66.09,93.57 66.09,93.41 RI23.2
USB3_PRX_L_DTX_P5: length 6.4
  TOP w0.094: v2(235.29,70.06) 234.93,70.06 234.85,69.97 234.85,69.02 234.55,68.73 234.18,68.73 233.91,68.99 v4(233.91,69.93) 233.91,70.73 RI27.2
  BOTTOM w0.094: JNGFF2.23 234.59,70.05 234.73,70.18 235.16,70.18 v2(235.29,70.06)
USB3_PTX_C_DRX_N1: length 1.6
  TOP w0.094: RI18.1 285.72,58.9 285.09,58.9 CI13.1
USB3_PTX_C_DRX_N3: length 1.3
  BOTTOM w0.094: CI5.1 20.83,76.48 21.14,76.79 21.14,77.13 RI22.1
USB3_PTX_C_DRX_N4: length 1.3
  TOP w0.094: CI27.1 67.64,91.56 67.64,91.84 RI26.1
USB3_PTX_C_DRX_N5: length 1.2
  TOP w0.094: RI30.1 236.27,71.29 236.27,71.49 CI29.1
USB3_PTX_C_DRX_P1: length 1.6
  TOP w0.094: RI17.1 285.71,58.7 285.09,58.7 CI16.1
USB3_PTX_C_DRX_P3: length 1.3
  BOTTOM w0.094: CI4.1 21.64,76.48 21.33,76.79 21.33,77.13 RI21.1
USB3_PTX_C_DRX_P4: length 1.3
  TOP w0.094: RI25.1 67.83,91.72 67.83,91.42 CI28.1
USB3_PTX_C_DRX_P5: length 1.2
  TOP w0.094: RI29.1 236.47,71.29 236.47,71.49 CI30.1
USB3_PTX_DRX_N1: length 162.1
  TOP w0.094: CI13.2 283.57,58.98 283.26,58.98 283.04,59.2 v2(283.04,59.28)
  IN1 w0.112: v2(168.95,81.68) 168.93,81.7 168.93,85.15 169.66,85.89 169.66,86.79 170.94,88.06 172.73,88.06 173.2,88.52 185.17,88.52 186.54,87.15 188.68,87.15 188.81,87.28 198.86,87.28 199.5,86.64 204.79,86.64 205.05,86.9 205.59,86.9 205.6,86.9 210.52,86.9 210.53,86.91 210.79,86.66 211.97,85.47 213.15,85.47 214,84.62 214.01,84.62 214.02,84.61 220.58,84.61 220.58,84.62 220.8,84.62 221.63,85.44 221.63,86.34 223.62,88.33 228.9,88.33 230.26,86.97 231.21,86.97 232.22,85.96 233,85.96 236.61,82.34 236.61,80.59 237.25,79.96 237.25,78.97 240.03,76.18 240.99,76.18 241.76,75.41 242.33,74.84 242.33,71.68 243.01,71 244.26,71 244.39,71.13 259.26,71.13 260.15,72.01 263.98,72.01 264.71,72.74 267.93,72.74 270.24,70.43 271.83,70.43 272.38,69.88 275.7,69.88 276.49,69.09 276.49,67.06 278.21,65.34 280.39,65.34 280.62,65.57 284.5,65.57 286.94,63.14 286.94,61.06 285.25,59.37 283.8,59.37 283.44,59.73 282.7,59.73 282.54,59.57 282.54,59.43 282.69,59.28 v2(283.04,59.28)
  BOTTOM w0.076: UC1.C13 166.23,75.66 166.14,75.57 166.01,75.57 165.92,75.66 165.92,76.08 165.87,76.14 165.85,76.2 165.8,76.37 165.81,76.35 165.79,76.4 165.79,76.62 165.85,76.81 165.85,76.9 165.79,77.01 165.79,77.38 166.05,77.64 166.37,77.64 167.26,78.52 167.26,78.95 167.42,79.11 167.42,79.31
  BOTTOM w0.094: 167.42,79.31 167.42,79.5 167.83,79.91 168.41,79.91 169.25,80.75 169.25,81.37 v2(168.95,81.68)
USB3_PTX_DRX_N2: length 46
  IN2 w0.122: v2(168.39,78.62) 167.4,79.61 167.4,81.89 165.46,83.82 165.46,86.9 163.92,88.45 162.11,88.45 161.45,89.11 161.45,91.54 156.29,96.71 155.29,96.71 152.98,99.01 152.98,103.21 154.18,104.4 154.97,104.4 155.28,104.09 155.64,104.09 155.87,104.32 155.87,104.48 v2(155.68,104.67)
  BOTTOM w0.076: UC1.B13 166.48,76.76 166.61,76.76 166.81,76.97 166.81,77.37 167.96,78.52 167.96,78.82 168.1,78.96 168.3,78.96 168.39,78.87 v2(168.39,78.62)
  BOTTOM w0.094: v2(155.68,104.67) 155.8,104.79 155.8,105.14 156.08,105.41 156.88,105.41 157.65,106.19 157.65,107.55 157.5,107.7 JDOCK1.90
USB3_PTX_DRX_N3: length 183.6
  IN1 w0.112: v2(165.19,79.66) 164.88,79.66 164.48,80.06 164.48,84 161.43,87.05 159.37,87.05 158.02,88.4 149.38,88.4 147.94,89.84 144.11,89.84 143.27,89 140.86,89 139.13,90.73 136.71,90.73 135.21,92.24 135.21,93.13 133.3,95.03 122.28,95.03 121.93,94.68 111.91,94.68 111.21,95.38 107.18,95.38 107.02,95.53 104.79,95.53 101.66,98.66 96.25,98.66 95.46,97.86 92.55,97.86 91.86,98.56 91.65,98.56 80.05,98.56 79.82,98.33 67.78,98.33 66.35,96.9 59.41,96.9 58.97,96.45 54.58,96.45 47.2,89.07 41.1,89.07 39.47,90.71 34.81,90.71 34.12,91.39 31.17,91.39 30.26,92.3 26.78,92.3 24.68,90.2 21.51,90.2 20.33,89.02 20.33,84.59 20.85,84.08 20.85,76.69 20.97,76.56 20.97,74.64 v2(20.97,74.63)
  BOTTOM w0.076: UC1.B15 164.71,76.67 164.57,76.67 164.39,76.86 164.39,77.41 164.58,77.6 164.58,79.45 164.73,79.6 165.13,79.6 v2(165.19,79.66)
  BOTTOM w0.094: v2(20.97,74.63) 21.14,74.81 21.14,75.21 CI5.2
USB3_PTX_DRX_N4: length 124.2
  TOP w0.094: CI27.2 67.48,89.96 67.48,89.63 67.77,89.35 68.93,89.35 69.67,90.09 69.67,90.97 69.21,91.43 v4(69.21,92.24) 69.21,94.09 69.41,94.29 v2(69.41,95.01)
  IN1 w0.112: v2(166.43,79.53) 166.38,79.53 165.48,78.63 164.61,78.63 163.79,79.46 163.79,83.29 160.87,86.21 158.96,86.21 157.44,87.73 144.47,87.73 144.24,87.51 141.01,87.51 138.82,89.69 136.78,89.69 134.38,92.1 134.38,92.89 132.9,94.37 122.56,94.37 122.2,94.02 111.43,94.02 110.87,94.57 106.99,94.57 106.69,94.87 104.1,94.87 101.15,97.82 97.12,97.82 95.59,96.29 72.69,96.29 71.31,94.92 70.42,94.92 69.97,94.47 69.08,94.47 69,94.56 69,94.66 69.35,95.01 v2(69.41,95.01)
  BOTTOM w0.076: 166.36,79.46 166.11,79.21 166.01,79.21 165.53,78.73 165.53,78.25 165.14,77.86 165.14,77.05 165.14,77.04 165.11,76.94 165.11,76.7 165.14,76.61 165.14,76.42 165.08,76.23 165.02,76.17 164.8,76.17 164.73,76.1 164.73,75.98 164.85,75.86 UC1.C15
  BOTTOM w0.094: 166.36,79.46 v2(166.43,79.53)
USB3_PTX_DRX_N5: length 96.4
  TOP w0.094: v2(235.77,74.93) 235.77,74.81 235.51,74.54 235.51,74.17 236.27,73.4 236.27,73.1 CI29.2
  IN1 w0.112: v2(165.57,80.32) 165.7,80.32 165.82,80.45 165.82,80.73 165.93,80.83 166.33,80.83 167.31,79.84 170.42,79.84 171.3,80.72 171.3,83.03 171.89,83.62 171.89,83.82 171.89,83.83 171.89,83.93 171.89,84.61 172.58,85.3 173.82,85.3 175.48,86.95 181.06,86.95 182.73,85.28 188.78,85.28 188.93,85.12 196.99,85.12 197.19,84.92 198.95,84.92 198.95,84.92 203.69,84.92 203.85,85.07 204.84,85.07 205.14,84.77 209.46,84.77 210.96,83.27 212.71,83.27 213.12,82.87 222.2,82.87 223.33,83.99 223.33,85.65 224.44,86.76 228.04,86.76 229.38,85.42 229.38,84.88 235.15,79.12 235.15,77.85 236.28,76.71 236.28,75.08 236.14,74.93 v2(235.77,74.93)
  BOTTOM w0.076: v2(165.57,80.32) 165.29,80.6 164.78,80.6 164.55,80.37 164.55,79.76 164.36,79.57 164.36,77.64 164.2,77.47 164.2,77.06 164.01,76.88 163.93,76.88 163.75,76.69 UC1.B17
USB3_PTX_DRX_P1: length 162.1
  TOP w0.094: v2(283.02,58.65) 283.16,58.79 283.39,58.79 CI16.2
  IN1 w0.112: v2(283.02,58.65) 283.02,58.72 282.82,58.91 282.71,59.03 282.59,59.03 282.29,59.33 282.29,59.67 282.6,59.97 283.54,59.97 283.9,59.62 285.14,59.62 286.69,61.16 286.69,63.04 284.4,65.33 280.72,65.33 280.49,65.1 278.1,65.1 276.25,66.95 276.25,68.99 275.6,69.63 272.27,69.63 271.72,70.18 270.14,70.18 267.83,72.5 264.81,72.5 264.08,71.77 260.25,71.77 259.36,70.88 244.49,70.88 244.36,70.75 242.91,70.75 242.08,71.58 242.08,74.74 241.59,75.24 240.89,75.93 239.93,75.93 237,78.86 237,79.85 236.37,80.49 236.37,82.24 232.9,85.71 232.12,85.71 231.11,86.72 230.16,86.72 228.79,88.09 223.72,88.09 221.87,86.24 221.87,85.34 220.9,84.37 220.68,84.37 220.68,84.37 213.91,84.37 213.91,84.37 213.9,84.37 213.04,85.23 211.87,85.23 211.52,85.58 211.21,85.88 210.61,86.48 210.44,86.65 205.7,86.65 205.15,86.65 204.89,86.39 199.4,86.39 198.76,87.03 188.91,87.03 188.78,86.9 186.44,86.9 185.07,88.28 173.3,88.28 172.83,87.81 171.04,87.81 169.91,86.68 169.91,85.79 169.18,85.05 169.18,82.03 169.28,81.93 169.52,81.69 v2(169.53,81.69)
  BOTTOM w0.076: 167.61,79.31 167.61,79.3 167.59,79.28 167.59,79.24 167.58,79.23 167.58,79.04 167.42,78.88 167.42,78.45 166.44,77.47 166.12,77.47 165.96,77.31 165.96,77.05 166.02,76.94 166.02,76.79 165.96,76.59 165.96,76.42 165.99,76.33 166.1,76.2 166.31,76.15 166.31,76.15 166.35,76.15 166.52,75.98 166.52,75.74 166.36,75.45 UC1.D13
  BOTTOM w0.094: v2(169.53,81.69) 169.44,81.6 169.44,80.67 168.49,79.72 167.91,79.72 167.61,79.42 167.61,79.31
USB3_PTX_DRX_P2: length 45.9
  IN2 w0.122: v2(168.72,79.12) 168.21,79.12 167.63,79.7 167.63,81.99 165.7,83.92 165.7,87 164.01,88.68 162.21,88.68 161.68,89.21 161.68,91.64 156.38,96.94 155.38,96.94 153.22,99.1 153.22,103.11 154.27,104.17 154.88,104.17 155.19,103.86 155.74,103.86 156.1,104.22 156.1,104.4 v2(156.31,104.61)
  BOTTOM w0.076: v2(168.72,79.12) 168.69,79.1 168.39,79.1 168.37,79.12 168.03,79.12 167.79,78.89 167.79,78.59 166.65,77.44 166.65,77.03 166.54,76.93 166.46,76.93 UC1.A13
  BOTTOM w0.094: JDOCK1.92 158,107.7 157.85,107.55 157.85,106.11 156.96,105.22 156.16,105.22 155.99,105.06 155.99,104.93 v2(156.31,104.61)
USB3_PTX_DRX_P3: length 183.6
  IN1 w0.112: v2(165.16,79.07) 164.78,79.07 164.68,79.18 164.68,79.51 164.23,79.96 164.23,83.9 161.33,86.8 159.27,86.8 157.92,88.15 149.28,88.15 147.83,89.6 144.22,89.6 143.37,88.75 140.76,88.75 139.03,90.49 136.61,90.49 134.96,92.14 134.96,93.03 133.2,94.79 122.39,94.79 122.03,94.43 111.81,94.43 111.11,95.13 107.08,95.13 106.92,95.29 104.69,95.29 101.56,98.41 96.35,98.41 95.56,97.62 92.45,97.62 91.76,98.31 80.15,98.31 79.92,98.08 67.88,98.08 66.45,96.65 59.52,96.65 59.07,96.2 54.68,96.2 47.31,88.83 41,88.83 39.37,90.46 34.71,90.46 34.02,91.15 31.07,91.15 30.16,92.05 26.88,92.05 24.78,89.95 21.61,89.95 20.58,88.92 20.58,84.7 21.09,84.18 21.09,76.79 21.22,76.66 21.22,74.96 v2(21.55,74.63)
  BOTTOM w0.076: v2(165.16,79.07) 165.16,79.15 164.88,79.44 164.8,79.44 164.74,79.38 164.74,77.53 164.55,77.34 164.55,76.93 164.64,76.84 164.88,76.84 164.94,76.9 164.94,77.09 UC1.A15
  BOTTOM w0.094: v2(21.55,74.63) 21.34,74.84 21.34,75.23 CI4.2
USB3_PTX_DRX_P4: length 124.2
  TOP w0.094: CI28.2 67.98,90.35 67.8,90.35 67.68,90.22 67.68,89.71 67.85,89.54 68.85,89.54 69.48,90.17 69.48,90.89 69.02,91.35 69.02,91.92 68.99,91.95 68.99,92.54 69.02,92.57 69.02,94.17 69.22,94.37 69.22,94.52 v2(68.73,95.01)
  IN1 w0.112: v2(166.39,78.95) 166.14,78.95 165.59,78.39 164.51,78.39 163.54,79.35 163.54,83.19 160.77,85.97 158.86,85.97 157.33,87.49 144.57,87.49 144.34,87.26 140.9,87.26 138.72,89.44 136.68,89.44 134.13,91.99 134.13,92.79 132.8,94.12 122.66,94.12 122.3,93.77 111.33,93.77 110.77,94.33 106.88,94.33 106.59,94.62 104,94.62 101.05,97.57 97.22,97.57 95.69,96.05 72.79,96.05 71.42,94.67 70.52,94.67 70.08,94.22 68.98,94.22 68.75,94.45 68.75,94.99 v2(68.73,95.01)
  BOTTOM w0.076: UC1.D15 164.99,75.38 165.09,75.54 165.14,75.69 165.17,75.8 165.17,75.92 165.21,76.08 165.23,76.12 165.25,76.2 165.29,76.35 165.31,76.4 165.31,76.64 165.27,76.73 165.27,76.92 165.31,77.01 165.31,77.02 165.31,77.8 165.7,78.19 165.7,78.66 166.08,79.05 166.29,79.05 v2(166.39,78.95)
USB3_PTX_DRX_P5: length 96.5
  TOP w0.094: CI30.2 236.47,73.1 236.47,73.48 235.7,74.25 235.7,74.46 235.77,74.53 v2(236.21,74.53)
  IN1 w0.112: v2(236.21,74.53) 236.21,74.65 236.53,74.98 236.53,76.81 235.39,77.95 235.39,79.22 229.63,84.98 229.63,85.53 228.15,87.01 224.33,87.01 223.08,85.75 223.08,84.09 222.1,83.11 213.22,83.11 212.81,83.52 211.06,83.52 209.71,84.87 209.71,84.87 209.56,85.02 205.24,85.02 205.08,85.17 204.94,85.31 203.74,85.31 203.59,85.16 198.84,85.16 197.29,85.16 197.09,85.37 189.04,85.37 188.88,85.52 182.84,85.52 181.16,87.2 175.38,87.2 173.72,85.54 172.48,85.54 171.65,84.71 171.65,83.82 171.65,83.72 171.06,83.13 171.06,80.83 170.32,80.09 167.42,80.09 166.43,81.08 v2(165.57,81.08)
  BOTTOM w0.076: UC1.A17 163.87,77.04 163.94,77.04 164.03,77.13 164.03,77.54 164.2,77.71 164.2,79.64 164.39,79.83 164.39,80.44 164.71,80.76 165.47,80.76 165.57,80.86 v2(165.57,81.08)
USB3_PTX_L_DRX_N1: length 6.8
  TOP w0.094: RI18.2 287.34,58.88 287.62,58.88 287.77,59.03 DI4.4 DI4.7 289.29,59.03 289.45,58.87 290.18,58.87 290.21,58.84 290.36,58.84 v4(291.34,57.86) 291.62,57.59 292.01,57.59 292.19,57.77 JUSB3.8
USB3_PTX_L_DRX_N3: length 16.6
  TOP w0.094: v2(17.05,82.41) 17.05,82.75 16.74,83.06 16.5,83.06 16.23,83.32 16.23,86.43 14.61,88.05 14.47,88.05 13.93,87.51 JUSB1.8
  BOTTOM w0.094: v2(17.05,82.41) 17.05,82.61 17.49,83.05 18.16,83.05 19.24,81.98 20.71,81.98 21.08,81.61 21.08,81.17 20.91,81 DI1.4 DI1.7 20.91,79.26 21.09,79.07 21.09,78.69 RI22.2
USB3_PTX_L_DRX_N4: length 10
  TOP w0.094: JUSB2.8 67.21,101.27 67.36,101.11 67.36,100.76 66.64,100.03 v4(66.64,97.91) 66.64,97.71 67.4,96.95 67.4,96.56 67.37,96.53 67.37,95.93 67.4,95.9 67.4,95.78 67.25,95.63 DI6.7 DI6.4 67.25,93.97 67.41,93.81 67.41,93.6 67.58,93.43 67.58,93.28 RI26.2
USB3_PTX_L_DRX_N5: length 4
  TOP w0.094: v2(235.88,69.3) 236.19,68.98 236.3,68.98 236.43,69.12 236.43,69.6 236,70.03 RI30.2
  BOTTOM w0.094: JNGFF2.27 235.63,69.05 v2(235.88,69.3)
USB3_PTX_L_DRX_P1: length 6.8
  TOP w0.094: JUSB3.9 292.19,57.21 292.01,57.39 291.54,57.39 291.44,57.5 291.39,57.5 290.97,57.91 290.97,57.96 290.28,58.65 v4(289.88,58.65) 289.41,58.65 289.29,58.53 DI4.6 DI4.5 287.79,58.53 287.64,58.69 287.31,58.69 RI17.2
USB3_PTX_L_DRX_P3: length 16.5
  TOP w0.094: v2(17.05,83.7) 17.05,83.44 16.86,83.25 16.58,83.25 16.42,83.4 16.42,86.51 14.69,88.24 14.52,88.24 13.93,88.83 JUSB1.9
  BOTTOM w0.094: v2(17.05,83.7) 17.5,83.25 18.24,83.25 19.32,82.17 20.79,82.17 21.27,81.69 21.27,81.17 21.41,81.03 DI1.5 DI1.6 21.41,79.2 21.29,79.08 21.29,78.78 RI21.2
USB3_PTX_L_DRX_P4: length 10
  TOP w0.094: RI25.2 67.6,93.68 67.6,93.81 67.75,93.95 DI6.5 DI6.6 67.75,95.58 67.59,95.74 v4(67.59,96.23) 67.59,97.03 66.86,97.76 66.86,98.23 66.83,98.26 66.83,99.95 67.56,100.68 67.56,101.06 67.77,101.27 JUSB2.9
USB3_PTX_L_DRX_P5: length 4
  TOP w0.094: RI29.2 236.63,69.84 236.63,69.04 236.38,68.79 235.95,68.79 v2(235.88,68.71)
  BOTTOM w0.094: v2(235.88,68.71) 235.83,68.76 234.9,68.76 234.69,68.55 JNGFF2.29
USB20_N1: length 147.2
  TOP w0.094: UI3.2 281.03,63.83 280.78,63.58 280.44,63.58 279.93,63.07 279.93,60.19 281.38,58.74 v4(281.38,58.26) 281.38,57.27 281.35,57.23 281.35,56.63 281.38,56.6 281.38,56.36 280.8,55.78 280.8,54.9 280.43,54.54 280.25,54.54 v2(280.02,54.77)
  IN1 w0.076: 169.9,65.18 169.88,65.18 169.86,65.17 169.65,65.17 169.58,65.1 168.88,65.1 168.74,65.24 168.74,65.49 168.78,65.52 v2(168.98,65.52)
  IN1 w0.112: 169.9,65.18 170.1,65.18 170.31,65.39 175.42,65.39 175.42,65.39 175.67,65.39 176.02,65.04 177.67,65.04 177.71,65.09 178.58,65.09 180.66,63.01 180.98,63.01 181.68,63.72 183.14,63.72 184.32,62.54 184.32,59.05 185.49,57.88 191.42,57.88 192.42,56.89 193.56,56.89 195.49,54.96 195.49,53.58 197.76,51.3 203.19,51.3 203.28,51.4 204.4,51.4 205.94,52.94 207.44,52.94 210.58,49.81 214.33,49.81 215.28,48.86 215.51,48.62 216.09,48.62 216.62,48.09 218.88,48.09 218.92,48.13 218.93,48.13 219.33,48.54 220.93,48.54 221.29,48.89 223.84,48.89 224.78,47.96 224.78,47.19 225.21,46.76 227.37,46.76 228.31,47.7 228.31,50.07 229.53,51.29 232.13,51.29 232.13,51.29 232.46,51.29 236.13,54.96 240.01,54.96 241.67,56.63 242.51,56.63 243.42,55.72 243.77,55.72 245.01,54.48 250.38,54.48 251.27,55.37 251.39,55.37 257.09,55.37 257.83,55.37 258.16,55.04 261.62,55.04 261.9,54.75 263.85,54.75 264.57,54.02 266.93,54.02 267.65,53.3 271.27,53.3 271.36,53.39 272.02,54.06 273.62,54.06 274.67,53.01 277.14,53.01 278.29,54.16 279.11,54.16 279.51,54.56 279.81,54.56 v2(280.02,54.77)
  BOTTOM w0.076: UC1.AB9 v2(168.98,65.52)
USB20_N1_R: length 18.3
  BOTTOM w0.094: JUSB3.2 290.69,59.91 290.45,60.15 290.02,60.15 289.73,60.44 289.73,64.53 288.86,65.4 288.03,65.4 v4(286.58,63.95) 286.33,63.69 285.29,63.69 284.91,63.31 283.69,63.31 283.34,63.66 283.34,63.97 283.21,64.1 282.74,64.1 DI5.2 283.07,64.49 283.26,64.68 283.26,65.11 283.82,65.68 284.06,65.68 284.13,65.74 284.13,66.02 284.06,66.08 LI7.2
USB20_N2: length 105
  IN1 w0.076: 160.1,64.38 160.12,64.39 160.12,64.45 160.44,64.77 160.44,65.1 160.74,65.4 160.98,65.4 161.45,64.93 163.84,64.93 164,64.76 164.69,64.76 165.39,64.06 167.76,64.06 168.04,63.79 168.72,63.79 168.84,63.91 169.24,63.91 169.34,63.81 170.39,63.81 170.6,64.02 170.6,64.27 170.84,64.51 v2(170.89,64.51)
  IN1 w0.112: 160.1,64.38 159.75,64.02 157.73,64.02 157.02,63.31 146.96,63.31 146.79,63.48 146.4,63.48 145.87,64.02 145.87,65.13 145.56,65.43 145.2,65.43 144.65,65.98 139.27,65.98 138.17,67.09 131.99,67.09 131.38,67.7 131.38,69.99 132.48,71.08 132.48,75.26 132.66,75.44 132.66,76.51 132.88,76.74 132.88,77.7 126.44,84.14 123.89,84.14 120.8,87.23 119.65,87.23 118.69,88.19 117.49,88.19 116.58,89.09 114.63,89.09 114.43,88.89 114.43,87.86 114.01,87.44 107.61,87.44 105.34,85.17 102.69,85.17 102.05,85.81 99.04,85.81 97.48,84.25 96.59,84.25 95.59,83.25 93.92,83.25 93.37,82.71 93.37,82.28 v2(93.56,82.1)
  BOTTOM w0.076: v2(170.89,64.51) 170.63,64.77 UC1.AD6
  BOTTOM w0.094: v2(93.56,82.1) 93.33,82.33 93.33,82.45 93.48,82.6 LZ1.1
USB20_N2_R: length 3.9
  BOTTOM w0.094: JEDP1.12 91.75,85.77 91.6,85.62 91.6,85.21 91.98,84.83 93.13,84.83 93.35,84.62 93.35,84.42 93.48,84.28 LZ1.2
USB20_N3: length 205.5
  IN1 w0.076: 159.79,61.9 159.79,62.01 159.75,62.05 159.75,62.3 160.72,63.26 162.46,63.26 163.39,62.33 164.59,62.33 164.65,62.39 165.17,62.39 165.34,62.56 166.03,62.56 166.24,62.78 167.12,62.78 167.84,62.05 167.84,61.52 168.49,60.87 168.49,60.42 168.88,60.04 169.77,60.04 170.13,60.4 170.56,60.4 170.96,60.01 173.6,60.01 173.97,60.38 174.72,60.38 174.94,60.16 175.79,60.16 176.21,60.59 176.21,61.07 v2(176.29,61.14)
  IN1 w0.112: v2(23.51,84.81) 23.76,85.07 25.18,85.07 27.64,87.53 27.64,88.22 28.2,88.78 29.91,88.78 31.48,87.21 33.95,87.21 35.19,88.45 38.26,88.45 40.79,85.91 47.51,85.91 53.04,91.44 57.05,91.44 57.59,91.98 58.98,91.98 60.38,90.59 64.17,90.59 65.27,89.49 66.01,89.49 67.23,88.27 67.23,85.25 68.47,84 74.74,84 76.93,86.19 83.24,86.19 84.19,85.25 84.19,84.95 85.52,83.62 89.01,83.62 90.87,81.76 90.87,80.73 91.27,80.32 93.62,80.32 96.84,83.54 97.75,83.54 99.35,85.14 101.78,85.14 102.41,84.51 105.69,84.51 107.96,86.78 115.19,86.78 116.15,85.82 118.5,85.82 119.42,84.89 119.42,78.06 121.58,75.9 128.7,75.9 130.62,73.98 130.62,73.19 130.62,73.19 130.62,71.55 130.59,71.52 130.06,70.99 130.06,70.54 130.06,69.23 130.06,69.23 130.06,67.15 130.59,66.61 132.76,64.45 132.96,64.45 137.5,64.45 138.87,63.07 139.19,62.76 139.19,61.97 139.59,61.56 153.17,61.56 153.49,61.24 154.88,61.24 155.06,61.43 159.61,61.43 159.69,61.51 159.69,61.51 159.79,61.61 159.79,61.9
  BOTTOM w0.076: v2(176.29,61.14) 175.97,61.46 175.97,61.46 175.65,61.78 174.76,61.78 174.46,62.08 173.65,62.08 173.56,62.17 173.27,62.17 173.11,62.1 173.1,62.1 172.98,62.1 172.76,62.16 172.62,62.16 172.45,62.1 172.33,62.11 172.04,62.17 171.93,62.17 UC1.AH3
  BOTTOM w0.094: LI3.1 24.6,84.28 24.68,84.2 24.68,84.08 24.78,83.97 24.87,83.97 24.99,84.09 24.99,84.53 24.14,85.38 23.88,85.38 23.79,85.29 23.79,84.89 23.71,84.81 v2(23.51,84.81)
USB20_N3_R: length 9.8
  BOTTOM w0.094: LI3.2 22.46,84.28 22.29,84.1 22.05,84.1 21.78,84.38 21.16,84.38 21.07,84.47 DI2.2 20.47,84.65 20.26,84.65 19.69,85.22 v4(17.04,85.22) 15.74,85.22 15.43,85.53 JUSB1.2
USB20_N4: length 123.7
  IN1 w0.076: 159.54,65.15 159.55,65.17 159.61,65.17 159.73,65.29 159.73,65.85 160.37,66.49 160.96,66.49 161.28,66.82 165.14,66.82 165.51,66.46 165.51,66.33 166.79,65.05 168.02,65.05 168.02,65.05 168.29,65.05 v2(168.87,64.47)
  IN1 w0.112: v2(74.48,86.23) 74.52,86.19 74.98,86.19 77.79,89 79.57,89 80.81,90.24 89.17,90.24 90.1,89.31 90.1,87.28 90.33,87.04 97.74,87.04 102.32,91.62 105.34,91.62 105.64,91.33 106.96,90.01 116.96,90.01 117.87,89.1 119.06,89.1 120,88.16 121.18,88.16 124.23,85.11 124.33,85.11 126.75,85.11 133.65,78.22 133.79,78.07 133.79,77.11 133.79,76.16 133.58,75.95 133.58,75.08 133.58,74.87 133.39,74.68 133.39,70.7 132.54,69.86 132.54,69.14 132.96,68.73 137.99,68.73 139.64,67.08 145.83,67.08 146.72,66.19 146.72,65.03 146.95,64.8 147.38,64.8 147.56,64.62 156.8,64.62 157.16,64.98 159.36,64.98 159.54,65.15
  BOTTOM w0.076: UC1.AD9 168.67,64.67 v2(168.87,64.47)
  BOTTOM w0.094: v2(74.48,86.23) 74.2,85.95 73.58,85.95 73.42,86.11 LI4.1
USB20_N4_R: length 19.7
  BOTTOM w0.094: JUSB2.2 64.52,98.84 64.52,98.57 64.97,98.11 65.79,98.11 v4(66.5,97.39) 67.55,96.35 67.59,96.35 68.01,95.93 68.01,95.89 68.25,95.65 68.25,94.82 69,94.07 69,93.02 71.03,90.99 71.03,90.07 71.91,89.2 71.91,88.76 72.1,88.57 DI3.2 71.48,87.32 71.48,86.93 71.3,86.75 71.3,86.14 71.48,85.96 71.55,85.96 71.7,86.11 LI4.2
USB20_N5: length 71.7
  IN2 w0.122: v2(174.87,61.11) 174.84,61.14 174.84,61.38 175.07,61.61 176.03,61.61 176.95,62.53 176.95,64.39 178.19,65.62 178.19,68.27 177.71,68.75 176.39,68.75 176.06,69.08 176.06,73.14 175.96,73.24 175.96,75.08 176.44,75.56 176.44,77.66 176.79,78 176.79,78.43 176.53,78.69 176.22,78.69 176.1,78.81 176.1,79.94 176.52,80.37 176.52,81.91 175.75,82.68 175.75,85.27 175.22,85.8 174.35,86.67 174.06,86.67 170.68,86.67 170.54,86.81 167.75,86.81 165.53,89.02 165.53,89.98 165.4,90.11 165.04,90.47 164.6,90.47 164.48,90.59 164.48,91.03 164.21,91.29 163.77,91.29 163.51,91.03 163.51,90.66 163.38,90.53 163.18,90.53 163.05,90.66 163.05,92.17 156.3,98.92 156.3,100.55 156.42,100.68 157,100.68 157.26,100.93 157.26,101.37 157,101.63 156.42,101.63 156.3,101.75 156.3,102.29 155.94,102.64 155.94,102.8 156.3,103.15 v2(156.3,103.18)
  BOTTOM w0.076: UC1.AJ1 173.42,61.65 174.33,61.65 v2(174.87,61.11)
  BOTTOM w0.094: JDOCK1.74 153.5,107.82 153.34,107.66 153.34,106.92 153.88,106.37 153.88,105.36 155.13,104.12 155.53,104.12 156.03,103.61 156.03,103.44 v2(156.3,103.18)
USB20_N6: length 73.1
  IN2 w0.122: v2(171,63.44) 170.87,63.44 170.76,63.55 170.76,63.76 170.85,63.86 171.57,63.86 171.66,63.95 172.13,63.95 172.79,63.29 172.79,62.6 173.31,62.08 174.3,62.08 174.48,62.27 175.76,62.27 176.28,62.79 176.28,67.16 175.08,68.36 175.08,69.72 175.22,69.86 175.22,69.86 175.35,69.99 175.35,71.67 174.76,72.26 174.76,73.78 174.87,73.89 174.87,75.07 175.35,75.56 175.35,82.13 175.09,82.4 175.09,85 174.59,85.5 167.45,85.5 167.02,85.93 167.02,86.61 164.21,89.41 162.57,89.41 162.34,89.64 162.34,91.94 156.25,98.03 155.37,98.03 154.8,98.6 154.8,99.83 155.61,100.64 155.61,101.24 155.35,101.5 154.27,101.5 154.01,101.75 154.01,102.72 v2(154.25,102.95)
  BOTTOM w0.076: UC1.AF6 170.63,63.81 v2(171,63.44)
  BOTTOM w0.094: JDOCK1.68 152,107.85 151.82,107.67 151.82,105.95 152.17,105.6 152.17,104.05 152.3,103.92 153.83,103.92 154.06,103.7 154.06,103.15 v2(154.25,102.95)
USB20_N7: length 129.1
  TOP w0.094: JUSH1.19 268.96,8.03 268.94,8.01 268.94,7.84 267.45,6.35 266.69,6.35 v2(266.66,6.33)
  IN4 w0.112: v2(266.66,6.33) 266.17,6.33 265.39,6.47 264.98,6.47 263.66,7 263.66,7 263.56,7.02 259.98,7.02 255.83,7.02 254.63,5.81 253.76,5.81 252.92,6.65 252.78,6.8 252.78,7.23 247.85,12.16 244.16,12.16 243.04,13.28 243.04,13.84 243.04,13.84 243.04,14.16 242.81,14.39 242.37,14.39 241.54,15.23 241.09,15.23 240.3,16.02 235.74,16.02 235.6,16.16 235.6,16.17 232.19,19.57 231.25,19.57 229.55,21.28 229.55,22.49 227.84,24.2 227.84,25.15 226.45,26.55 226.45,27.16 223.07,30.53 223.07,31.75 222.01,32.82 220.56,32.82 219.13,34.25 218.65,34.25 217.83,35.06 217.83,36.04 216.31,37.56 216.31,37.91 215.07,39.15 214.4,39.15 212.32,41.23 212.01,41.23 209.34,43.9 208.93,43.9 206.8,46.02 206.45,46.02 202.94,49.53 200.19,49.53 199.86,49.21 194.44,49.21 192.79,50.86 191.62,50.86 190.52,51.96 189.46,51.96 188.75,52.68 188.75,53.82 188.51,54.05 188.51,55.84 186.91,57.45 180.93,57.45 179.85,58.53 179.21,58.53 177.21,60.53 177.21,60.94 v2(176.99,61.17)
  BOTTOM w0.076: v2(176.99,61.17) 176.99,61.38 177.09,61.49 177.34,61.49 177.4,61.56 177.4,61.64 176.86,62.18 174.9,62.18 174.6,62.48 174.42,62.48 174.34,62.4 174.34,62.32 174.27,62.25 174.12,62.25 174.04,62.32 174.04,62.4 173.96,62.48 173.79,62.48 173.64,62.34 173.46,62.34 173.32,62.48 173.13,62.48 UC1.AH1
USB20_N8: length 141.9
  IN1 w0.076: 176.62,64.4 175.24,64.4 175.12,64.28 173.21,64.28 172,63.06 170.82,63.06 170.7,62.95 169.51,62.95 169.38,63.07 169.38,63.18 v2(169.61,63.41)
  IN1 w0.112: 176.62,64.4 178.31,64.4 179.75,62.96 179.75,59.29 180.48,58.56 181.59,58.56 183,57.15 191.02,57.15 192.24,55.92 193.59,55.92 194.76,54.75 194.76,52.51 195.54,51.73 195.54,50.91 195.9,50.55 197.42,50.55 197.48,50.61 198.31,50.61 199.06,49.86 204.2,49.86 206.15,51.81 207.63,51.81 210.3,49.14 214.06,49.14 215.24,47.96 215.81,47.96 216.35,47.42 219.16,47.42 219.61,47.87 221.21,47.87 221.45,48.11 222.52,48.11 222.82,48.11 225.04,45.89 227.98,45.89 228.98,46.89 228.98,49.49 230.03,50.55 232.66,50.55 235.53,53.41 239.18,53.41 239.5,53.09 239.5,52.64 v2(239.69,52.45)
  BOTTOM w0.076: v2(169.61,63.41) 169.34,63.85 UC1.AF8
  BOTTOM w0.094: v2(239.69,52.45) 239.69,52.13 239.96,51.85 241.7,50.11 241.7,45.93 241.91,45.71 241.91,42.9 241.82,42.81 241.82,42.1 241.28,41.56 241.28,39.62 242.11,38.8 242.11,34.22 239.81,31.93 239.32,31.93 239.32,31.93 238.96,31.93 237.27,30.24 237.27,29.8 235.88,28.41 234.93,28.41 234.03,27.51 234.03,25.18 234.39,24.82 234.39,23.36 235.55,22.2 235.55,20.72 238.34,17.93 243.22,17.93 244.51,16.64 244.51,15.98 244.7,15.79 JNGFF1.5
USB20_N9: length 86.9
  IN1 w0.076: v2(173.9,63.05) 173.9,62.89 174.02,62.77 174.23,62.77 174.34,62.67 174.34,62.53 172.63,60.83 171.37,60.83 171.03,61.17 169.48,61.17 168.56,62.09 168.56,62.5 167.38,63.67 164.74,63.67 164.48,63.41 163.36,63.41 162.8,63.97 160.39,63.97 159.85,63.43 159.75,63.43 159.71,63.47 159.7,63.47
  IN1 w0.112: 159.7,63.47 159.39,63.47 158.13,62.21 155.46,62.21 154.76,62.91 150.63,62.91 150.13,62.41 146.71,62.41 146.54,62.58 145.3,62.58 145.2,62.58 144.82,62.96 140.97,62.96 138.61,65.32 138.61,66 137.94,66.67 131.82,66.67 130.97,67.52 130.97,69.61 130.97,70.62 131.53,71.17 131.53,71.45 131.53,71.46 131.53,71.74 131.53,71.74 131.53,73.57 131.53,73.67 131.53,74.32 131.53,74.37 130.74,75.15 130.74,76.54 130.74,76.84 128.4,79.18 128.4,81.59 126.47,83.52 123.17,83.52 119.92,86.77 116.64,86.77 115.73,87.68 115.73,87.99 115.8,88.07 116.06,88.07 116.16,88.16 v2(116.16,88.42)
  BOTTOM w0.076: UC1.AG1 173.44,62.95 173.44,62.87 173.38,62.81 173.11,62.81 173.01,62.91 173.01,63.15 173.14,63.27 173.38,63.34 173.81,63.34 173.9,63.25 v2(173.9,63.05)
  BOTTOM w0.094: LV27.2 114.64,87.74 114.8,87.9 114.99,87.9 115.21,87.68 115.74,87.68 116.05,87.99 116.05,88.31 v2(116.16,88.42)
USB20_N9_R: length 24.4
  BOTTOM w0.094: JEDP1.2 96.75,86.98 96.44,87.29 96.44,87.75 98.11,89.41 98.11,89.82 98.56,90.28 98.94,90.28 101.41,92.74 102.38,92.74 102.41,92.76 v4(102.66,92.76) 103.98,92.76 104.01,92.73 104.6,92.73 104.64,92.76 105.94,92.76 108.71,90 109.36,90 109.64,89.71 DV4.2 109.87,89.23 109.87,89.69 109.95,89.78 110.19,89.78 110.62,89.35 110.62,88.4 111.12,87.9 112.63,87.9 112.79,87.74 LV27.1
USB20_N10: length 128
  IN1 w0.076: v2(170.25,62.32) 170.25,62.1 170.19,62.04 169.87,62.04 169.78,61.95 169.78,61.78 169.84,61.72 171.55,61.72 173.55,63.72 174.75,63.72 175.19,63.28 175.19,62.87 175.52,62.54 177.76,62.54 177.8,62.58 177.82,62.58
  IN1 w0.112: v2(241.8,55.61) 242.03,55.37 242.03,55 241.96,54.92 241.96,53.94 241.14,53.12 241.14,52.19 240.33,51.38 239.2,51.38 237.88,52.71 235.78,52.71 232.96,49.89 230.35,49.89 229.69,49.22 229.69,46.66 228.2,45.18 224.76,45.18 222.98,46.96 221.37,46.96 221.13,47.21 219.88,47.21 219.43,46.76 216.07,46.76 215.54,47.29 214.97,47.29 214.26,48 209.71,48 209.11,48.61 208.39,48.61 207.91,49.09 207.91,50.45 207.23,51.13 206.44,51.13 205.45,50.14 205.45,48.73 205.24,48.51 204.17,48.51 203.78,48.12 200.04,48.12 199.49,48.67 195.33,48.67 192.65,51.35 192.65,51.85 191.74,52.76 191.74,55.23 191.37,55.59 189.53,55.59 189.06,55.13 187.48,55.13 186.13,56.48 182.5,56.48 181.13,57.85 180.11,57.85 179.06,58.91 179.06,61.93 178.41,62.58 177.82,62.58
  BOTTOM w0.076: UC1.AH7 170.16,62.78 170.32,62.62 170.32,62.39 v2(170.25,62.32)
  BOTTOM w0.094: v2(241.8,55.61) 241.8,55.8 241.88,55.88 242.16,55.88 242.24,55.96 242.24,56.3 241.58,56.96 238.62,56.96 237.87,57.71 237.87,58.94 238.55,59.62 238.55,60.76 239.52,61.73 239.52,72.26 236.02,75.75 234.94,75.75 234.73,75.55 JNGFF2.9
USB20_P1: length 147.2
  TOP w0.094: v2(280,54.13) 280.21,54.34 280.51,54.34 280.99,54.82 280.99,55.7 281.57,56.28 v4(281.57,56.94) 281.57,57.93 281.6,57.96 281.6,58.55 281.57,58.59 281.57,58.82 280.12,60.27 280.12,62.99 280.52,63.39 280.78,63.39 280.84,63.33 UI3.3
  IN1 w0.076: v2(168.34,65.52) 168.34,65.51 168.58,65.27 168.58,65.17 168.81,64.94 169.65,64.94 169.71,65 169.87,65 169.89,64.98 169.9,64.98
  IN1 w0.112: 169.9,64.98 170.19,64.98 170.4,65.19 175.5,65.19 175.58,65.19 175.94,64.84 178.48,64.84 180.55,62.77 181.08,62.77 181.79,63.47 183.04,63.47 184.07,62.44 184.07,58.95 185.38,57.64 191.32,57.64 192.32,56.64 193.46,56.64 195.24,54.86 195.24,53.47 197.66,51.06 203.29,51.06 203.38,51.15 204.5,51.15 206.04,52.69 207.34,52.69 210.47,49.56 214.23,49.56 215.03,48.76 215.41,48.37 215.99,48.37 216.52,47.84 218.98,47.84 219.02,47.89 219.03,47.89 219.43,48.29 221.04,48.29 221.39,48.64 223.74,48.64 224.53,47.86 224.53,47.09 225.11,46.51 227.47,46.51 228.56,47.6 228.56,49.97 229.64,51.04 232.02,51.04 232.56,51.04 236.24,54.71 240.11,54.71 241.78,56.38 242.41,56.38 243.31,55.47 243.66,55.47 244.9,54.23 250.48,54.23 251.37,55.12 251.49,55.12 257.19,55.12 257.73,55.12 258.06,54.79 261.51,54.79 261.8,54.5 263.75,54.5 264.47,53.78 266.83,53.78 267.55,53.05 271.37,53.05 271.46,53.15 272.12,53.81 273.52,53.81 274.57,52.76 277.24,52.76 278.39,53.91 279.21,53.91 279.61,54.31 279.82,54.31 v2(280,54.13)
  BOTTOM w0.076: UC1.AB10 v2(168.34,65.52)
USB20_P1_R: length 18.3
  BOTTOM w0.094: LI7.3 284.56,66.13 284.32,65.89 284.32,65.66 284.14,65.48 283.9,65.48 283.45,65.03 283.45,64.67 283.62,64.49 DI5.3 283.86,64.07 283.63,64.07 283.53,63.98 283.53,63.74 283.77,63.5 284.83,63.5 285.21,63.88 286.2,63.88 286.63,64.31 286.68,64.31 287.99,65.62 v4(288.42,65.62) 288.91,65.62 289.92,64.61 289.92,60.52 290.1,60.34 290.5,60.34 290.69,60.53 JUSB3.3
USB20_P2: length 105
  IN1 w0.076: v2(170.24,64.37) 170.31,64.37 170.44,64.24 170.44,64.09 170.32,63.97 169.41,63.97 169.31,64.07 168.77,64.07 168.65,63.95 168.11,63.95 167.83,64.23 165.46,64.23 164.76,64.93 164.07,64.93 163.9,65.09 161.52,65.09 161.05,65.56 160.67,65.56 160.27,65.17 160.27,64.84 160,64.57 159.94,64.57 159.93,64.55
  IN1 w0.112: v2(92.92,82.1) 93.13,82.3 93.13,82.81 93.81,83.49 95.49,83.49 96.49,84.49 97.38,84.49 98.94,86.05 102.15,86.05 102.79,85.42 105.24,85.42 107.5,87.68 113.9,87.68 114.18,87.96 114.18,88.99 114.53,89.34 116.69,89.34 117.6,88.43 118.79,88.43 119.75,87.47 120.9,87.47 123.99,84.38 126.55,84.38 133.13,77.8 133.13,76.63 132.9,76.41 132.9,75.34 132.72,75.16 132.72,70.98 131.63,69.88 131.63,67.8 132.09,67.33 138.27,67.33 139.37,66.23 144.75,66.23 145.3,65.68 145.66,65.68 146.11,65.23 146.11,64.12 146.5,63.73 146.89,63.73 147.06,63.56 156.92,63.56 157.63,64.27 159.64,64.27 159.93,64.55
  BOTTOM w0.076: UC1.AD7 170.24,64.64 v2(170.24,64.37)
  BOTTOM w0.094: v2(92.92,82.1) 93.14,82.31 93.14,82.44 92.98,82.6 LZ1.4
