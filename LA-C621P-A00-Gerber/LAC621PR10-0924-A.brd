# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCD_CBL_DET#: length 176
  IN2 w0.122: v2(181.37,64.16) 181.39,64.16 183.32,66.09 184.76,66.09 185.66,67 186.4,67 186.73,67.32 186.73,68.6 183.68,71.65 182.17,71.65 181.22,72.6 181.22,75.29 179.84,76.67 179.84,82.9 177.89,84.85 177.89,85.7 175.92,87.68 173.65,87.68 173.64,87.68 172.53,87.68 171.09,87.68 170.84,87.93 170.52,88.26 167.88,88.26 166.93,89.21 166.93,90.3 161.87,95.36 161.45,95.36 158.11,98.71 158.11,99.26 157.69,99.68 157.69,102.04 157.98,102.34 157.98,102.99 157.41,103.57 157.41,105.8 156.78,106.43 154.31,106.43 152.08,104.2 152.08,104.07 151.11,103.1 148.1,103.1 147.98,102.98 147.94,102.98 145.96,101.01 145.96,99.01 140.07,93.12 136.61,93.12 134.64,91.14 132.73,91.14 131.91,90.33 130.67,90.33 129.63,89.28 122.33,89.28 119.77,86.72 114.69,86.72 114.39,87.02 107.24,87.02 105.93,85.71 105.81,85.71 105.52,85.42 105.52,85.42 105.28,85.17 102.19,85.17 101.39,85.97 97.09,85.97 96.81,85.69 96.71,85.69 96.71,85.69 96.51,85.69 96.5,85.69 94.2,85.69 93.66,85.15 93.66,85.09 92.25,83.68 85.46,83.68 84.65,84.48 83.41,84.48 82.6,83.68 78.62,83.68 77.55,84.75 77.55,85.84 79.12,87.41 79.12,87.93 v2(78.7,88.35)
  BOTTOM w0.076: 177.78,62.88 176.49,62.88 176.06,63.31 176.06,63.82 175.81,64.07 175.81,64.38 175.12,65.07 173.49,65.07 173.18,64.76 172,64.76 UC1.AC3
  BOTTOM w0.102: RC287.1 181.57,64.37 v2(181.37,64.16) 181.58,63.96 v3(181.58,63.62) 181.58,63.39 181.36,63.17 180.55,63.17 180.26,62.88 178.07,62.88 178.07,62.88 177.78,62.88 ; v2(78.7,88.35) 77.75,87.39 JEDP1.40
LCD_TST: length 254.2
  TOP w0.102: RE20.2 245.91,72.8 246.53,73.42 246.53,74.7 246.98,75.14 246.98,75.68 246.98,75.87 247.47,76.36 247.48,76.36 v2(247.64,76.51) 247.64,76.69 247.39,76.93 UE1.A36
  IN2 w0.122: v2(258.91,72.37) 258.91,75.47 257.82,76.56 257.82,77.62 258.26,78.06 259.66,78.06 261.56,79.96 261.71,80.11 261.71,81.12 260.92,81.9 260.92,83.14 260.04,84.03 259.62,84.03 259.18,84.03 258,85.21 258,87.25 257.11,88.14 256.9,88.34 256.9,90.15 253.27,93.78 248.42,93.78 244.35,97.84 244.35,101.58 244.06,101.88 241.98,101.88 240.6,100.5 238.17,100.5 236.79,101.88 235.01,101.88 232.57,99.44 225.12,99.44 224.53,100.02 218.34,100.02 214.81,100.02 213.76,101.07 208.55,101.07 201.71,94.24 192.8,94.24 187.29,99.75 184.52,99.75 179.28,104.98 179.28,107.17 178.47,107.98 178.47,109.18 177.66,109.98 172.37,109.98 171.63,109.98 170.62,108.97 160.67,108.97 159.97,109.66 157.91,109.66 157.46,109.21 155.81,109.21 148.46,109.21 148.01,109.66 146.76,109.66 143.65,106.55 143.65,104.88 143.65,104.17 140.33,100.85 139.97,100.85 139.83,100.85 139.59,100.85 137.93,99.19 137.93,98.12 135.93,96.12 128.59,96.12 125.4,92.93 125.4,92.74 125.09,92.43 110.25,92.43 109.89,92.8 107.16,92.8 106.56,93.2 106.29,93.31 106.19,93.35 106.1,93.39 105.92,93.46 105.91,93.46 105.76,93.53 105.49,93.66 105.28,93.66 105.24,93.67 104.88,93.74 104.53,93.81 103.65,93.81 101.64,93.81 101.64,93.81 101.42,94.03 95.38,94.03 92.7,91.35 85.18,91.35 82.64,88.81 v2(82.64,88.09)
  IN4 w0.089: v2(247.64,76.51) 251.49,72.65 252.41,72.65 252.61,72.46 252.62,72.46 253.71,71.36 257.91,71.36 v2(258.91,72.37)
  BOTTOM w0.102: v2(82.64,88.09) 83.02,87.71 83.02,87.71 83.07,87.66 83.07,87.38 83.25,87.2 JEDP1.29
LCD_VCC_TEST_EN: length 207.1
  TOP w0.102: v2(247.28,73.82) 247.51,74.04 248.14,74.04 v3(249.85,75.75) 249.85,76.31 249.39,76.76 UE1.A40 ; v2(99.2,79.12) 99.2,79.21 101.74,81.75 101.74,84.17 101.92,84.34 105.68,84.34 106.91,85.58 109.93,85.58 110.35,85.16 113.68,85.16 114.37,84.47 114.98,84.47 115.21,84.7 115.21,85.41 114.93,85.69 114.54,85.69 113.76,86.48 v2(113.76,88.73)
  IN3 w0.122: v2(247.28,73.82) 247.11,73.98 246.7,73.98 246.67,74.01 245.72,74.01 245.33,74.4 245.33,74.67 245.14,74.86 245.14,75.83 245.14,76.03 244.68,76.49 243.76,77.42 243.76,77.63 243.76,77.63 243.76,78.5 244.05,78.8 244.05,82 244.53,82.48 244.53,87.01 244.61,87.09 244.61,88.24 245.55,89.18 245.55,91.58 244.42,92.71 244.42,96.16 243.07,97.51 232.02,97.51 231.88,97.66 229.78,97.66 229.33,98.11 228.61,98.84 228.26,98.84 227,100.1 224.95,100.1 224.34,100.7 217.59,100.7 216.73,99.84 211.82,99.84 210.73,98.74 210.43,98.74 205.73,94.05 205.73,92.21 205.54,92.01 205.53,92.01 204.84,91.32 203.14,91.32 202.32,90.5 188.91,90.5 184.89,94.53 179.17,94.53 177.9,93.26 177.9,92.5 177.9,92.32 176.83,91.25 174.2,91.25 173.12,92.32 173.12,94.75 170.53,97.34 158.63,97.34 158.02,97.96 144.56,97.96 142.04,95.44 127.09,95.44 126.87,95.22 122.96,95.22 120.58,92.83 119.46,92.83 116.66,90.02 114.64,90.02 113.76,89.14 v2(113.76,88.73)
  BOTTOM w0.102: v2(99.2,79.12) 99.2,78.61 DV3.2
LED_10_GRN#: length 13.6
  BOTTOM w0.102: QL2.6 281.69,80.31 282.16,80.78 282.16,81.05 282.87,81.76 282.87,83.88 283.97,84.98 v3(283.98,84.98) 285.62,86.62 285.62,89.29 286.35,90.02 RL19.1
LED_10_GRN_R#: length 9.7
  BOTTOM w0.102: RL19.2 286.27,92.21 284.53,93.96 v3(284.53,94.35) 284.53,94.65 280.71,98.47 JLOM1.11
LED_100_ORG#: length 16.5
  BOTTOM w0.102: QL1.3 281.03,78.06 281.6,78.63 281.6,79.89 282.41,80.71 282.41,80.98 283.11,81.68 283.11,83.8 283.91,84.6 284.5,84.6 v3(285.57,85.67) 285.87,85.96 285.87,89.17 287.24,90.54 RL20.1
LED_100_ORG_R#: length 8.7
  BOTTOM w0.102: JLOM1.13 281.97,97.54 284.93,94.58 284.93,94.12 v3(285.91,93.15) 286.4,92.65 286.8,92.65 RL20.2
LED_SATA_DIAG_OUT#: length 55.8
  TOP w0.102: v2(248.58,88.81) 248.58,88.81 248.58,88.8 248.89,88.49 UE1.A10
  IN1 w0.089: v2(283.15,72.86) 282.68,73.33 278.8,73.33 278.68,73.21 276.94,73.21 276.64,73.51 275.23,73.51 275.11,73.63 274.28,73.63 272.24,75.67 269.91,75.67 264.14,81.44 264.14,82.2 262.67,83.68 261.85,83.68 261.18,84.35 260.03,84.35 258.5,85.88 258.5,86.49 258.06,86.93 255.75,86.93 254.67,85.85 254.67,85.18 253.58,84.08 251.18,84.08 249.67,85.59 249.67,87.71 248.58,88.8 248.58,88.81 v2(248.58,88.81)
  BOTTOM w0.102: v1(252.48,93.54) 252.39,93.45 252.39,90.75 251.91,90.27 250.13,90.27 249.6,89.74 249.39,89.74 248.58,88.93 v2(248.58,88.81) ; v2(283.15,72.86) 282.74,72.45 DZ4.1
LID_CL#: length 109.8
  TOP w0.102: JLED1.7 281.65,9.96 v2(281.16,10.44) ; v2(286.74,67.88) 288.16,66.45 UZ10.2 ; RE26.1 257.69,74.98 v2(257.85,74.83)
  IN1 w0.089: v2(286.74,67.88) 286.65,67.8 283.5,67.8 283.07,68.23 283.07,69.51 283.86,70.3 283.86,71 283.56,71.3 277.33,71.3 276.61,70.59 272.67,70.59 272.21,71.05 270.5,71.05 268.19,73.36 266.82,73.36 265.4,74.78 257.9,74.78 v2(257.85,74.83)
  IN2 w0.122: v2(281.16,10.44) 281.16,10.71 277.3,14.57 277.3,17.7 272.21,22.79 272.21,25.45 272.93,26.18 272.93,27.77 274,28.84 274,31.42 275.68,33.11 275.68,35.87 275.48,36.07 275.48,36.94 275.56,37.02 275.56,40.33 275.48,40.41 275.48,42.66 275.88,43.06 275.88,43.97 278.43,46.52 278.43,50.57 279.4,51.54 279.4,51.54 279.66,51.79 280.56,51.79 281.68,52.91 282.07,53.3 282.07,58.87 281.95,59 281.95,61.35 284.51,63.91 286.27,63.91 286.73,64.37 286.73,66.12 286.49,66.36 286.49,67.63 v2(286.74,67.88)
LID_CL_SIO#: length 10.3
  TOP w0.102: UE1.B54 253.12,79.63 v2(252.8,79.95) ; RE25.2 RE26.2 CE8.1 v2(256.17,77.07) 255.73,77.07 255.54,76.88 v3(255.54,76.09)
  BOTTOM w0.102: v2(252.8,79.95) 253.23,79.95 256.12,77.07 v2(256.17,77.07)
LOM_ACTLED_YEL#: length 22.1
  TOP w0.102: v3(267.73,73.32) 272.01,73.32 v2(272.15,73.46) 272.15,75.04 272.84,75.72 UL4.15 ; UL1.26 267.48,85.13 267.77,84.84 v2(267.77,83.68)
  IN2 w0.122: v2(272.15,73.46) 272.05,73.36 271.55,73.36 269.27,75.64 269.27,81.87 267.77,83.37 v2(267.77,83.68)
LOM_SPD10LED_GRN#: length 42.8
  TOP w0.102: v2(267.35,84.12) 267.38,84.12 267.07,84.43 UL1.25 ; UL4.42 274.39,83.73 276.26,85.6 282.3,85.6 283.45,84.45 283.45,82.95 283.37,82.87 283.37,80.01 283.51,79.87 283.51,75.94 v2(281.85,74.28)
  IN4 w0.089: v2(281.85,74.28) 281.04,75.09 279.35,75.09 272.91,81.52 269.13,81.52 267.35,83.3 v2(267.35,84.12)
  BOTTOM w0.102: UL2.2 281.88,73.07 281.88,74.25 v2(281.85,74.28)
LOM_SPD100LED_ORG#: length 33.3
  TOP w0.102: UL4.16 272.8,75.22 272.43,74.85 272.43,73.92 272.59,73.76 272.59,73.01 v2(272.54,72.96) 272.54,71.69 v3(272.86,71.36) ; UL1.27 267.48,85.53 267.99,85.02 267.99,83.99 268.47,83.52 v2(268.47,83.4)
  IN2 w0.122: v2(272.54,72.96) 272.61,73.03 272.61,73.82 272.18,74.26 272.04,74.26 272.03,74.27 271.4,74.27 271.39,74.26 271.21,74.26 271.2,74.27 271.19,74.27 269.92,75.54 269.92,75.55 269.6,75.87 269.6,81.98 268.47,83.11 v2(268.47,83.4)
  BOTTOM w0.102: v2(272.54,72.96) 272.54,72.88 272.98,72.44 273.54,72.44 274.91,73.82 281.09,73.82 281.29,74.02 281.29,74.3 281.69,74.7 282.03,74.7 282.51,74.21 UL2.1
LPC_LAD0: length 158.8
  TOP w0.102: JLPDE1.3 247.8,66.26 247.63,66.09 246.17,66.09 244.95,67.31 244.95,68.49 v3(244.88,68.56) 244.48,68.56 244.01,68.09 244.01,67.39 v2(243.75,67.14) ; v2(261.3,68.53) 261.49,68.53 263.15,66.87 UE2.A30 ; v2(243.42,81.08) 243.72,81.38 UE1.A27
  IN1 w0.089: v2(261.3,68.53) 260.6,67.83 253.5,67.83 253.28,68.05 252.41,68.05 251.57,67.22 250.67,67.22 250.35,66.91 245.34,66.91 244.72,67.54 244.15,67.54 v2(243.75,67.14)
  IN2 w0.122: v2(196.27,47.43) 196.27,47.42 202.85,40.85 209.67,40.85 210.98,42.16 212.02,42.16 212.87,43.01 212.87,44.48 214.08,45.7 220.53,45.7 220.54,45.7 220.74,45.7 220.74,45.7 221.35,45.09 237.99,45.09 239.73,46.83 239.73,49.75 239.73,50.37 242.78,53.41 243.7,53.41 244.77,54.49 244.77,55.34 245.88,56.45 245.88,61.03 244.29,62.63 244.29,65.27 243.75,65.81 v2(243.75,67.14) 244.17,67.55 244.51,67.55 246.3,69.34 246.3,72.27 244.28,74.29 244.28,80.22 v2(243.42,81.08)
  BOTTOM w0.076: 170.27,49.48 170.19,49.56 170.19,50.36 169.94,50.61 169.66,50.61 167.55,52.72 167.22,52.72 165.97,53.97 165.97,54.16 165.77,54.36 165.77,54.64 165.8,54.72 165.8,54.97 165.77,55.1 165.77,55.27 165.83,55.45 165.93,55.57 166.03,55.67 UC1.AY13
  BOTTOM w0.102: v2(196.27,47.43) 192.86,44.01 180.88,44.01 177.19,47.69 172.06,47.69 170.27,49.48
LPC_LAD1: length 158.2
  TOP w0.102: UE2.B32 262.9,65.33 v2(262.8,65.23) ; JLPDE1.4 248.3,66.25 247.86,65.82 245.04,65.82 244.36,66.49 v2(244.36,67.14) ; UE1.A26 243.75,81.88 v2(243.5,82.13)
  IN1 w0.089: v2(244.36,67.14) 246.49,65.01 248.56,65.01 248.61,65.07 250.5,65.07 250.53,65.03 251.02,65.03 251.89,65.9 253.69,65.9 254.14,65.46 256.99,65.46 257.31,65.14 257.83,65.14 258.08,65.4 258.08,65.68 258.96,66.55 261.56,66.55 262.8,65.31 v2(262.8,65.23)
  IN2 w0.122: v2(243.5,82.13) 244.53,81.11 244.53,74.39 246.55,72.37 246.55,69.1 246.18,68.74 246.18,67.22 245.92,66.95 245.41,66.95 245.22,67.14 v2(244.36,67.14) 244.36,65.55 244.54,65.37 244.54,62.73 246.13,61.14 246.13,55.85 245.89,55.61 245.89,55.26 243.8,53.17 242.88,53.17 239.98,50.27 239.98,49.86 239.98,49.85 239.98,46.71 238.1,44.84 221.25,44.84 220.64,45.45 214.19,45.45 213.13,44.39 213.13,44.27 213.12,44.26 213.12,42.91 212.12,41.91 211.09,41.91 209.77,40.6 201.88,40.6 v2(195.06,47.43)
  BOTTOM w0.076: UC1.BA13 166.3,54.92 166.3,54.1 167.35,53.05 167.69,53.05 169.77,50.97 170.06,50.97 170.52,50.5 170.52,49.88 170.91,49.48
  BOTTOM w0.102: 170.91,49.48 172.25,48.15 177.38,48.15 181.07,44.47 192.1,44.47 v2(195.06,47.43)
LPC_LAD2: length 157
  TOP w0.102: v2(261.3,67.95) 261.73,67.95 262.65,67.03 UE2.A31 ; v2(246.28,82.84) 246.28,82.84 245.87,82.43 245.51,82.43 245.49,82.45 245.41,82.45 245.23,82.63 UE1.B26 ; v2(246.75,65.41) 247.94,65.41 248.8,66.27 JLPDE1.5
  IN1 w0.089: v2(246.75,65.41) 249.16,65.41 250.75,67 251.66,67 252.49,67.83 253.19,67.83 253.41,67.61 254.96,67.61 260.69,67.61 261.02,67.95 v2(261.3,67.95)
  IN2 w0.122: v2(195.66,47.43) 194.99,48.1 193.61,48.1 193.22,47.71 193.22,47.16 193.55,46.83 193.55,46.43 200.13,39.85 210.08,39.85 211.39,41.16 212.49,41.16 214.19,42.87 214.57,42.87 215.65,43.95 230.31,43.95 230.42,44.05 238.38,44.05 240.73,46.4 240.73,49.96 243.19,52.42 244.11,52.42 246.64,54.95 246.64,55.3 246.88,55.54 246.88,62.52 246.76,62.64 246.76,65.4 v2(246.75,65.41) 246.93,65.59 246.93,68.1 247.64,68.81 247.64,72.45 245.3,74.79 245.3,76.76 245.91,77.37 245.91,78.21 245.29,78.83 245.29,82.2 245.51,82.42 245.85,82.42 245.86,82.43 245.87,82.43 246.28,82.84 v2(246.28,82.84)
  BOTTOM w0.076: 170.37,49.7 170.36,49.72 170.36,50.43 170,50.79 169.72,50.79 167.62,52.89 167.28,52.89 166.14,54.03 166.14,54.43 UC1.BB13
  BOTTOM w0.102: v2(195.66,47.43) 192.48,44.24 180.97,44.24 177.29,47.92 172.15,47.92 170.37,49.7
LPC_LAD3: length 156.9
  TOP w0.102: v2(194.47,47.43) 194.47,47.96 v3(194.83,48.33) ; v2(246.04,64.47) 246.11,64.39 247.67,64.39 249.3,66.02 JLPDE1.6 ; v2(245.68,82.83) 245.38,83.13 UE1.B25 ; v2(261.99,64.68) 262.02,64.68 262.37,65.03 262.37,65.38 262.4,65.41 UE2.B33
  IN1 w0.089: v2(246.04,64.47) 246.14,64.37 248.53,64.37 248.77,64.62 250.34,64.62 250.35,64.6 251.63,64.6 252.23,65.2 253.54,65.2 254.35,64.39 257.2,64.39 257.65,63.94 258.41,63.94 258.68,64.2 259.74,64.2 260.21,64.68 v2(261.99,64.68)
  IN2 w0.122: v2(245.68,82.83) 245.44,82.83 245.04,82.44 245.04,78.73 245.66,78.11 245.66,77.55 245.56,77.45 245.03,76.92 245.03,74.6 247.23,72.39 247.23,68.75 247.08,68.61 247.07,68.61 246.68,68.22 246.68,66.54 246.09,65.94 246.09,64.52 v2(246.04,64.47) 246.04,63.01 246.63,62.42 246.63,55.64 246.39,55.4 246.39,55.05 244.01,52.67 243.09,52.67 240.48,50.06 240.48,46.51 238.27,44.3 230.31,44.3 230.21,44.2 215.49,44.2 214.45,43.16 214.13,43.16 212.38,41.41 211.29,41.41 209.98,40.1 200.63,40.1 193.47,47.27 193.47,47.61 193.71,47.85 194.06,47.85 194.47,47.44 v2(194.47,47.43)
  BOTTOM w0.076: UC1.AY12 166.31,55.87 166.31,55.22 166.47,55.07 166.47,54.17 167.42,53.22 167.76,53.22 169.83,51.15 170.11,51.15 170.8,50.46 170.8,49.92 171.18,49.54
  BOTTOM w0.102: 171.18,49.54 172.34,48.38 177.48,48.38 181.16,44.69 191.74,44.69 v2(194.47,47.43)
LPC_LDRQ1#: length 2.8
  TOP w0.102: UE1.A22 243.72,83.88 243.4,83.56 243.4,83.32 242.72,82.64 RPE8.1
LPC_LFRAME#: length 160.9
  TOP w0.102: v2(245.57,64.85) 245.57,63.96 245.64,63.88 247.92,63.88 249.8,65.77 JLPDE1.7 ; UE1.A21 243.65,84.38 v2(243.47,84.2) ; v3(193.87,46.83) 193.87,47.42 v2(193.88,47.44) ; UE2.B31 263.4,65.56 263.21,65.37 263.21,65.02 v2(262.8,64.61)
  IN1 w0.089: v2(262.8,64.61) 262.39,65.02 262.39,65.42 262.1,65.71 258.42,65.71 258.3,65.59 258.3,64.96 258.52,64.74 258.52,64.35 258.32,64.15 257.8,64.15 257.35,64.6 254.49,64.6 254.13,64.96 253.68,65.42 251.71,65.42 251.11,64.82 250.44,64.82 250.43,64.83 248.68,64.83 248.52,64.67 246.44,64.67 246.11,65 245.72,65 v2(245.57,64.85)
  IN2 w0.122: v2(243.47,84.2) 244.78,82.9 244.78,78.64 245.41,78 245.41,77.66 244.78,77.02 244.78,74.5 246.89,72.38 246.89,72.37 246.89,68.78 246.43,68.32 246.43,66.72 245.57,65.86 v2(245.57,64.85) 245.57,63.05 246.38,62.23 246.38,55.75 246.14,55.5 246.14,55.15 243.9,52.92 242.98,52.92 240.23,50.16 240.23,49.96 240.23,46.61 238.21,44.59 221.15,44.59 220.87,44.87 220.57,45.17 214.25,45.17 213.38,44.29 213.38,42.82 212.22,41.66 211.19,41.66 209.88,40.35 200.95,40.35 193.88,47.42 v2(193.88,47.44)
  BOTTOM w0.076: 171.37,49.68 171,50.04 171,50.49 170.14,51.35 169.86,51.35 167.83,53.38 167.49,53.38 166.63,54.24 166.63,55.48 UC1.BA12
  BOTTOM w0.102: 171.37,49.68 172.44,48.61 177.57,48.61 181.25,44.92 191.37,44.92 v2(193.88,47.44)
LPSS_UART2_RXD: length 218.8
  IN2 w0.122: v2(173.68,71.36) 173.91,71.36 174.47,70.8 174.47,70.41 174.24,70.18 174.24,69.74 174.11,69.61 173.37,68.87 173.37,67.7 173.81,67.26 174.75,67.26 175.5,66.51 175.5,63.77 v2(175.61,63.67)
  IN3 w0.122: v2(53.37,72.2) 53.61,72.44 53.61,73.22 57.35,76.95 57.35,83.08 57.86,83.58 66.29,83.58 67.17,84.47 79.19,84.47 80.46,83.2 82.16,83.2 83.84,81.52 90.36,81.52 91.2,80.69 93.82,80.69 96.33,83.2 97.37,83.2 99.53,85.35 101.41,85.35 101.92,84.85 105.4,84.85 108.37,87.82 112.14,87.82 114.3,85.66 115.15,85.66 115.69,86.2 115.69,87.26 118.24,89.8 118.94,89.8 122.93,93.79 126.94,93.79 127.73,94.58 142.76,94.58 143.52,95.34 146.4,95.34 148.03,93.7 148.98,93.7 150.71,95.44 162.27,95.44 165.75,91.97 165.75,87.39 171.16,81.98 171.16,79.8 172.83,78.12 172.83,72.21 v2(173.68,71.36)
  BOTTOM w0.076: v2(175.61,63.67) 175.03,63.67 174.54,64.15 173.7,64.15 173.48,64.37 UC1.AD1
  BOTTOM w0.102: v2(53.37,72.2) 53.66,72.49 53.66,72.92 53.26,73.32 35.25,73.32 33.36,75.21 33.36,77.53 RC330.2 32.47,78.45 RC336.2 33.19,80.44 33.19,83.47 v3(34.02,84.3) 34.14,84.43 34.3,84.58 34.3,87.85 32.03,90.11 26.31,90.11 25.18,88.99 24.93,88.99 24.63,88.69 JUART1.3
LPSS_UART2_TXD: length 219.8
  IN2 w0.122: v2(173.98,70.55) 173.83,70.4 173.83,69.68 173.12,68.98 173.12,67.6 173.71,67.01 174.65,67.01 175.26,66.41 175.26,64.13 175.13,64.01 175.13,63.54 v2(175.61,63.07)
  IN3 w0.122: v2(173.98,70.55) 173.85,70.55 172.58,71.82 172.58,78.02 170.91,79.7 170.91,81.88 165.5,87.29 165.5,91.86 162.17,95.19 150.82,95.19 149.08,93.45 147.93,93.45 146.29,95.09 143.63,95.09 142.87,94.33 127.83,94.33 127.04,93.54 123.03,93.54 119.04,89.55 118.34,89.55 115.94,87.15 115.94,86.1 115.26,85.41 114.19,85.41 112.03,87.57 108.47,87.57 105.5,84.6 101.82,84.6 101.31,85.11 99.63,85.11 97.48,82.95 96.43,82.95 93.92,80.44 91.1,80.44 90.26,81.28 83.73,81.28 82.06,82.95 80.36,82.95 79.09,84.22 67.28,84.22 66.39,83.33 57.96,83.33 57.6,82.97 57.6,76.85 53.86,73.11 53.86,72.47 v2(54.13,72.2)
  BOTTOM w0.076: v2(175.61,63.07) 175.39,63.07 174.48,63.99 173.52,63.99 173.42,64.03 173,64.21 UC1.AD2
  BOTTOM w0.102: JUART1.2 24.59,89.49 24.86,89.22 25.09,89.22 26.21,90.34 32.13,90.34 34.52,87.95 34.52,82.7 v3(34.01,82.19) 33.42,81.59 33.42,80.71 RC335.2 34.41,78.45 RC331.2 33.59,77.63 33.59,75.3 35.35,73.55 53.36,73.55 53.89,73.02 53.89,72.44 v2(54.13,72.2)
LX_1.8VALW:
  vias: v3(215.18,109.16)
LX_1VS_VCCIO:
  vias: v3(198.47,50.54)
LX_3V: length 3.6
  TOP w0.508: 222.82,72.67 222.46,73.03 219.42,73.03
  vias: v2(217.92,72.6) v2(218.53,72.62) v2(223.53,72.39) v3(214.01,75.25)
LX_5V: length 2.8
  TOP w0.508: 220.79,63.48 223.63,63.48
  vias: v2(219.98,63.48) v2(219.98,62.87) v2(224.47,63.46) v3(219.93,62.3)
M2_DEVSLP: length 144.9
  TOP w0.102: RN37.2 257.09,11.45 v3(257.67,11.45) 257.9,11.45 258.67,10.68 v2(258.67,10.39)
  IN1 w0.089: v2(258.67,10.39) 257.92,9.65 257.92,3.42 v2(257.3,2.8)
  IN2 w0.122: v2(245.45,17.86) 245.92,17.39 249.11,17.39 249.57,17.85 255.9,17.85 257.29,16.46 257.29,15.12 258.53,13.87 258.53,11.23 258.67,11.1 v2(258.67,10.39)
  IN4 w0.089: v2(175.31,74.55) 175.97,75.22 179.58,75.22 181.17,73.63 183.95,73.63 184.93,72.65 186.09,72.65 186.87,73.43 192.23,73.43 193.95,71.71 197.09,71.71 198.34,70.46 198.34,68.15 199.88,66.61 199.88,63.83 201.15,62.56 204.9,62.56 207.35,60.1 207.96,60.1 208.42,59.64 208.77,59.28 208.77,57.64 210.1,56.32 210.1,53.9 210.25,53.75 210.25,52 210.37,51.88 210.37,51.42 211.13,50.66 211.89,50.66 212.05,50.5 212.05,49.96 212.35,49.66 213.43,49.66 217.08,46.01 220.91,46.01 221.53,46.63 223.01,46.63 225.25,44.38 225.25,41.33 227.78,38.8 229.36,38.8 231.97,36.19 231.97,33.54 232.39,33.12 232.39,27.12 238.03,21.48 238.78,21.48 239.92,20.34 241.47,20.34 242.66,19.14 244.17,19.14 v2(245.45,17.86)
  BOTTOM w0.076: UC1.J3 172.25,72.52 172.41,72.52 172.63,72.6 172.76,72.6 172.76,72.6 172.92,72.55 173.17,72.55 173.27,72.59 173.45,72.67 173.48,72.68 173.71,72.68 174.87,73.85 174.87,74.12 175.19,74.44
  BOTTOM w0.102: JNGFF3.38 v2(257.3,2.8) ; 175.19,74.44 v2(175.31,74.55)
M_ID2#: length 5.9
  BOTTOM w0.102: CV57.1 245.37,103.77 244.58,104.56 243.74,104.56 243.39,104.91 243.39,105.64 JCRT1.4
MASK_BASE_LEDS#: length 8.6
  TOP w0.102: v2(288.17,68.71) 289.96,66.92 v3(289.96,65.67) 289.2,64.91 287.87,64.91 287.51,64.55 UZ10.4
  BOTTOM w0.102: v2(288.17,68.71) 287.98,68.51 QZ7.5
MASK_SATA_LED#: length 51.4
  TOP w0.102: v2(250.15,85.68) 249.64,86.19 UE1.B9
  IN1 w0.089: v2(250.15,85.68) 250.33,85.5 251.52,85.5 252.72,84.3 253.49,84.3 254.46,85.27 254.46,85.94 255.66,87.15 258.39,87.15 259.52,86.02 259.52,85.9 259.95,85.47 260.66,85.47 262.25,83.89 263.96,83.89 264.78,83.07 264.78,81.11 269.2,76.69 271.6,76.69 274.43,73.85 275.2,73.85 275.32,73.73 276.73,73.73 277.03,73.43 278.59,73.43 278.71,73.55 282.82,73.55 283.22,73.94 285.76,73.94 v2(286.42,73.28)
  BOTTOM w0.102: QZ3.5 284.58,71.49 284.76,71.3 285.72,71.3 286.42,72.01 v2(286.42,73.28)
MCARD_PCIE#_SATA: length 4.5
  TOP w0.102: UE2.B8 269.77,60.79 v2(269.76,60.79) ; v2(272.68,61.09) 273.09,60.68 T131.1
  IN1 w0.089: v2(272.68,61.09) 272.28,60.69 271.89,60.69 271.8,60.79 v2(269.76,60.79)
ME_FWP: length 189.4
  TOP w0.102: v2(226.78,24.46) 226.78,24.21 226.44,23.87 222.77,23.87 222.63,24.01 216.92,24.01 211.59,29.34 200.84,29.34 194.4,35.78 171.24,35.78 165.87,41.14 165.87,42.51 166.05,42.68 166.05,42.7 166.1,42.75 166.1,43.29 RC223.1
  IN3 w0.122: v2(243.95,96.04) 242.99,95.08 242.99,91.95 243.29,91.65 243.29,87.34 243.06,87.11 242.9,87.11 241.11,85.32 241.11,82.94 240.84,82.68 240.84,79.56 240.46,79.18 240.46,78.65 240.46,78.17 241.73,76.9 241.73,76.27 241.88,76.13 241.88,75.5 242.83,74.54 243.54,74.54 245.2,72.88 246.2,72.88 246.61,72.48 247.16,72.48 247.35,72.29 248.14,72.29 251.75,68.68 251.75,68.4 251.75,66.55 251.97,66.33 251.97,64.62 252.23,64.36 253.33,64.36 254.93,62.76 254.93,56.24 256.58,54.58 256.58,53.6 257.04,53.14 257.04,50.63 257.04,50.22 257.3,49.97 257.3,46.29 257.04,46.03 257.04,45.32 257.04,45.32 257.04,41.83 255.75,40.54 254.9,40.54 253.34,38.98 252,38.98 251.2,39.78 251.2,40.26 250.93,40.53 250,40.53 249.76,40.28 249.76,39.58 248.99,38.8 247.83,38.8 247.2,39.43 241.05,39.43 240.22,38.6 v2(239.83,38.6)
  BOTTOM w0.102: v2(226.78,24.46) 227.32,25 230.4,25 231.48,26.07 231.48,28.32 236.98,33.82 237.99,33.82 239.69,35.53 239.69,38.45 v2(239.83,38.6) ; SW1.3 249.03,93.44 249.26,93.67 249.26,95.86 248.6,96.52 RC221.1 244.44,96.52 v2(243.95,96.04)
ME_FWP_EC: length 22.4
  TOP w0.102: v2(252.13,95.2) 252.13,94.91 252.89,94.15 252.89,91.49 253.5,90.88 253.5,90.84 253.84,90.51 253.84,87.71 254.18,87.37 255.45,87.37 255.59,87.23 255.59,86.6 255.37,86.38 UE1.A64
  IN1 w0.089: v2(245.83,96.96) 248.59,96.96 249.85,95.7 251.91,95.7 252.13,95.47 v2(252.13,95.2)
  BOTTOM w0.102: v2(245.83,96.96) 245.43,96.96 RC221.2 245.15,97.64 245.87,97.64 246.08,97.44 SW1.1
ME_RESET#: length 7
  BOTTOM w0.102: UC12.2 180.71,89.26 180.61,89.16 179.97,89.16 179.69,89.44 179.69,91.17 RC227.1 178.09,91.9 RC225.2 177.78,91.98 v3(177.08,92.68)
ME_SUS_PWR_ACK: length 160.1
  TOP w0.102: v2(188.41,49.49) 188.41,49.01 188.7,48.72 RC74.2 ; v2(234.51,43.26) 234.78,42.98 234.78,40.21 v2(237.45,37.55) ; UE2.A8 272,61.04 272.05,61.09 v2(272.06,61.09)
  IN1 w0.089: v2(234.51,43.26) 232.53,43.26 231.9,42.63 225.02,42.63 223.02,44.63 221.02,44.63 220.6,45.06 220.59,45.06 220.52,45.13 215.76,45.13 214.9,46 214.43,46 213.73,46.7 209.09,46.7 208.58,47.2 204.25,47.2 202.92,45.87 191.83,45.87 190.87,46.83 190.87,48.02 190.12,48.77 188.92,48.77 188.41,49.28 v2(188.41,49.49)
  IN3 w0.122: v2(237.45,37.55) 237.78,37.22 240.26,37.22 241.47,38.43 246.78,38.43 247.96,37.25 253.58,37.25 255.35,39.01 256.28,39.01 256.82,39.55 257.27,39.55 258.72,38.1 258.72,36.37 257.94,35.59 257.94,35.06 258.39,34.61 261.17,34.61 261.74,35.18 261.74,35.66 261.63,35.77 259.96,35.77 259.79,35.94 259.79,36.73 263.01,39.96 263.01,44.06 262.99,44.08 262.99,45.81 263.85,46.67 263.85,47.87 262,49.71 262,51.08 262.17,51.25 262.17,53.01 261.93,53.25 261.93,56.01 262.11,56.19 263.96,56.19 264.89,57.12 264.89,58.64 266.62,60.37 271.34,60.37 v2(272.06,61.09)
  IN4 w0.089: v2(188.41,49.49) 187.09,50.81 187.09,53.13 186.88,53.34 186.88,53.82 185.04,55.66 184.77,55.66 184.77,55.67 181.53,55.67 180.12,54.26 171.88,54.26 171.06,55.08 168.27,55.08 166.21,57.14 166.21,58.19 v2(166.59,58.57)
  BOTTOM w0.076: v2(166.59,58.57) 166.21,58.95 UC1.AR13
MEC_XTAL1: length 5.8
  TOP w0.102: UE2.A61 268.15,55.49 268.61,55.03 v3(268.61,54.7) 268.61,53.71 267.73,52.84 267.47,52.84 CE28.1 267.37,52 YE1.1
MEC_XTAL2: length 2.9
  TOP w0.102: YE1.2 269.04,52.36 CE29.1 270.17,53.54 RE290.2
MEC_XTAL2_R: length 2.4
  TOP w0.102: UE2.A62 268.65,55.39 269.25,54.79 RE290.1
MEDIACARD_IRQ#: length 133.8
  TOP w0.102: UR2.32 265.47,43.04 266.02,42.5 RR19.2 266.38,42.55 265.75,43.18 265.75,44.69 266.25,45.18 266.46,45.18 266.8,45.52 266.8,47.62 v3(266.84,47.66) 267.15,47.97 v2(267.32,47.97)
  IN1 w0.089: v2(221.53,45.75) 221.7,45.57 223.33,45.57 224.46,44.44 236.88,44.44 237.31,44.87 238.39,44.87 242.91,49.39 242.91,49.89 246.09,53.06 257.21,53.06 257.56,53.42 260.53,53.42 263.55,50.4 263.55,49.85 263.56,49.84 263.56,49.81 264.3,49.07 266.69,49.07 267.32,48.44 v2(267.32,47.97)
  IN4 w0.089: v2(221.53,45.75) 221.35,45.58 216.9,45.58 213.24,49.23 210.63,49.23 210.38,49.48 210.38,50.8 209.94,51.24 209.94,51.7 209.82,51.82 209.82,53.52 209.66,53.67 209.66,54.08 209.66,56.11 208.33,57.45 208.33,57.63 208.33,59.12 208.11,59.34 207.78,59.67 207.17,59.67 204.73,62.11 200.78,62.11 199.39,63.51 199.39,66.45 197.89,67.96 197.89,70.3 196.91,71.28 193.77,71.28 192.05,73 188.01,73 187.15,72.14 184.76,72.14 183.71,73.2 180.99,73.2 179.61,74.57 178.3,74.57 176.61,72.89 175.75,72.89 v2(175.27,73.36)
  BOTTOM w0.076: UC1.M1 173.17,71 172.69,71.47 172.69,71.82 172.93,72.05 173.59,72.05 174.9,73.36 175.19,73.36
  BOTTOM w0.102: v2(175.27,73.36) 175.27,73.36 175.19,73.36
MEM_SMBCLK: length 49.9
  TOP w0.102: v2(194.56,58.7) 194.42,58.57 v3(194.42,57.25) 194.42,56.05 195.53,54.94 195.53,53.68 QC2.6 ; RC12.1 179.27,68.42 178.39,68.42 178.12,68.69 176.04,68.69 175.88,68.85 174.77,68.85 172.73,68.85 171.88,69.7 171.48,69.7 v2(170.29,69.7)
  IN4 w0.076: 172.22,69.73 171.43,69.73 171.42,69.74 170.33,69.74 v2(170.29,69.7)
  IN4 w0.089: v2(194.56,58.7) 194.22,59.05 194.22,60.68 193.85,61.04 193.85,62.86 192.63,64.08 192.63,65.26 190.06,67.83 187.46,67.83 186.46,68.83 185.9,68.83 185.72,68.65 185.72,68.19 185.5,67.97 185.12,67.97 184.67,68.43 184.55,68.43 182.87,70.11 176.78,70.11 176.2,70.11 175.59,69.5 174.93,68.84 173.3,68.84 172.41,69.73 172.22,69.73
  BOTTOM w0.076: UC1.R7 169.98,69.38 v2(170.29,69.7)
MEM_SMBDATA: length 54
  TOP w0.102: RC14.1 178.74,67.91 175.43,67.91 174.97,68.37 172.53,68.37 171.68,69.22 170.09,69.22 v2(169.61,69.7) ; v2(193.84,58.7) 193.94,58.6 193.94,55.85 195.05,54.74 195.05,50.94 195.58,50.41 v3(196.05,50.41) 196.14,50.41 196.84,51.11 QC2.3
  IN4 w0.076: v2(169.61,69.7) 169.98,69.33 170.45,69.33 170.49,69.38 170.65,69.38
  IN4 w0.089: v2(193.84,58.7) 193.75,58.8 193.75,60.48 193.38,60.85 193.38,62.1 192.52,62.96 192.52,63.52 188.81,67.23 187.11,67.23 186.48,67.86 186.05,67.86 185.69,67.5 184.92,67.5 184.47,67.96 184.36,67.96 182.68,69.64 176.59,69.64 176.59,69.64 176.39,69.64 175.92,69.17 175.12,68.37 173.1,68.37 172.21,69.26 171.23,69.26 171.11,69.38 170.65,69.38
  BOTTOM w0.076: UC1.R8 169.32,69.42 v2(169.61,69.7)
MIC1_L: length 3.2
  TOP w0.203: CA43.1 279.87,28.46 279.87,28.51 279.53,28.86 279.24,29.15 279.24,29.61 279.31,29.68 UA1.19
MIC1_R: length 3.8
  TOP w0.203: 280.95,28.72 280.88,28.78 280.22,28.78 v3(279.71,29.29) UA1.20
  TOP w0.381: CA44.1 281.77,27.89 280.95,28.72
MPHYP_PWR_EN: length 61.5
  IN2 w0.122: v2(177.66,82.53) 177.24,82.11 177.24,81.07 177.95,80.35 177.95,75.7 178.15,75.51 178.15,73.54 177.32,72.71 177.32,71.17 178.15,70.34 178.59,70.34 179.37,69.56 179.37,69.33 179.37,68.91 179.37,68.91 179.37,65.14 179.22,64.99 179.07,64.85 179.07,60.51 176.79,58.22 172.72,58.22 170.93,60.01 170.93,60.15 170.55,60.54 169.99,60.54 169.64,60.19 169,60.19 168.97,60.21 168.79,60.38 168.67,60.51 v2(167.52,60.51)
  BOTTOM w0.076: UC1.AM10 167.92,60.9 v2(167.52,60.51)
  BOTTOM w0.102: v2(177.66,82.53) 177.78,82.53 182.61,87.36 182.61,92.45 181.57,93.5 179.11,93.5 178.95,93.33 v3(178.6,93.33) 177.64,93.33 177.01,93.97 175.23,93.97 174.46,93.2 RZ83.2
MSCLK: length 61.5
  TOP w0.102: v2(263.36,58.44) 263.1,58.69 263.1,60.74 263.22,60.85 263.22,61.46 263.03,61.65 261.74,61.65 261.39,61.29 UE2.B43 ; RE72.2 297.63,44.28 299.11,42.8 JDEG1.6 300.61,42.8 300.99,43.18 302,43.18 v2(302.53,42.65)
  IN1 w0.089: v2(263.36,58.44) 263.4,58.44 263.73,58.76 264.62,58.76 264.7,58.85 265.74,58.85 265.78,58.81 266.57,58.81 266.63,58.87 268.09,58.87 269,57.95 271.82,57.95 271.91,58.04 272.99,58.04 273.33,58.38 275.22,58.38 275.77,58.93 276.22,58.93 276.54,58.6 277.66,58.6 278.8,57.46 281.1,57.46 282.05,56.51 283.62,56.51 283.93,56.83 286.48,56.83 290.22,53.09 290.22,51.5 291.38,50.33 291.82,50.33 296.34,50.33 302.53,44.15 v2(302.53,42.65)
MSDATA: length 80.2
  TOP w0.102: v2(253.83,59.29) 253.83,60.93 v3(254.47,61.57) 255.18,62.28 RE86.2 255.8,62.48 259.1,62.48 259.32,62.26 259.32,61.94 259.61,61.65 259.9,61.65 260.01,61.54 UE2.A40 ; RE75.2 297.1,45.3 299.1,43.3 JDEG1.7 300.74,43.3 300.89,43.45 302.37,43.45 303.01,42.82 303.01,42.37 v2(302.68,42.04)
  IN1 w0.089: v2(253.83,59.29) 254.06,59.29 254.72,58.63 258.21,58.63 258.56,58.28 261.15,58.28 262.16,59.29 262.98,59.29 263.63,59.94 268.4,59.94 268.82,59.51 270.65,59.51 271.05,59.12 273.6,59.12 273.87,58.85 274.93,58.85 275.48,59.4 276.1,59.4 276.31,59.61 276.31,59.92 276.57,60.18 279.46,60.18 281.3,58.34 281.3,57.93 282.24,56.98 283.42,56.98 283.74,57.3 286.68,57.3 290.69,53.29 290.69,51.69 291.53,50.85 296.54,50.85 303,44.4 303,42.36 v2(302.68,42.04)
NB_PSID: length 7.7
  TOP w0.102: v3(53.44,91.17) 53.05,91.56 PD6.2
  TOP w0.254: v2(53.68,93.8) 54.04,93.44 54.04,92.87 53.91,92.74 PD6.2 PD6.3 54.36,94.67 PL4.2
NB_PSID_TS5A63157: length 4
  TOP w0.254: 55.25,99.22 54.95,99.22 54.69,98.97 PU1.3 ; 55.25,99.22 PR7.2 56.6,98.15 PR6.1 ; 55.25,99.22 v3(55.26,99.22)
NON_DOCK: length 28.6
  TOP w0.102: RH359.1 190.31,47.16 v2(190.41,47.26)
  BOTTOM w0.076: UC1.AY7 169.59,55.71 169.92,55.39 169.92,54.13 170.08,53.97 170.14,53.97 171.14,53.97 171.42,53.69 173.63,53.69 174.11,53.2
  BOTTOM w0.102: 174.11,53.2 175.29,52.02 175.29,50.85 175.43,50.71 175.63,50.71 176.93,49.42 177.8,49.42 181,46.22 189.37,46.22 v2(190.41,47.26)
NRB_BIT: length 19.8
  TOP w0.102: RC186.2 186.59,57.32 185.92,57.32 185.41,57.83 178.84,57.83 178.58,58.09 172.4,58.09 172.12,57.82 171.54,57.82 171.1,58.26 169.63,58.26 v2(169.32,58.57)
  BOTTOM w0.076: UC1.AR7 169.7,58.95 169.32,58.57 v2(169.32,58.57)
NTC_IA: length 6.3
  TOP w0.203: PU602.15 85.87,65.47 85.99,65.36 86.57,65.36 v2(86.63,65.31)
  BOTTOM w0.254: v2(86.63,65.31) 86.63,62.2 v3(86.86,61.97) 87.02,61.8 PR635.2
NVME_LED#: length 21
  TOP w0.102: RZ118.2 267.63,15.47 v2(267.74,15.36) v1(268.29,15.36)
  IN2 w0.122: v2(267.74,15.36) 270.12,12.98 270.12,10.1 268.2,8.18 264.28,8.18 264.02,7.93 264.02,3.1 v2(264.3,2.82)
  BOTTOM w0.102: JNGFF3.10 v2(264.3,2.82)
ONE_DIMM#: length 19.1
  BOTTOM w0.076: UC1.M2 172.44,71.26 171.9,71.26 171.74,71.11 171.74,70.89 171.75,70.88 171.75,70.78 172.05,70.48 172.05,70.17 172.38,69.84 172.38,69.51 172.58,69.31 173.75,69.31 175.19,70.75
  BOTTOM w0.102: RC267.2 181.64,67.25 181.64,68.05 181.47,68.22 179.95,68.22 179.7,68.47 179.7,69.41 RC268.1 180.48,69.87 180.74,70.12 180.74,70.73 180.42,71.05 179.66,71.05 179.47,71.24 177.46,71.24 v1(177.33,71.11) 175.55,71.11 175.19,70.75
P33ALW: length 3.7
  TOP w0.254: PU901.18 30.06,83.29 30.26,83.49 30.26,84.79 v3(30.77,85.3) PR931.1
P33ALW2: length 2.8
  TOP w0.203: PU901.9 28.68,77.8 29.3,77.17 v3(29.49,77.17) 29.91,76.75 PR932.2
P50ALW: length 4.9
  TOP w0.254: PU901.27 24.68,84.69 24.5,84.86 24.27,84.86 23.74,84.33 22.87,84.33 v3(22.33,84.87) 22.33,85.82 PR937.1
PANEL_BKEN_EC: length 206.4
  TOP w0.102: v2(246.87,79.28) 247.36,78.8 247.36,78.52 247.14,78.3 UE1.B38
  IN2 w0.122: v2(85.29,85.06) 85.29,85.21 86.42,86.34 92.81,86.34 93.2,86.72 95.62,86.72 96.1,87.21 96.39,87.5 97.11,87.5 97.17,87.55 98.98,87.55 100.01,88.58 100.01,89.45 102.44,91.88 102.85,91.88 102.85,91.88 104.34,91.88 104.51,91.85 105.02,91.75 105.65,91.48 106.22,91.1 107.28,90.04 116.79,90.04 117.52,89.32 117.72,89.32 120.32,89.32 121.93,90.93 125.71,90.93 125.89,91.11 128.84,91.11 132.3,94.57 140.11,94.57 140.26,94.71 144.11,98.56 144.11,101.97 144.79,102.65 144.93,102.8 145.41,103.27 145.41,103.69 145.41,105.58 146.17,106.35 150.57,106.35 150.82,106.6 150.96,106.74 150.96,106.74 151.68,107.46 156.54,107.46 157.16,107.46 157.82,106.8 158.33,106.29 160.73,106.29 161.55,105.47 161.55,105.02 161.99,104.59 164.35,104.59 165.57,103.37 165.57,100.68 166.21,100.04 166.21,98.54 167.82,96.92 173.86,96.92 176.8,93.98 179.33,93.98 179.78,93.53 179.78,93.53 180.8,92.51 180.86,92.44 180.87,92.44 180.88,92.44 181.24,92.44 185.2,88.47 185.53,88.47 188.07,85.93 198.18,85.93 201.99,82.12 202.83,82.12 208.24,82.12 209,81.36 222.81,81.36 223.56,82.11 224.07,82.11 224.48,81.7 224.48,81.24 224.8,80.92 229.58,80.92 230.67,82.01 232.53,82.01 234.02,83.5 238,83.5 239.09,84.58 239.58,84.58 241.69,86.69 243.45,86.69 245.52,84.62 246.39,84.62 247.2,83.81 247.2,79.61 v2(246.87,79.28)
  BOTTOM w0.102: v2(246.87,79.28) 247.47,79.87 248.25,79.87 v3(248.62,80.25) ; DV2.2 85.07,82.52 85.07,84.84 v2(85.29,85.06)
PANEL_BKLEN: length 134.3
  IN1 w0.089: v2(167.09,68.72) 166.49,68.11 166.27,68.11 165.71,67.55 159.97,67.55 159.7,67.82 159.7,67.95 159.32,68.33 158.91,68.33 158.51,68.74 157.82,68.74 157.44,69.12 157.44,70.06 156.87,70.63 155.5,70.63 155.14,70.98 155.14,72.05 154.96,72.23 149.6,72.23 149.01,72.82 144.68,72.82 144.2,73.3 144.2,74.63 144.19,74.64 144.19,75.5 140.5,79.19 140.02,79.19 139.52,79.69 139.52,80.21 138.95,80.78 137.34,80.78 136.88,80.32 135.19,80.32 134.97,80.1 134.29,80.1 134,80.39 134,80.75 133.67,81.08 133.22,81.08 130.99,83.31 130.99,84.5 129.19,86.3 126.97,86.3 124.72,88.55 122.94,88.55 122.94,88.55 122.07,88.55 121.58,89.04 120.3,89.04 119.41,89.93 118.22,89.93 117.31,90.84 107.31,90.84 105.99,92.17 105.69,92.46 101.23,92.46 99.24,90.47 94.18,90.47 93.58,91.07 79.44,91.07 78.45,90.08 74.23,90.08 69.73,85.58 68.97,85.58 v2(68.87,85.47)
  BOTTOM w0.076: v2(167.09,68.72) 167.09,68.77 166.72,69.14 UC1.R12
  BOTTOM w0.102: DV2.3 83.82,82.46 82.85,81.49 77.32,81.49 74.78,84.03 v3(71.69,84.03) 71.21,84.03 69.76,85.47 v2(68.87,85.47)
PANEL_ID: length 7.7
  TOP w0.102: RE300.2 276.16,65.49 CE47.1 274.76,64.95 274.76,62.54 274.41,62.18 273.38,62.18 273.24,62.04 v3(272.38,62.04) UE2.A10
PBAT_PRES#: length 402.8
  TOP w0.102: v2(252.06,54.18) 253.43,52.81 254.81,52.81 256.01,51.61 v3(256.23,51.61) 256.27,51.61 256.72,52.06 258.26,52.06 258.93,52.73 259.65,52.73 260.15,52.23 261.65,52.23 262.18,52.75 262.18,54.69 262.09,54.78 262.09,55.36 262.15,55.42 UE2.A49 ; PRP1.1 60.36,17.96 60.16,17.76 59.35,17.76 58.82,18.28 PD2.3 58.3,18.16 58.3,16.95 59.35,15.9 59.35,15.29 60.24,14.41 60.87,14.41 PD4.1 61.28,15.78 61.37,15.88 PR3.2 62.5,15.67 v2(62.5,14.43) ; PU902.1 254.39,92.12 254.92,91.59 254.92,90.75 v2(254.85,90.68)
  IN1 w0.089: v2(62.5,14.43) 62.9,14.02 64.31,14.02 64.84,14.56 64.84,16.73 66.1,17.99 71.72,17.99 73.15,19.42 73.15,40.83 68.97,45.01 68.97,46.75 68.86,46.86 68.86,50.64 68.05,51.45 68.05,60.25 68.85,61.05 68.97,61.17 68.97,65.19 64.65,69.5 64.65,71.83 v2(64.46,72.03)
  IN2 w0.122: v2(254.85,90.68) 254.96,90.58 254.96,88.24 256.21,86.98 256.21,85.03 256.66,84.59 256.66,83.43 255.96,82.73 255.82,82.73 255.37,82.28 255.37,79.38 257.17,77.58 257.17,75.28 256.45,74.56 256.45,71.78 255.94,71.27 255.94,69.93 256.2,69.67 256.2,65.84 255.59,65.23 255.59,63.13 255.58,63.12 255.58,59.18 253.74,57.33 253.74,56.19 252.06,54.51 v2(252.06,54.18) ; v2(64.46,72.03) 64.35,71.92 62.84,71.92 60.7,74.06 58.11,74.06 57.35,74.82 57.35,84.85 56.8,85.41 56.77,85.41 55.94,86.24 55.94,88.52 56.62,89.2 56.62,90.89 57.57,91.85 59.85,91.85 60.29,91.42 62.09,91.42 64.2,93.53 64.2,95.43 v2(64.76,95.99)
  IN3 w0.122: v2(254.85,90.68) 252.56,92.97 250.94,92.97 248.68,95.23 248.68,96.56 245.75,99.48 245.6,99.63 245.31,99.92 245.31,99.92 245.16,100.08 244.1,100.08 243.34,100.83 232.81,100.83 231.6,102.04 230.52,102.04 230.37,101.89 228.74,101.89 227.43,103.19 214.42,103.19 213.55,102.33 209.33,102.33 207.79,100.78 207.79,99.63 201.81,93.65 200.24,93.65 200.17,93.58 191.81,93.58 189.45,95.94 188.62,96.77 176.45,96.77 170.52,102.7 168.85,102.7 167.56,103.99 167.56,105.51 166.64,106.43 166.64,107.24 166.05,107.84 160.73,107.84 160.34,107.45 149.58,107.45 148.83,106.69 135.56,106.69 132.59,109.66 129.26,109.66 127.8,108.2 127.8,104.34 120.16,96.69 119.72,96.25 117.81,96.25 117.3,95.75 117.04,95.49 117.04,94.04 115.66,92.65 110.8,92.65 110.42,93.02 110.16,93.28 106.2,93.28 105.78,93.69 102.52,93.69 100.39,95.82 89.67,95.82 89.56,95.93 67.7,95.93 67.33,95.56 65.18,95.56 v2(64.76,95.99)
  BOTTOM w0.102: v2(64.76,95.99) 64.12,95.35 64.12,93.86 64.22,93.75 PR828.1
PBAT_PRES#_C: length 6.1
  TOP w0.102: v2(61.07,19.18) 60.91,19.35 59.65,19.35 v3(59.49,19.18) 59.49,18.7 59.63,18.56 60.7,18.56 60.93,18.33 61.25,18.33 PRP1.8
  BOTTOM w0.102: PBATT1.6 60.76,19.18 v2(61.07,19.18)
PBAT_SMBCLK: length 258
  TOP w0.102: UE2.A56 265.65,55.1 v2(265.62,55.07) ; RPE13.8 264.09,49.59 263.77,49.91 263.77,50.58 263.97,50.78 v2(264.32,50.78) ; PRP1.3 v2(60.26,16.62) 59.61,16.62 PD3.3
  IN2 w0.122: v2(264.32,50.78) 264.32,51.03 264.63,51.34 265.04,51.34 265.38,51 265.38,48.89 267.69,46.58 267.69,44.06 266.92,43.29 266.92,41.33 266.45,40.85 266.45,35.91 265.48,34.95 265.48,34.7 264.74,33.96 264.74,31.94 264.27,31.48 264.27,30.2 264.42,30.05 264.42,28.7 263.84,28.11 263.84,27 262.57,25.74 261.23,25.74 260.07,24.58 255.29,24.58 253.83,23.12 253.83,22.84 252.44,21.44 247.43,21.44 246.72,20.73 246.72,20.22 246.01,19.51 244.89,19.51 242.81,17.42 233.57,17.42 231.58,19.41 231.04,19.41 229.2,21.26 229.2,22.15 228.48,22.87 214.75,22.87 213.41,24.21 202.6,24.21 200.16,26.65 192.29,26.65 190.23,28.72 113.01,28.72 107.89,23.61 86.65,23.61 85.58,22.54 79.39,22.54 77.22,20.36 75.09,20.36 74.46,19.73 73.06,19.73 69.26,15.94 67.56,15.94 66.58,14.96 65.96,14.96 65.75,14.96 65.75,14.96 65.39,14.96 64.57,15.78 62.39,15.78 61.12,17.05 60.7,17.05 v2(60.26,16.62)
  IN4 w0.089: v2(265.62,55.07) 264.82,55.07 264.36,54.6 264.36,51.67 264.32,51.64 v2(264.32,50.78)
PBAT_SMBCLK_C: length 7.3
  TOP w0.102: PRP1.6 62.22,17.94 62.67,17.94 v2(62.78,17.83) v3(64.57,17.83)
  BOTTOM w0.102: PBATT1.4 62.85,20.81 62.85,20.03 63.54,19.34 63.54,18.52 62.95,17.94 62.88,17.94 v2(62.78,17.83)
PBAT_SMBDAT: length 257.3
  TOP w0.102: RPE13.7 264.59,49.78 264.3,50.06 v2(264.3,50.19) ; PD2.2 59.2,17.15 v2(59.93,17.15) PRP1.2 ; UE2.B59 265.42,56.71 265.42,57.37 v2(265.41,57.37)
  IN2 w0.122: v2(59.93,17.15) 60.08,17.15 60.49,17.56 61.33,17.56 62.6,16.29 64.78,16.29 65.6,15.47 65.96,15.47 66.17,15.47 66.17,15.47 66.38,15.47 67.35,16.44 69.05,16.44 72.85,20.24 74.25,20.24 74.88,20.87 77.01,20.87 79.19,23.04 85.37,23.04 86.44,24.11 107.68,24.11 112.8,29.22 190.43,29.22 192.5,27.16 200.36,27.16 202.81,24.71 213.62,24.71 214.95,23.37 228.69,23.37 229.7,22.36 229.7,21.47 231.25,19.92 231.79,19.92 233.78,17.93 242.6,17.93 244.68,20.01 245.8,20.01 246.22,20.43 246.22,20.94 247.22,21.94 252.23,21.94 253.33,23.05 253.33,23.33 255.08,25.08 259.86,25.08 261.02,26.24 262.36,26.24 263.33,27.21 263.33,28.32 263.92,28.9 263.92,29.84 263.77,29.99 263.77,31.68 264.24,32.15 264.24,34.17 264.98,34.91 264.98,35.16 265.94,36.12 265.94,41.06 266.42,41.53 266.42,43.49 267.19,44.26 267.19,46.37 264.3,49.26 v2(264.3,50.19)
  IN4 w0.089: v2(264.3,50.19) 264.21,50.19 263.85,50.55 263.85,51.83 263.89,51.86 263.89,54.8 265.41,56.32 v2(265.41,57.37)
PBAT_SMBDAT_C: length 7.4
  TOP w0.102: v3(61.26,20.34) 61.26,19.68 62.09,18.84 62.4,18.84 62.5,18.73 v2(62.5,18.42) 62.02,18.42 PRP1.7
  BOTTOM w0.102: PBATT1.5 61.76,19.88 62.31,19.88 63.05,19.14 63.05,18.72 62.75,18.42 v2(62.5,18.42)
PBATT+_C:
  vias: v2(64.12,19.49) v2(64.15,18.81) v2(64.74,18.79) v2(64.78,19.45) v2(65.35,18.73) v2(65.37,19.47) v2(65.93,18.72) v2(65.96,19.49) v2(66.54,18.77) v2(66.58,19.5) v2(67.13,18.84) v2(67.18,19.5) v2(67.72,19.14) v3(61.93,22.58) v3(63.22,19.38) v3(63.44,21.4)
PCH_ALW_ON: length 63.2
  TOP w0.102: v2(247.23,46.36) 247.18,46.31 RZ65.1 ; v2(276.78,59.59) 276.78,60.42 277.02,60.65 RPE10.4 ; UE2.A34 260.08,64.54 259.88,64.75 259.52,64.75 259.38,64.89 259.38,65.88 v2(259.14,66.12)
  IN3 w0.122: v2(259.14,66.12) 259.24,66.22 260.33,66.22 260.87,65.68 262.94,65.68 263.22,65.4 263.22,64.2 263.54,63.88 263.93,63.88 264.43,63.38 265.52,63.38 265.7,63.56 266.05,63.56 266.78,62.83 270.41,62.83 271.02,62.22 276.33,62.22 276.6,61.95 276.6,59.77 v2(276.78,59.59)
  BOTTOM w0.102: v2(259.14,66.12) 258.79,66.12 257.7,67.21 254.44,67.21 254.21,66.98 250.49,66.98 249.66,66.16 249.66,65.29 251.65,63.3 251.65,61.82 252.03,61.45 252.03,59.65 251.77,59.39 251.38,59.39 249.51,57.52 248.16,57.52 247.69,57.05 247.69,54.58 246.85,53.74 v3(246.85,53.46) 246.85,51.83 248.32,50.36 248.32,50.1 247.69,49.47 247.69,47.46 247.69,46.82 v2(247.23,46.36)
PCH_BATLOW#: length 14.1
  TOP w0.102: RC72.1 167.85,46.35 v3(167.91,46.4) 167.91,48.62 167.87,48.66 167.87,49.02 167.87,53.71 166.67,54.91 166.67,56.39 166.1,56.95 166.1,57.71 165.87,57.94 v2(165.69,57.94)
  BOTTOM w0.076: v2(165.69,57.94) 165.98,57.65 UC1.AU13
PCH_CL_CLK1: length 136.5
  BOTTOM w0.102: JNGFF1.34 253.95,23.93 252.73,25.15 251.5,25.15 248.8,27.84 248.8,29.67 248.8,34.77 249.01,34.97 249.01,35.6 249.34,35.93 249.34,36.83 247.59,38.59 246,38.59 245.86,38.59 244.15,40.29 244.15,41.82 244.71,42.38 246.29,43.96 246.29,45.21 246.15,45.34 246.15,49.24 245.86,49.54 245.86,50.43 242.28,54 242.16,54 241.51,54.66 240.65,54.66 239.15,56.16 238.37,56.16 237.46,57.06 237.46,57.39 237.46,59.24 238.09,59.86 238.09,63.79 237.91,63.98 237.91,64.84 238.09,65.02 238.09,71.56 235.45,74.2 233.11,74.2 232.33,74.98 232.33,75.77 v3(231.86,76.24) 230.92,77.18 230.92,78.16 229.64,79.44 219.93,79.44 219.47,78.98 200.12,78.98 199.91,78.78 196.03,78.78 195.93,78.87 190.14,78.87 186.05,74.78 185.45,74.78 185.41,74.77 185.18,74.53 184.85,74.53 184.75,74.43 182.5,74.43 182.35,74.59 181.35,74.59 180.88,75.05 179.19,76.74 175.04,76.74 174.84,76.53 174.84,76.32 173.73,75.21 173.73,75.2 173.24,75.2 173.03,75 173.03,74.77 172.71,74.44 172.71,74.21 172.47,73.97 172.37,73.97 UC1.G3
PCH_CL_DATA1: length 134.8
  BOTTOM w0.102: UC1.G2 173.01,73.95 173.6,73.95 173.93,74.28 173.93,75.13 175.18,76.38 179.04,76.38 181.19,74.23 182.2,74.23 182.36,74.08 184.9,74.08 184.99,74.17 185.32,74.17 185.58,74.43 186.2,74.43 190.29,78.52 195.79,78.52 195.88,78.42 200.06,78.42 200.27,78.63 219.63,78.63 220.07,79.06 v3(220.97,79.06) 229.52,79.06 230.52,78.06 230.52,76.29 232.97,73.84 235.31,73.84 237.74,71.41 237.74,65.17 237.55,64.99 237.55,63.83 237.74,63.65 237.74,60.01 237.11,59.38 237.11,57.87 237.11,57.87 237.11,57.24 237.11,57.24 237.11,56.92 238.01,56.02 238.22,55.81 239,55.81 240.51,54.3 241.35,54.3 241.51,54.14 241.52,54.14 242.01,53.65 242.14,53.65 245.5,50.28 245.5,49.39 245.8,49.1 245.8,45.2 245.93,45.06 245.93,44.11 244.56,42.73 243.8,41.97 243.8,41.28 243.28,40.77 243.28,40.43 245.48,38.23 246.15,38.23 246.15,38.23 246.41,38.23 248.65,35.99 248.65,35.12 248.45,34.91 248.45,29.52 248.45,27.69 249.67,26.48 251.4,24.74 252.64,24.74 253.45,23.93 JNGFF1.32
PCH_CL_RST1#: length 137.1
  BOTTOM w0.102: JNGFF1.30 252.95,23.2 253.09,23.34 253.09,23.78 252.49,24.39 251.19,24.39 249.85,25.73 249.13,25.73 248.69,26.18 248.69,26.33 248.92,26.56 248.92,26.71 248.78,26.85 248.64,26.85 248.4,26.61 248.26,26.61 248.09,26.78 248.09,29.37 248.09,35.06 248.3,35.26 248.3,35.84 248.02,36.12 247.23,36.12 246.6,35.49 244.34,35.49 243.86,35.98 243.86,39.35 242.93,40.28 242.93,40.91 243.44,41.43 243.44,42.12 244.41,43.09 245.58,44.25 245.58,44.91 245.44,45.05 245.44,48.95 245.15,49.24 245.15,50.13 241.99,53.29 241.86,53.29 241.21,53.95 240.36,53.95 238.86,55.45 238.07,55.45 237.86,55.66 237.65,55.87 236.75,56.77 236.75,57.09 236.75,57.1 236.75,58.02 236.75,59.76 237.38,60.39 237.38,63.5 237.2,63.68 237.2,65.13 237.38,65.32 237.38,71.27 235.16,73.49 232.82,73.49 230.16,76.14 230.16,77.57 229.07,78.65 v3(222.67,78.65) 220.16,78.65 219.78,78.27 200.41,78.27 200.2,78.06 195.73,78.06 195.64,78.16 190.44,78.16 186.35,74.07 185.73,74.07 185.47,73.82 185.14,73.82 185.05,73.72 182.21,73.72 182.05,73.88 181.04,73.88 180.29,74.63 180.29,74.63 178.89,76.03 175.19,76.03 174.13,74.97 174.13,74.08 173.7,73.65 UC1.G1
PCH_DPWROK: length 136.3
  TOP w0.102: UE2.A36 259.92,63.54 259.65,63.81 v2(259.65,63.79) ; RC215.1 178.37,39.05 177.97,38.65 v3(177.61,38.65) 176.98,38.65 176.62,39.01 CC266.1 176.62,39.7 176.82,39.91 v2(176.82,40.39) 176.87,40.44 RC220.1
  IN2 w0.122: v2(259.65,63.79) 259.65,63.69 259.3,63.33 258.83,63.33 258.79,63.38 258.41,63.38 258.02,62.98 258.02,58.06 257.11,57.15 257.11,57.08 256.08,56.05 254.19,54.16 254.19,53.58 254.17,53.56 254.17,53.56 253.29,52.67 250.45,52.67 248.35,50.58 248.35,49.89 247.05,48.59 247.05,47.04 246.62,46.61 246.62,44.62 244.14,42.14 244.14,40.45 240.6,36.92 236.86,36.92 234.93,38.85 228.64,38.85 228.36,39.13 223.95,39.13 222.05,37.24 218.47,37.24 217.88,36.64 217.88,36.29 217.35,35.76 217.35,35.08 216.22,33.95 205.42,33.95 204.87,34.5 195.2,34.5 188.35,41.36 187.64,41.36 187.63,41.36 187.22,41.36 178.02,41.36 177.05,40.39 v2(176.82,40.39)
  BOTTOM w0.076: UC1.BB20 162.42,54.5 162.42,53.31 164.51,51.23 164.51,50.83
  BOTTOM w0.102: v2(176.82,40.39) 174.87,42.35 170.75,42.35 164.96,48.14 164.96,50.39 164.51,50.83
PCH_JTAG_TCK: length 85.9
  TOP w0.102: RC86.2 132.28,85.2 132.28,83.35 131.77,82.83 131.77,81.18 ; v2(140.19,80.52) 140.19,81.12 139.64,81.67 139.15,81.67 138.66,81.19 137.44,81.19 136.58,80.33 v3(135.91,80.33) 135.91,80.33 134.83,81.41 132.13,81.41 131.91,81.18 131.77,81.18 ; 131.77,81.18 v2(131.76,81.17) ; v2(93.5,40.62) 93.11,41 JXDP1.55
  IN1 w0.089: v2(129.04,73.05) 129.03,73.04 129.03,72.18 128.5,71.65 128.5,70.43 113.23,55.16 113.23,53.25 106.17,46.2 100.44,46.2 98.45,44.21 94.43,44.21 93.23,43.02 93.23,40.88 v2(93.5,40.62)
  IN4 w0.089: v2(131.76,81.17) 131.76,81.13 131,80.37 129.36,80.37 129.35,80.37 129.06,80.37 128.55,79.86 128.55,79.57 128.29,79.3 128.29,75.23 129.03,74.49 129.03,73.24 129.04,73.23 v2(129.04,73.05)
  BOTTOM w0.076: v2(140.19,80.52) 140.65,80.06 140.65,78.85 141.37,78.12 141.37,77.52 141.18,77.33 141.18,77.05 141.24,76.94 141.45,76.73 UC1.B56
PCH_JTAG_TDI: length 76.2
  TOP w0.102: RC229.2 106.87,39.61 v3(109.91,42.65) 111.24,42.65 116.96,48.37 116.96,54.51 116.96,54.7 124.16,61.9 124.16,62.82 124.84,63.5 126.13,63.5 130.97,68.35 130.97,71.07 132.07,72.17 132.22,72.17 132.98,72.93 132.98,73.07 134.61,74.69 134.61,74.81 135.64,75.85 135.85,75.85 137.55,77.55 138.18,77.55 138.52,77.89 138.52,77.97 138.91,78.36 139.22,78.36 140.13,79.28 140.43,79.28 141.31,80.16 v2(141.31,80.57) 141.31,82.57 142.43,83.69 142.43,85.87 142.83,86.27 v2(142.83,86.81)
  BOTTOM w0.076: UC1.D59 140.31,75.54 140.39,75.8 140.39,75.92 140.47,76.2 140.51,76.35 140.52,76.37 140.53,76.39 140.53,76.64 140.5,76.7 140.5,76.96 140.51,76.99 140.53,77.01 140.53,77.44 140.41,77.55 140.41,78.48 140.41,78.62 139.98,79.06 139.98,79.34 139.75,79.56 139.75,80.6 140.04,80.89 140.99,80.89 v2(141.31,80.57)
  BOTTOM w0.102: v2(142.83,86.81) 142.22,86.81 141.95,86.53 RC81.2
PCH_JTAG_TDO: length 77.6
  TOP w0.102: RC230.2 104.14,37.79 v3(104.69,38.33) 107.57,38.33 117.42,48.18 117.42,54.46 124.67,61.71 130.67,61.71 132.36,63.4 132.36,63.73 131.72,64.37 131.48,64.61 131.48,70.08 133.57,72.17 133.57,72.88 135.19,74.5 135.19,74.75 135.83,75.39 136.23,75.39 137.85,77.01 138.7,77.01 139.41,77.71 139.41,78.23 140.23,79.05 140.53,79.05 142.17,80.69 v2(142.17,82.66)
  BOTTOM w0.076: 140.36,81.74 140.36,81.44 140.68,81.12 141.32,81.12 141.68,80.75 141.68,80.33 140.99,79.65 140.99,79.02 141.55,78.46 141.55,77.26 UC1.A56
  BOTTOM w0.102: 140.36,81.74 140.36,82.01 141,82.66 v2(142.17,82.66) 142.74,83.22 142.74,83.22 142.81,83.29 RC82.2
PCH_JTAG_TMS: length 68.1
  TOP w0.102: RC228.2 103.91,42.68 104.64,41.95 106.85,41.95 109.12,44.22 v3(110.94,44.22) 111.85,44.22 116.28,48.66 116.28,54.23 116.28,54.23 116.28,54.99 123.48,62.19 123.48,63.11 124.56,64.19 125.85,64.19 130.29,68.63 130.29,71.35 131.56,72.62 131.56,73.3 131.85,73.59 132.18,73.59 133.11,74.51 133.11,75.04 134.73,76.66 135.54,76.66 136.45,77.57 136.45,77.73 138.7,79.99 v2(138.85,79.99)
  BOTTOM w0.076: UC1.C59 140.28,76.17 140.36,76.42 140.36,76.59 140.33,76.71 140.33,76.98 140.36,77.05 140.36,77.32 140.25,77.43 140.25,78.55 139.81,78.99 139.81,79.27 139.09,79.99 138.86,79.99
  BOTTOM w0.102: v2(138.85,79.99) 138.86,79.99 138.86,80.17 139.16,80.47 139.37,80.47 139.88,80.98 139.88,81.87 141.3,83.29 RC130.2
PCH_PCIE_WAKE#: length 158
  TOP w0.102: v2(219.8,44.66) 219.8,44.91 219.57,45.14 219.29,45.14 219.11,45.32 219.11,46.1 RC67.2 ; UE2.B46 261.91,59.79 v2(261.99,59.72)
  IN1 w0.089: v2(254.29,52.28) 251.5,52.28 248.92,49.7 248.92,48.27 248.63,47.98 248.09,47.98 247.33,47.22 247.33,47.2 246.42,46.28 246.42,45.6 245.75,44.93 245.75,44.48 244.96,43.69 244.36,43.69 243.67,43.01 241.67,43.01 240.69,42.04 238.6,42.04 238.52,42.12 237.36,42.12 235.23,42.12 234.65,41.54 229.8,41.54 229.6,41.74 224.94,41.74 222.73,43.95 220.48,43.95 219.96,44.46 219.96,44.49 v2(219.8,44.66)
  IN2 w0.122: v2(252.13,57.97) 252.13,58.5 251.12,59.51 251.12,60.64 251.52,61.04 251.52,64.02 251.52,64.44 251.98,64.91 251.98,66.62 251.96,66.65 251.96,73.16 251.37,73.75 251.37,75.29 251.24,75.42 251.24,77.4 250.67,77.97 250.67,79.85 250.64,79.89 250.64,85.96 v2(250.66,85.98)
  IN4 w0.089: v2(252.13,57.97) 252.82,57.97 254.63,56.15 259.97,56.15 261.03,57.21 261.03,58.85 261.9,59.72 v2(261.99,59.72)
  BOTTOM w0.076: 169.26,49.48 169.05,49.69 169.05,50.21 167.3,51.96 166.62,51.96 164.73,53.86 164.73,54.45 UC1.BB15
  BOTTOM w0.102: v2(252.13,57.97) 251.8,57.64 251.8,56.45 254.29,53.96 v2(254.29,52.28) ; v2(219.8,44.66) 219.8,44.75 218.93,45.62 217.89,45.62 217.02,44.75 206.62,44.75 205.15,43.27 180.49,43.27 176.78,46.98 171.76,46.98 169.26,49.48 ; RE274.2 250.05,87.03 250.05,86.38 250.45,85.98 v2(250.66,85.98)
PCH_PLTRST#: length 38.5
  IN2 w0.122: v2(186.3,68.43) 186.3,68.24 184.6,66.54 182.73,66.54 181.34,65.15 181.15,65.15 180.62,64.62 180.35,64.34 180.35,59.6 177.92,57.18 177.92,57.05 177.75,56.88 177.75,56 177.07,55.32 173.93,55.32 171.02,58.22 170.04,58.22 169.72,58.54 169.72,59.35 169.49,59.58 168.72,59.58 v2(168.41,59.88)
  BOTTOM w0.102: RC64.2 RC244.2 187.41,69.63 RC60.2 186.88,69.55 RC61.2 ; RC62.2 RC61.2 ; RC61.2 186.37,68.51 v2(186.3,68.43) 186.79,67.94 UC7.1 188.36,67.94 188.54,67.76 v1(188.54,67.58) 188.54,67.46 188.36,67.29 UC7.2
  BOTTOM w0.254: v2(168.41,59.88) 168.05,60.25 UC1.AN10
PCH_PLTRST#_AND: length 221.3
  TOP w0.102: CZ68.1 261.45,11.33 v2(260.98,10.85) ; UR2.1 263.92,44.28 264.59,44.95 v2(264.66,44.95) ; RZ114.1 263.93,14.9 v2(264.48,14.9)
  IN1 w0.089: v2(257.21,21.24) 257.69,20.76 259.4,20.76 v2(259.8,21.16) 260.9,22.25 263.24,22.25 264.25,23.27 265.29,23.27 266,22.56 v2(267.58,22.56) ; v2(188.72,50.05) 188.95,50.28 189.58,50.28 190.03,49.83 190.03,49.17 191.09,48.11 191.09,46.92 191.92,46.09 202.67,46.09 204.44,47.86 205.51,47.86 205.69,48.05 206,48.05 206.63,47.42 208.67,47.42 209.18,46.91 213.82,46.91 214.52,46.21 214.99,46.21 215.85,45.35 220.61,45.35 220.68,45.27 220.69,45.27 221.11,44.85 223.11,44.85 225.07,42.88 231.84,42.88 232.69,43.73 235.2,43.73 237.08,43.73 237.58,44.23 238.7,44.23 239.8,45.32 243.43,45.32 243.57,45.47 244.02,45.47 244.02,45.47 244.2,45.47 244.36,45.3 245.14,45.3 245.43,45.6 245.43,47.15 246.16,47.88 246.34,47.88 v2(246.56,48.1) ; v2(254.44,2.8) 254.67,3.03 254.67,8.84 257.29,11.46 260.37,11.46 v2(260.98,10.85) 261.15,10.85 262.8,12.5 262.8,12.64 264.48,14.32 v2(264.48,14.9)
  IN2 w0.122: v2(260.98,10.85) 260.98,12.11 260.1,12.99 260.1,16.48 259.21,17.36 259.21,20.11 259.5,20.4 259.5,20.86 v2(259.8,21.16)
  IN3 w0.122: v2(264.66,44.95) 264.66,44.18 265.03,43.81 265.03,40.43 263.39,38.79 263.39,36.8 264.29,35.89 264.29,35.65 264.39,35.56 264.39,33.94 v2(263.47,33.02) 263.19,32.74 263.19,31.47 265.62,29.04 265.62,25.3 266.15,24.77 266.15,24.27 267.58,22.84 v2(267.58,22.56)
  IN4 w0.089: v2(263.47,33.02) 263.47,33.21 262.25,34.43 262.25,35.94 262.45,36.14 262.45,36.72 258.91,40.26 258.33,40.26 256.96,41.63 256.96,43.3 255.4,44.86 248.37,44.86 247.81,45.42 247.81,47.12 247.49,47.44 247.49,47.67 247.06,48.1 v2(246.56,48.1)
  BOTTOM w0.102: JNGFF1.58 259.95,21.31 v2(259.8,21.16) ; v2(188.72,50.05) 188.92,50.25 188.92,50.48 188.67,50.72 188.67,51.77 188.67,52.28 188.66,52.76 188.45,53.74 188.3,54.09 188.1,54.57 188.1,54.88 187.49,55.48 186.9,56.06 186.75,56.21 186.75,58.57 187.26,59.08 187.26,62.76 187.56,63.06 187.56,63.71 186.78,64.49 186.22,64.49 RC325.2 186.02,65.09 186.25,65.32 186.73,65.32 RC65.1 187.04,66.21 186.61,66.64 UC7.4 ; v2(246.56,48.1) 246.56,49.45 246.24,49.77 246.24,50.55 244.54,52.25 244.54,55.74 247.01,58.21 249.22,58.21 250.98,59.97 250.98,61.48 250.61,61.85 250.06,61.85 249.16,62.75 249.16,64.26 247.6,65.82 244.77,65.82 243.8,64.85 243.19,64.85 242.74,65.3 JNGFF2.42 ; v2(254.44,2.8) 254.3,2.65 JNGFF3.50 ; v2(257.21,21.24) 257.03,21.42 256.77,21.42 256.45,21.75 JNGFF1.44
