# Allegro board LAC621PR10-0924-A.brd (continued)
## Nets (continued)
HUB_DP1_P3_C: C308.2 R258.2
HUB_DP1_P3_R: JDOCK1.28 R258.1
HUB_DP1_SCL: RPV1.1 UV8.K13 UV11.12
HUB_DP1_SDA: RPV1.2 UV8.L14 UV11.9
HUB_GPIO4: RV518.2 UV8.B14
HUB_GPIO5: RV519.2 UV8.B13
HUB_GPIO6: RV83.1 UV8.C1
HUB_GPIO7: RPV1.4 UV8.M12
HUB_GPIO8: RPV1.3 UV8.M13
HUB_GPIO9: RV73.1 UV8.L3
HUB_LP_EN: UV8.A5 UV28.4 UV29.9
HUB_SPI_CLK: UV8.B3 UV9.6
HUB_SPI_CS#: RV86.2 UV8.A4 UV9.1
HUB_SPI_DIN: UV8.B4 UV9.2
HUB_SPI_DO: UV8.A3 UV9.5
HUB_SPI_HOLD: RV87.2 UV9.7
HUB_SPI_WP#: RV517.2 UV8.B1 UV9.3
HUB_SRCDET: RV84.1 UV8.C2
HUB_SW1_AUXN: JDOCK1.35 UV12.6 UV12.8
HUB_SW1_AUXP: JDOCK1.33 UV12.3 UV12.11
HUB_SW2_AUXN: JDOCK1.36 UV11.6 UV11.8
HUB_SW2_AUXP: JDOCK1.34 UV11.3 UV11.11
HUB_VGA_BLUE: RV78.1 UV8.M8 UV16.5
HUB_VGA_DET: RV88.2 UV8.M3
HUB_VGA_GREEN: RV77.1 UV8.M7 UV16.2
HUB_VGA_HSYNC: UV8.M9 UV16.6
HUB_VGA_IREF: RV89.1 UV8.M5
HUB_VGA_NC: T108.1(TP-1) UV8.L5
HUB_VGA_RED: RV76.1 UV8.M6 UV16.1
HUB_VGA_SCL: RV251.2 UV8.L4 UV16.10
HUB_VGA_SDA: RV250.2 UV8.M4 UV16.9
HUB_VGA_VSYNC: UV8.L9 UV16.7
HW_GPS_DISABLE#: DZ6.1 RE12.2 UE1.A35
HW_GPS_DISABLE#_R: DZ6.2 JNGFF2.18
I2C_1_SCL: RZ21.2 RZ29.2 UC1.U9
I2C_1_SCL_R: JKBTP1.19 RZ29.1 RZ117.2
I2C_1_SDA: RZ20.2 RZ26.2 UC1.U8
I2C_1_SDA_R: JKBTP1.18 RZ26.1 RZ116.2
I2C_HUB_SCL: RPV2.2 UV8.A2
I2C_HUB_SDA: RPV2.1 UV8.A1
I2S_BCLK: RA31.2 UA1.16
I2S_DO: RA32.2 UA1.17
I2S_MCLK: RA30.2 UA1.15
I_ADP: PR816.1 UE2.A12
I_BATT: PR819.1 RE64.2
I_SYS: PR620.1 PR820.1 RE312.2
IFDET_SATA#_PCIE: JNGFF3.61 RPC4.3 UC1.G4 UN4.20 UN5.20
ILIM_SEL: RI13.1 UI3.4
ILMT_+1VALWP: PR307.2 PR310.1 PU301.3
IMON_IA: PC625.2 PR629.2 PU602.14
IMON_VSA: PC643.1 PR651.1 PU602.23
IMVP_VR_ON: PR616.1 RE304.1 UE3.4 UE4.2
IMVP_VR_ON_EC: RE304.2 UE2.A1 UE3.1
INT_SPK_L+: CA22.1 LA6.1 UA1.42
INT_SPK_L-: CA23.1 LA7.1 UA1.43
INT_SPK_R+: CA19.1 LA8.1 UA1.45
INT_SPK_R-: CA24.1 LA9.1 UA1.44
INT_SPKR_L+: DA6.3 JSPK1.1 LA6.2
INT_SPKR_L-: DA6.2 JSPK1.2 LA7.2
INT_SPKR_R+: DA7.3 JSPK1.3 LA8.2
INT_SPKR_R-: DA7.2 JSPK1.4 LA9.2
INTRUDER#: RC69.1 UC1.AP16
IR_CAM_DET#: JIR1.1 RC346.1 UC1.AW7
IRQ_SERIRQ: RC21.2 UC1.AY11 UE1.B21 UE2.A28
ISH_I2C2_SCL: RZ76.1 UC1.AD12
ISH_I2C2_SCL_R: JNGFF2.32 RZ76.2
ISH_I2C2_SDA: RZ77.1 UC1.AD11
ISH_I2C2_SDA_R: JNGFF2.34 RZ77.2
ISH_UART0_CTS#: RZ80.1 UC1.U4
ISH_UART0_CTS#_R: JNGFF1.54 RZ80.2
ISH_UART0_RTS#: RZ81.1 UC1.U3
ISH_UART0_RTS#_R: JNGFF1.56 RZ81.2
ISH_UART0_RXD: RZ78.1 UC1.U1
ISH_UART0_RXD_R: JNGFF1.50 RZ78.2
ISH_UART0_TXD: RZ79.1 UC1.U2
ISH_UART0_TXD_R: JNGFF1.52 RZ79.2
ISUMN_GT: PC624.2 PC626.2 PC641.1 PH602.2 PL604.2 PR632.1 PR633.2 PR638.1
ISUMN_IA: PC642.2 PC645.1 PC646.2 PH605.2 PL603.2 PR640.2 PR644.2 PR656.2
ISUMP_GT: PC624.1 PC626.1 PR628.1 PR633.1 PR674.1 PU602.7
ISUMP_IA: PC642.1 PC646.1 PR656.1 PR657.1 PR661.2 PU602.19
ISUMP_VSA: PC633.1 PC637.1 PR624.2 PR642.1 PR643.2 PU602.27
ITP_PMODE: JXDP1.46 RC115.1 UC1.E8
JCRT-11: JCRT1.11 T87.1(TP-1)
JDIMM1_EVENT#: JDIMM1.134 RD61.1
JDIMM2_EVENT#: JDIMM2.134 RD4.1
JTAG_CLK: JDEG1.4 RPE7.3 UE2.B56
JTAG_RST#: CE30.1 JTAG1.1 RE63.2 RE65.1 UE2.B47
JTAG_TDI: JDEG1.2 RPE7.1 UE2.A51
JTAG_TDO: JDEG1.5 RPE7.4 UE2.B55
JTAG_TMS: JDEG1.3 RPE7.2 UE2.A53
KB_DET#: JKBTP1.1 RC288.1 UC1.BB7
LAN_ACTLED_YEL#: QL1.6 RL14.1
LAN_ACTLED_YEL_R#: JLOM1.10 RL14.2
LAN_DISABLE#_R: RL5.2 RL7.2 RL9.1 UE1.B53 UL1.3
LAN_MDIN0: RL72.1 UL1.14
LAN_MDIN0_L: RL72.2 UL4.11
LAN_MDIN1: RL74.1 UL1.18
LAN_MDIN1_L: RL74.2 UL4.9
LAN_MDIN2: RL76.1 UL1.21
LAN_MDIN2_L: RL76.2 UL4.6
LAN_MDIN3: RL78.1 UL1.24
LAN_MDIN3_L: RL78.2 UL4.2
LAN_MDIP0: RL71.1 UL1.13
LAN_MDIP0_L: RL71.2 UL4.12
LAN_MDIP1: RL73.1 UL1.17
LAN_MDIP1_L: RL73.2 UL4.10
LAN_MDIP2: RL75.1 UL1.20
LAN_MDIP2_L: RL75.2 UL4.7
LAN_MDIP3: RL77.1 UL1.23
LAN_MDIP3_L: RL77.2 UL4.3
LAN_TEST_EN: RL12.1 UL1.30
LAN_WAKE#: RC323.2 RL70.2 UC1.AM15 UE2.B27 UL1.2
LCD_CBL_DET#: JEDP1.40 RC287.1 UC1.AC3
LCD_TST: JEDP1.29 RE20.2 UE1.A36
LCD_VCC_TEST_EN: DV3.2 UE1.A40
LED_10_GRN#: QL2.6 RL19.1
LED_10_GRN_R#: JLOM1.11 RL19.2
LED_100_ORG#: QL1.3 RL20.1
LED_100_ORG_R#: JLOM1.13 RL20.2
LED_SATA_DIAG_OUT#: DZ4.1 UE1.A10
LID_CL#: JLED1.7 RE26.1 UZ10.2
LID_CL_SIO#: CE8.1 RE25.2 RE26.2 UE1.B54
LOM_ACTLED_YEL#: UL1.26 UL4.15
LOM_SPD10LED_GRN#: UL1.25 UL2.2 UL4.42
LOM_SPD100LED_ORG#: UL1.27 UL2.1 UL4.16
LPC_LAD0: JLPDE1.3 UC1.AY13 UE1.A27 UE2.A30
LPC_LAD1: JLPDE1.4 UC1.BA13 UE1.A26 UE2.B32
LPC_LAD2: JLPDE1.5 UC1.BB13 UE1.B26 UE2.A31
LPC_LAD3: JLPDE1.6 UC1.AY12 UE1.B25 UE2.B33
LPC_LDRQ1#: RPE8.1 UE1.A22
LPC_LFRAME#: JLPDE1.7 UC1.BA12 UE1.A21 UE2.B31
LPSS_UART2_RXD: JUART1.3 RC330.2 RC336.2 UC1.AD1
LPSS_UART2_TXD: JUART1.2 RC331.2 RC335.2 UC1.AD2
LX_1.8VALW: PL501.1 PR502.1 PU501.3
LX_1V_PRIM: PL404.1 PR409.1 PU402.2 PU402.3
LX_1VS_VCCIO: PL402.1 PR405.1 PU401.2 PU401.3
LX_3V: PC102.2 PL100.1 PR106.1 PU100.6 PU100.19 PU100.20
LX_5V: PC114.2 PL101.1 PR112.1 PU102.6 PU102.19 PU102.20
M2_DEVSLP: JNGFF3.38 RN37.2 UC1.J3
M_ID2#: CV57.1 JCRT1.4
MASK_BASE_LEDS#: QZ7.5 UZ10.4
MASK_SATA_LED#: QZ3.5 UE1.B9
MCARD_PCIE#_SATA: T131.1(TP-1) UE2.B8
ME_FWP: RC221.1 RC223.1 SW1.3
ME_FWP_EC: RC221.2 SW1.1 UE1.A64
ME_RESET#: RC225.2 RC227.1 UC12.2
ME_SUS_PWR_ACK: RC74.2 UC1.AR13 UE2.A8
MEC_XTAL1: CE28.1 UE2.A61 YE1.1
MEC_XTAL2: CE29.1 RE290.2 YE1.2
MEC_XTAL2_R: RE290.1 UE2.A62
MEDIACARD_IRQ#: RR19.2 UC1.M1 UR2.32
MEM_SMBCLK: QC2.6 RC12.1 UC1.R7
MEM_SMBDATA: QC2.3 RC14.1 UC1.R8
MIC1_L: CA43.1 UA1.19
MIC1_R: CA44.1 UA1.20
MPHYP_PWR_EN: RZ83.2 UC1.AM10
MSCLK: JDEG1.6 RE72.2 UE2.B43
MSDATA: JDEG1.7 RE75.2 RE86.2 UE2.A40
NB_PSID: PD6.2 PD6.3 PJPDC1.5 PL4.2
NB_PSID_TS5A63157: PR6.1 PR7.2 PU1.3
NON_DOCK: RH359.1 UC1.AY7
NRB_BIT: RC186.2 UC1.AR7
NTC_IA: PR635.2 PU602.15
NVME_LED#: JNGFF3.10 RZ118.2
ONE_DIMM#: RC267.2 RC268.1 UC1.M2
P33ALW: PR931.1 PU901.18
P33ALW2: PR932.2 PU901.9
P50ALW: PR937.1 PU901.27
PANEL_BKEN_EC: DV2.2 UE1.B38
PANEL_BKLEN: DV2.3 UC1.R12
PANEL_ID: CE47.1 RE300.2 UE2.A10
PBAT_PRES#: PD2.3 PD4.1 PR3.2 PR828.1 PRP1.1 PU902.1 UE2.A49
PBAT_PRES#_C: PBATT1.6 PRP1.8
PBAT_SMBCLK: PD3.3 PRP1.3 RPE13.8 UE2.A56
PBAT_SMBCLK_C: PBATT1.4 PRP1.6
PBAT_SMBDAT: PD2.2 PRP1.2 RPE13.7 UE2.B59
PBAT_SMBDAT_C: PBATT1.5 PRP1.7
PBATT+_C: PBATT1.1 PBATT1.2 PBATT1.3 PC3.1 PL2.1 PL3.1
PCH_ALW_ON: RPE10.4 RZ65.1 UE2.A34
PCH_BATLOW#: RC72.1 UC1.AU13
PCH_CL_CLK1: JNGFF1.34 UC1.G3
PCH_CL_DATA1: JNGFF1.32 UC1.G2
PCH_CL_RST1#: JNGFF1.30 UC1.G1
PCH_DPWROK: CC266.1 RC215.1 RC220.1 UC1.BB20 UE2.A36
PCH_JTAG_TCK: JXDP1.55 RC86.2 UC1.B56
PCH_JTAG_TDI: RC81.2 RC229.2 UC1.D59
PCH_JTAG_TDO: RC82.2 RC230.2 UC1.A56
PCH_JTAG_TMS: RC130.2 RC228.2 UC1.C59
PCH_PCIE_WAKE#: RC67.2 RE274.2 UC1.BB15 UE2.B46
PCH_PLTRST#: RC60.2 RC61.2 RC62.2 RC64.2 RC244.2 UC1.AN10 UC7.1 UC7.2
PCH_PLTRST#_AND: CZ68.1 JNGFF1.44 JNGFF1.58 JNGFF2.42 JNGFF3.50 RC65.1 RC325.2 RZ114.1 UC7.4 UR2.1
PCH_PLTRST#_AND_R: JUSH1.6 RZ114.2 RZ115.2
PCH_PLTRST#_EC: JLPDE1.8 RC244.1 UE2.B30
PCH_POPIRCOMP: RC89.1 UC1.AU16
PCH_PWROK: PR614.1 UC1.BA20
PCH_RSMRST#: RE88.1 UE2.A45 UZ6.1
PCH_RSMRST#_Q: RC75.2 RC124.1 RC215.2 UC1.AY17 UZ6.4
PCH_RTCRST#: CC25.1 CMOS1.1 JAPS1.9 RC57.1 UC1.AM16
PCH_RTCX1: CC23.2 RC54.2 UC1.AM18 YC2.1
PCH_RTCX2: RC54.1 RC296.1 UC1.AM20
PCH_RTCX2_R: CC26.2 RC296.2 YC2.2
PCH_SATA_LED#: QZ3.4 RPC4.2 RZ118.1 UC1.H1
PCH_SMB_ALERT#: RC23.2 UC1.R10
PCH_SPI_CLK: JSPI1.13 RC35.2 UC1.AV2
PCH_SPI_CLK_0_R: RC29.2 RPC1.6 UC5.6
PCH_SPI_CLK_1_R: RC28.2 RPC2.7 UC6.6
PCH_SPI_CLK_2_R: RZ60.2 RZ63.2 UZ12.19
PCH_SPI_CLK_R1: JSPI1.14 RC35.1 RPC1.3 RPC2.2 RZ60.1
PCH_SPI_CS#0: JSPI1.11 RC36.2 UC1.AU3
PCH_SPI_CS#0_R1: JSPI1.12 RC36.1 RC37.1
PCH_SPI_CS#0_R2: RC37.2 UC5.1
PCH_SPI_CS#1: JSPI1.19 RC32.2 UC1.AU2
PCH_SPI_CS#1_R1: JSPI1.20 RC32.1 RC42.1
PCH_SPI_CS#1_R2: RC42.2 UC6.1
PCH_SPI_CS#2: RZ61.1 UC1.AU1
PCH_SPI_CS#2_R: RZ61.2 RZ110.1 RZ113.1 UZ12.20
PCH_SPI_D0: JSPI1.17 RC10.2 RC33.2 UC1.AV3
PCH_SPI_D0_0_R: RPC1.7 UC5.5
PCH_SPI_D0_1_R: RPC2.6 UC6.5
PCH_SPI_D0_2_R: RZ59.2 UZ12.21
PCH_SPI_D0_R1: JSPI1.18 RC33.1 RPC1.2 RPC2.3 RZ59.1
PCH_SPI_D1: JSPI1.15 RC34.2 UC1.AW3
PCH_SPI_D1_0_R: RPC1.8 UC5.2
PCH_SPI_D1_1_R: RPC2.5 UC6.2
PCH_SPI_D1_2_R: RZ58.2 UZ12.24
PCH_SPI_D1_R1: JSPI1.16 RC34.1 RPC1.1 RPC2.4 RZ58.1
PCH_SPI_D2: JSPI1.9 RC11.2 RC38.2 UC1.AW2
PCH_SPI_D2_0_R: RC39.2 UC5.3
PCH_SPI_D2_1_R: RC43.2 UC6.3
PCH_SPI_D2_R1: JSPI1.10 RC30.2 RC38.1 RC39.1 RC43.1
PCH_SPI_D3: JSPI1.7 RC40.2 UC1.AU4
PCH_SPI_D3_0_R: RPC1.5 UC5.7
PCH_SPI_D3_1_R: RPC2.8 UC6.7
PCH_SPI_D3_R1: JSPI1.8 RC31.2 RC40.1 RC316.2 RPC1.4 RPC2.1
PCH_SPI_DO2_XDP: JXDP1.60 RC11.1
PCH_SPI_DO_XDP: RC10.1 RC128.1 RC133.2
PCI_CLK_LPC0: RC16.1 RC18.1 UC1.AW9
PCI_CLK_LPC1: RC22.1 RC24.1 UC1.AY9
PCIE_PRX_C_DTX_N9: CL2.1 UL1.39
PCIE_PRX_C_DTX_N10: CR27.2 UR2.8
PCIE_PRX_C_DTX_N11: JNGFF3.29 RN82.1
PCIE_PRX_C_DTX_N12: JNGFF3.43 RN78.1
PCIE_PRX_C_DTX_P9: CL1.1 UL1.38
PCIE_PRX_C_DTX_P10: CR26.2 UR2.7
PCIE_PRX_C_DTX_P11: JNGFF3.31 RN81.1
PCIE_PRX_C_DTX_P12: JNGFF3.41 RN77.1
PCIE_PRX_C_RD_DTX_N11: CN34.2 UN5.4
PCIE_PRX_C_RD_DTX_N12: CN24.2 UN4.4
PCIE_PRX_C_RD_DTX_P11: CN33.2 UN5.5
PCIE_PRX_C_RD_DTX_P12: CN23.2 UN4.5
PCIE_PRX_DTX_N3: JNGFF2.33 UC1.H16
PCIE_PRX_DTX_N5: JNGFF1.35 UC1.F16
PCIE_PRX_DTX_N6: JNGFF1.59 UC1.G18
PCIE_PRX_DTX_N9: CL2.2 UC1.E22
PCIE_PRX_DTX_N10: CR27.1 UC1.F25
PCIE_PRX_DTX_N11: CN34.1 UC1.E28
PCIE_PRX_DTX_N12: CN24.1 UC1.E30
PCIE_PRX_DTX_P3: JNGFF2.35 UC1.G16
PCIE_PRX_DTX_P5: JNGFF1.33 UC1.E16
PCIE_PRX_DTX_P6: JNGFF1.57 UC1.F18
PCIE_PRX_DTX_P9: CL1.2 UC1.E23
PCIE_PRX_DTX_P10: CR26.1 UC1.E25
PCIE_PRX_DTX_P11: CN33.1 UC1.E27
PCIE_PRX_DTX_P12: CN23.1 UC1.F30
PCIE_PRX_RD_DTX_N11: RN82.2 UN5.15
PCIE_PRX_RD_DTX_N12: RN78.2 UN4.15
PCIE_PRX_RD_DTX_P11: RN81.2 UN5.14
PCIE_PRX_RD_DTX_P12: RN77.2 UN4.14
PCIE_PTX_C_DRX_N3: CZ58.2 JNGFF2.39
PCIE_PTX_C_DRX_N5: CZ14.2 JNGFF1.29
PCIE_PTX_C_DRX_N6: CZ22.2 JNGFF1.53
PCIE_PTX_C_DRX_N9: CL6.2 UL1.42
PCIE_PTX_C_DRX_N10: CR25.2 UR2.4
PCIE_PTX_C_DRX_N11: CN36.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN26.1 JNGFF3.47
PCIE_PTX_C_DRX_P3: CZ59.2 JNGFF2.41
PCIE_PTX_C_DRX_P5: CZ13.2 JNGFF1.27
PCIE_PTX_C_DRX_P6: CZ21.2 JNGFF1.51
PCIE_PTX_C_DRX_P9: CL5.2 UL1.41
PCIE_PTX_C_DRX_P10: CR24.2 UR2.3
PCIE_PTX_C_DRX_P11: CN35.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN25.1 JNGFF3.49
PCIE_PTX_C_RD_DRX_N11: CN31.2 UN5.2
PCIE_PTX_C_RD_DRX_N12: CN22.2 UN4.2
PCIE_PTX_C_RD_DRX_P11: CN32.2 UN5.1
PCIE_PTX_C_RD_DRX_P12: CN21.2 UN4.1
PCIE_PTX_DRX_N3: CZ58.1 UC1.D17
PCIE_PTX_DRX_N5: CZ14.1 UC1.C19
PCIE_PTX_DRX_N6: CZ22.1 UC1.D20
PCIE_PTX_DRX_N9: CL6.1 UC1.B23
PCIE_PTX_DRX_N10: CR25.1 UC1.D23
PCIE_PTX_DRX_N11: CN31.1 UC1.D24
PCIE_PTX_DRX_N12: CN22.1 UC1.A25
PCIE_PTX_DRX_P3: CZ59.1 UC1.C17
PCIE_PTX_DRX_P5: CZ13.1 UC1.D19
PCIE_PTX_DRX_P6: CZ21.1 UC1.C20
PCIE_PTX_DRX_P9: CL5.1 UC1.A23
PCIE_PTX_DRX_P10: CR24.1 UC1.C23
PCIE_PTX_DRX_P11: CN32.1 UC1.C24
PCIE_PTX_DRX_P12: CN21.1 UC1.B25
PCIE_PTX_RD_DRX_N11: CN36.2 UN5.17
PCIE_PTX_RD_DRX_N12: CN26.2 UN4.17
PCIE_PTX_RD_DRX_P11: CN35.2 UN5.18
PCIE_PTX_RD_DRX_P12: CN25.2 UN4.18
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.47 JNGFF1.62 JNGFF2.46 JNGFF3.54 RE274.1 RE275.1
PCIE_WAKE#_R: RE35.2 RE275.2 UE1.B10
PD_ACE_DET#: RE310.2 UE1.A60
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE2.A48
PGOOD_3V: PR107.2 PR119.1 PU100.9 PU101.1
PGOOD_5V: PR113.2 PR120.1 PU101.2 PU102.9
PLTRST_5048#: RC64.1 UE1.B22
PLTRST_LAN#: RC62.1 UL1.36
PLTRST_TPM#: RC60.1 RC325.1 UZ12.17
PLTRST_VMM2320#: RC61.1 UV8.A13
PM_LANPHY_ENABLE: RL7.1 UC1.AW17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: JUSH1.23 RPE5.3 UE2.B68
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE2.B67
PROCHOT_GATE: RE311.2 UE1.A61
PS_ID: PU1.4 UE2.B24
PSID_DISABLE#: PR11.2 UE1.A37
PWM1_GT: PR680.1 PU602.12 PU605.8
PWM_IA: PR662.1 PU602.22 PU603.8
PWM_VSA: PU602.30 PU606.3
RD1_A_DE0: RN25.2 RN38.1 UN4.6
RD1_A_DE1: RN26.2 RN39.1 UN4.8
RD1_A_EQ0: RN42.2 RN45.1 UN4.23
RD1_A_EQ1: RN43.2 RN46.1 UN4.22
RD1_A_EQ2: RN44.2 RN47.1 UN4.19
RD1_B_DE0: RN27.2 RN40.1 UN4.13
RD1_B_DE1: RN28.2 RN41.1 UN4.9
RD1_B_EQ0: RN49.2 RN52.1 UN4.11
RD1_B_EQ1: RN50.2 RN53.1 UN4.21
RD1_B_EQ2: RN51.2 RN54.1 UN4.16
RD1_REXT: RN30.1 UN4.10
RD2_A_DE0: RN55.2 RN59.1 UN5.6
RD2_A_DE1: RN56.2 RN60.1 UN5.8
RD2_A_EQ0: RN63.2 RN66.1 UN5.23
RD2_A_EQ1: RN64.2 RN67.1 UN5.22
RD2_A_EQ2: RN65.2 RN68.1 UN5.19
RD2_B_DE0: RN57.2 RN61.1 UN5.13
RD2_B_DE1: RN58.2 RN62.1 UN5.9
RD2_B_EQ0: RN69.2 RN72.1 UN5.11
RD2_B_EQ1: RN70.2 RN73.1 UN5.21
RD2_B_EQ2: RN71.2 RN74.1 UN5.16
RD2_REXT: RN31.1 UN5.10
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE2.B13
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE2.A13
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE2.B14
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE2.A14
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE2.A16
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE2.B17
RES_BIAS: RL13.1 UL1.12
RESET_OUT#: RC129.1 RE56.2 UC1.B6 UE2.B39
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.1 UA1.28
RING2_R: CA4.1 CA13.2 DA3.2 JHP1.4 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.14
RJ45_MDIN1: JLOM1.6 TL1.18
RJ45_MDIN2: JLOM1.5 TL1.20
RJ45_MDIN3: JLOM1.8 TL1.24
RJ45_MDIP0: JLOM1.1 TL1.13
RJ45_MDIP1: JLOM1.3 TL1.17
RJ45_MDIP2: JLOM1.4 TL1.19
RJ45_MDIP3: JLOM1.7 TL1.23
RUN_ON: PR402.1 QE2.2 RE280.2 RE292.1 RPE10.2 UE5.4 UZ3.3 UZ4.3
RUN_ON#: QE2.5 QE2.6 RE68.2
RUN_ON_EC: RE292.2 UE2.B9 UE5.2
RUNPWROK: QE2.3 RE67.2 UC8.1 UC8.4 UC8.10 UC8.13 UE1.A4 UE2.B26
S5_1.2V: PC214.1 PR208.2 PU201.8
SA_LGATE: PQ501.8 PU606.5
SA_SNUB: PC622.1 PR627.2
SA_SW: PL601.1 PQ501.9 PR619.2 PR624.1 PR627.1 PU606.8
SA_UGATE: PQ501.1 PU606.1
SATA_LED: JLED1.3 QZ4.3
SATA_LED#: QZ3.6 QZ4.2
SATA_PRX_C_DTX_N0: CN18.1 JSATA1.5
SATA_PRX_C_DTX_N1: C313.2 JDOCK1.56
SATA_PRX_C_DTX_P0: CN17.1 JSATA1.6
SATA_PRX_C_DTX_P1: C312.2 JDOCK1.54
SATA_PRX_C_RD_DTX_N0: CN45.2 UN7.4
SATA_PRX_C_RD_DTX_P0: CN48.2 UN7.5
SATA_PRX_DTX_N0: CN45.1 UC1.F20
SATA_PRX_DTX_N1: C313.1 UC1.G21
SATA_PRX_DTX_P0: CN48.1 UC1.E20
SATA_PRX_DTX_P1: C312.1 UC1.F21
SATA_PRX_RD_DTX_N0: CN18.2 UN7.12
SATA_PRX_RD_DTX_P0: CN17.2 UN7.11
SATA_PTX_C_DRX_N0: CN44.1 JSATA1.3
SATA_PTX_C_DRX_N1: C315.1 JDOCK1.62
SATA_PTX_C_DRX_P0: CN43.1 JSATA1.2
SATA_PTX_C_DRX_P1: C314.1 JDOCK1.60
SATA_PTX_C_RD_DRX_N0: CN50.2 UN7.2
SATA_PTX_C_RD_DRX_P0: CN47.2 UN7.1
SATA_PTX_DRX_N0: CN50.1 UC1.B21
SATA_PTX_DRX_N1: C315.2 UC1.D21
SATA_PTX_DRX_P0: CN47.1 UC1.A21
SATA_PTX_DRX_P1: C314.2 UC1.C21
SATA_PTX_RD_DRX_N0: CN44.2 UN7.14
SATA_PTX_RD_DRX_P0: CN43.2 UN7.15
SATAGP1: RC246.1 UC1.H3
SD/MMCCD#: JSD1.18 UR2.30
SD/MMCCLK: RR1.1 UR2.17
SD/MMCCLK_R: CR23.1 JSD1.5 RR1.2
SD/MMCCMD: RR23.1 UR2.19
SD/MMCCMD_R: JSD1.2 RR23.2
SD/MMCDAT0/RCLK+: RR22.1 UR2.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR22.2
SD/MMCDAT1/RCLK-: RR21.1 UR2.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR21.2
SD/MMCDAT2: RR18.1 UR2.21
SD/MMCDAT2_R: JSD1.9 RR18.2
SD/MMCDAT3: RR17.1 UR2.20
SD/MMCDAT3_R: JSD1.1 RR17.2
SD_GPIO: RR16.2 UR2.28
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.12 UR2.25
SD_UHS2_D0P: JSD1.11 UR2.26
SD_UHS2_D1N: JSD1.15 UR2.23
SD_UHS2_D1P: JSD1.16 UR2.22
SDWP: QR1.1 UR2.29
SDWP_Q: JSD1.19 QR1.3
SIM_DET: JNGFF2.58 RI31.2
SIM_DET_R: JSIM1.9 RI31.1
SIO_EXT_SCI#: RC237.1 UC1.AN7 UE2.A33
SIO_EXT_SMI#: RC236.2 UC1.A6 UE2.A6
SIO_EXT_WAKE#: RC283.2 UC1.AD3 UE2.B5
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.2 UC1.BA15 UE2.B58
SIO_RCIN#: RC13.2 UC1.AW13 UE2.A27
SIO_SLP_A#: JAPS1.6 RC339.2 UC1.AN16 UE2.B28
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE2.B37 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 UC1.AT11 UC13.1
SIO_SLP_S3#: JAPS1.2 PR511.1 QE11.2 RC320.1 RE280.1 RZ120.1 UC1.AP15 UC13.2 UE2.A35 UE3.2 UE5.1
SIO_SLP_S4#: JAPS1.5 PR208.1 PR1500.1 UC1.BA16 UC14.2 UE2.B36 UZ21.4
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE2.A18
SIO_SLP_SUS#: PR312.2 PR406.1 PR504.1 RC76.2 RC340.2 RZ64.1 RZ82.2 UC1.AN15 UC14.1
SIO_SLP_SUS#_R: RC76.1 UE2.B52
SIO_SLP_WLAN#: RZ71.1 UC1.BB17 UE1.A14
SL_BAT_PRES#: PR926.1 PU901.21
SLEEVE: LA11.1 QA2.3 RA6.1 UA1.29
SLEEVE_R: CA1.1 CA12.1 DA3.3 JHP1.3 LA11.2
SLICE_BAT_ON: PR930.2 RE17.2 UE1.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PR4.1 PR926.2 RPE12.1 UE1.B33
SLOT2_CONFIG_0: JNGFF2.13 RPE11.2 UE1.B12
SLOT2_CONFIG_1: JNGFF2.61 RPE11.4 UE1.A18
SLOT2_CONFIG_2: JNGFF2.67 RPE11.3 UE1.A44
SLOT2_CONFIG_3: JNGFF2.1 RPE11.1 UE1.B34
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: RC19.1 RC347.1 UC1.R9 UL1.28
SML0_SMBDATA: RC20.1 RC348.1 UC1.W2 UL1.31
SML1_SMBCLK: RC15.1 UC1.W3 UE2.B6
SML1_SMBDATA: RC17.1 UC1.V3 UE2.A5
SNB_+1VALWP: PC302.1 PR303.2
SNUB_1.2V: PC211.1 PR204.2
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SOFT_START_GC: PR14.2 PU901.2
SPKR: RA12.2 RC183.2 UC1.AW5
SRTCRST#: CC24.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.2 PU401.7
STSTART_DCBLOCK_GC: PR906.2 PU901.16
SUS_STAT#: RC26.1 UC1.BA11
SUSACK#: UC1.AP11 UE2.B7
SUSCLK: RC48.1 RN99.2 RZ56.1 UC1.BA17
SUSCLK_R: JNGFF3.60 RN99.1
SW1_DP0_AUXN: CV111.1 RV604.2 UV26.27
SW1_DP0_AUXN_C: CV111.2 UV8.H2
SW1_DP0_AUXP: CV110.1 RV608.2 UV26.26
SW1_DP0_AUXP_C: CV110.2 UV8.H1
SW1_DP0_CADET: RV606.2 UV26.43
SW1_DP0_HPD: UV8.J1 UV26.48
SW1_DP0_N0: CV103.1 UV26.49
SW1_DP0_N0_C: CV103.2 UV8.G2
SW1_DP0_N1: CV105.1 UV26.46
SW1_DP0_N1_C: CV105.2 UV8.F2
SW1_DP0_N2: CV107.1 UV26.44
SW1_DP0_N2_C: CV107.2 UV8.E2
SW1_DP0_N3: CV109.1 UV26.41
SW1_DP0_N3_C: CV109.2 UV8.D2
SW1_DP0_P0: CV102.1 UV26.50
SW1_DP0_P0_C: CV102.2 UV8.G1
SW1_DP0_P1: CV104.1 UV26.47
SW1_DP0_P1_C: CV104.2 UV8.F1
SW1_DP0_P2: CV106.1 UV26.45
SW1_DP0_P2_C: CV106.2 UV8.E1
SW1_DP0_P3: CV108.1 UV26.42
SW1_DP0_P3_C: CV108.2 UV8.D1
SW1_DP1_AUXN: CV150.1 RV605.2 UV26.29
SW1_DP1_AUXN_C: CV150.2 JNGFF1.12
SW1_DP1_AUXP: CV149.1 RV609.2 UV26.28
SW1_DP1_AUXP_C: CV149.2 JNGFF1.14
SW1_DP1_CADET: RV607.2 UV26.33
SW1_DP1_HPD: JNGFF1.23 UV26.38
SW1_DP1_N0: CV156.1 UV26.39
SW1_DP1_N0_C: CV156.2 JNGFF1.24
SW1_DP1_N1: CV152.1 UV26.36
SW1_DP1_N1_C: CV152.2 JNGFF1.18
SW1_DP1_N2: CV148.1 UV26.34
SW1_DP1_N2_C: CV148.2 JNGFF1.17
SW1_DP1_N3: CV145.1 UV26.31
SW1_DP1_N3_C: CV145.2 JNGFF1.11
SW1_DP1_P0: CV157.1 UV26.40
SW1_DP1_P0_C: CV157.2 JNGFF1.26
SW1_DP1_P1: CV153.1 UV26.37
SW1_DP1_P1_C: CV153.2 JNGFF1.20
SW1_DP1_P2: CV147.1 UV26.35
SW1_DP1_P2_C: CV147.2 JNGFF1.19
SW1_DP1_P3: CV146.1 UV26.32
SW1_DP1_P3_C: CV146.2 JNGFF1.13
SW1_PS8338_CFG0: RV601.2 UV26.59
SW1_PS8338_P0: RV615.2 UV26.60
SW1_PS8338_P1: RV603.2 RV621.1 UV26.1
SW1_PS8338_PC10: RV614.2 RV620.1 UV26.56
SW1_PS8338_PC11: RV613.2 RV619.1 UV26.55
SW1_PS8338_PC20: RV612.2 RV618.1 UV26.54
SW1_PS8338_PC21: RV611.2 RV617.1 UV26.53
SW1_PS8338_PEQ: RV610.2 RV616.1 UV26.8
SW1_PS8338_SW: QV11.1 RV602.2 UV26.18
SW2_VGA1_BLUE: CV53.1 LV18.1 RV34.1 UV16.22
SW2_VGA1_GREEN: CV52.1 LV17.1 RV33.1 UV16.25
SW2_VGA1_HSYNC: LV19.1 UV16.20
SW2_VGA1_RED: CV51.1 LV16.1 RV32.1 UV16.27
SW2_VGA1_SCL: JCRT1.15 RV36.2 UV16.14
SW2_VGA1_SDA: JCRT1.12 RV35.2 UV16.12
SW2_VGA1_VSYNC: LV20.1 UV16.18
SW2_VGA2_BLUE: JDOCK1.45 UV16.21
SW2_VGA2_GREEN: JDOCK1.59 UV16.24
SW2_VGA2_HSYNC: JDOCK1.65 UV16.19
SW2_VGA2_RED: JDOCK1.53 UV16.26
SW2_VGA2_SCL: JDOCK1.48 UV16.15
SW2_VGA2_SDA: JDOCK1.46 UV16.13
SW2_VGA2_VSYNC: JDOCK1.67 UV16.17
SW_1.2V: PC205.2 PL201.2 PQ201.7 PR204.1 PU201.16
SW_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.10
SW_LAN0_10_GRN#: QL2.1 RL30.2 UL4.41
SW_LAN0_100_ORG#: QL1.4 RL29.2 UL4.18
SW_LAN0_ACTLED_YEL#: QL1.1 UL4.17
SW_LAN0_MDIN0: TL1.11 UL4.25
SW_LAN0_MDIN1: TL1.7 UL4.29
SW_LAN0_MDIN2: TL1.5 UL4.34
SW_LAN0_MDIN3: TL1.1 UL4.38
SW_LAN0_MDIP0: TL1.12 UL4.24
SW_LAN0_MDIP1: TL1.8 UL4.28
SW_LAN0_MDIP2: TL1.6 UL4.33
SW_LAN0_MDIP3: TL1.2 UL4.37
SW_LAN1_10_GRN#: JDOCK1.3 UL4.40
SW_LAN1_100_ORG#: JDOCK1.4 UL4.20
SW_LAN1_ACTLED_YEL#: JDOCK1.100 UL4.19
SW_LAN1_MDIN0: JDOCK1.106 UL4.23
SW_LAN1_MDIN1: JDOCK1.112 UL4.27
SW_LAN1_MDIN2: JDOCK1.124 UL4.32
SW_LAN1_MDIN3: JDOCK1.130 UL4.36
SW_LAN1_MDIP0: JDOCK1.104 UL4.22
SW_LAN1_MDIP1: JDOCK1.110 UL4.26
SW_LAN1_MDIP2: JDOCK1.122 UL4.31
SW_LAN1_MDIP3: JDOCK1.128 UL4.35
SW_USB20_N1: LI7.1 UI3.11
SW_USB20_P1: LI7.4 UI3.10
SYS_LED_MASK#: QL1.2 QL1.5 QL2.2 QZ3.2 RE21.2 UE1.B48 UZ10.1
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.2 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: JXDP1.52 RC230.1 UC8.2
THERMATRIP2#: CE36.1 QE4.1 RE69.2 UE2.B34
THERMATRIP3#: RE301.1 UE2.A2
THSEL_STRAP: RE78.1 UE2.B29
TOUCH_SCREEN_DET#: JEDP1.32 RV623.2 UC1.AY5
TOUCH_SCREEN_PD#: JEDP1.5 RPC5.6 UC1.A7
TOUCHPAD_INTR#: JKBTP1.16 RC272.2 UC1.BA5
TP_LAN_JTAG_TCK: RL2.2 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.2 UL1.33
TPM_GPIO4: RZ110.2 UZ12.13
TPM_LPM#: QZ9.1 RZ111.1 UZ12.3
TPM_PIRQ#: RZ69.2 UC1.M3 UZ12.18
TRST#_XDP: JXDP1.54 UC8.12
TS_EN: QV7.2 RC282.2 UC1.AP5
UART0_TXD: RE306.1 UC1.AB2
UIM_CLK: CZ66.1 JNGFF2.24 JSIM1.3
UIM_DATA: CZ65.1 JNGFF2.26 JSIM1.7
UIM_RESET: CZ67.1 JNGFF2.22 JSIM1.2
USB3_PRX_DTX_N1: RI16.1 UC1.H8
USB3_PRX_DTX_N2: JDOCK1.84 UC1.J6
USB3_PRX_DTX_N3: RI20.1 UC1.J10
USB3_PRX_DTX_N4: RI24.1 UC1.E10
USB3_PRX_DTX_N5: RI28.1 UC1.H13
USB3_PRX_DTX_P1: RI15.1 UC1.G8
USB3_PRX_DTX_P2: JDOCK1.86 UC1.H6
USB3_PRX_DTX_P3: RI19.1 UC1.H10
USB3_PRX_DTX_P4: RI23.1 UC1.F10
USB3_PRX_DTX_P5: RI27.1 UC1.G13
USB3_PRX_L_DTX_N1: DI4.1 DI4.9 JUSB3.5 RI16.2
USB3_PRX_L_DTX_N3: DI1.1 DI1.9 JUSB1.5 RI20.2
USB3_PRX_L_DTX_N4: DI6.1 DI6.9 JUSB2.5 RI24.2
USB3_PRX_L_DTX_N5: JNGFF2.21 RI28.2
USB3_PRX_L_DTX_P1: DI4.2 DI4.8 JUSB3.6 RI15.2
USB3_PRX_L_DTX_P3: DI1.2 DI1.8 JUSB1.6 RI19.2
USB3_PRX_L_DTX_P4: DI6.2 DI6.8 JUSB2.6 RI23.2
USB3_PRX_L_DTX_P5: JNGFF2.23 RI27.2
USB3_PTX_C_DRX_N1: CI13.1 RI18.1
USB3_PTX_C_DRX_N3: CI5.1 RI22.1
USB3_PTX_C_DRX_N4: CI27.1 RI26.1
USB3_PTX_C_DRX_N5: CI29.1 RI30.1
USB3_PTX_C_DRX_P1: CI16.1 RI17.1
USB3_PTX_C_DRX_P3: CI4.1 RI21.1
USB3_PTX_C_DRX_P4: CI28.1 RI25.1
USB3_PTX_C_DRX_P5: CI30.1 RI29.1
USB3_PTX_DRX_N1: CI13.2 UC1.C13
USB3_PTX_DRX_N2: JDOCK1.90 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_N4: CI27.2 UC1.C15
USB3_PTX_DRX_N5: CI29.2 UC1.B17
USB3_PTX_DRX_P1: CI16.2 UC1.D13
USB3_PTX_DRX_P2: JDOCK1.92 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_DRX_P4: CI28.2 UC1.D15
USB3_PTX_DRX_P5: CI30.2 UC1.A17
USB3_PTX_L_DRX_N1: DI4.4 DI4.7 JUSB3.8 RI18.2
USB3_PTX_L_DRX_N3: DI1.4 DI1.7 JUSB1.8 RI22.2
USB3_PTX_L_DRX_N4: DI6.4 DI6.7 JUSB2.8 RI26.2
USB3_PTX_L_DRX_N5: JNGFF2.27 RI30.2
USB3_PTX_L_DRX_P1: DI4.5 DI4.6 JUSB3.9 RI17.2
USB3_PTX_L_DRX_P3: DI1.5 DI1.6 JUSB1.9 RI21.2
USB3_PTX_L_DRX_P4: DI6.5 DI6.6 JUSB2.9 RI25.2
USB3_PTX_L_DRX_P5: JNGFF2.29 RI29.2
USB20_N1: UC1.AB9 UI3.2
USB20_N1_R: DI5.2 JUSB3.2 LI7.2
USB20_N2: LZ1.1 UC1.AD6
USB20_N2_R: JEDP1.12 LZ1.2
USB20_N3: LI3.1 UC1.AH3
USB20_N3_R: DI2.2 JUSB1.2 LI3.2
USB20_N4: LI4.1 UC1.AD9
USB20_N4_R: DI3.2 JUSB2.2 LI4.2
USB20_N5: JDOCK1.74 UC1.AJ1
USB20_N6: JDOCK1.68 UC1.AF6
USB20_N7: JUSH1.19 UC1.AH1
USB20_N8: JNGFF1.5 UC1.AF8
USB20_N9: LV27.2 UC1.AG1
USB20_N9_R: DV4.2 JEDP1.2 LV27.1
USB20_N10: JNGFF2.9 UC1.AH7
USB20_P1: UC1.AB10 UI3.3
USB20_P1_R: DI5.3 JUSB3.3 LI7.3
USB20_P2: LZ1.4 UC1.AD7
USB20_P2_R: JEDP1.13 LZ1.3
USB20_P3: LI3.4 UC1.AJ3
USB20_P3_R: DI2.3 JUSB1.3 LI3.3
USB20_P4: LI4.4 UC1.AD10
USB20_P4_R: DI3.3 JUSB2.3 LI4.3
USB20_P5: JDOCK1.72 UC1.AJ2
USB20_P6: JDOCK1.66 UC1.AF7
USB20_P7: JUSH1.18 UC1.AH2
USB20_P8: JNGFF1.3 UC1.AF9
USB20_P9: LV27.3 UC1.AG2
USB20_P9_R: DV4.3 JEDP1.3 LV27.4
USB20_P10: JNGFF2.7 UC1.AH8
USB_OC0#: CI33.1 RPC3.4 UC1.A9 UI3.13
USB_OC1#: CI34.1 RPC3.2 UC1.C9 UI1.3
USB_OC2#: CI35.1 RPC3.1 UC1.D9 UI2.3
USB_OC3#: RPC3.3 UC1.B9
USB_PWR_EN1#: RPE9.2 UE1.B44 UI1.4
USB_PWR_EN2#: RPE9.3 UE1.A33 UI2.4
USB_PWR_SHR_EN#: RPE9.4 UE1.A8 UI3.6
USB_PWR_SHR_VBUS_EN: RPE9.1 UE1.B50 UI3.5
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 RC281.2 RZ87.1 UE1.A16
USH_DET#_R: DZ7.1 JUSH1.1 RZ87.2
USH_PWR_STATE#: JUSH1.5 RZ10.2 UE1.A34
USH_RST#: RZ115.1 UE1.A62
USH_SMBCLK: JUSH1.16 RZ8.2 UE2.A50
USH_SMBDAT: JUSH1.15 RZ9.2 UE2.B53
VCI_IN2#: RPE5.4 UE2.B63
VCT_LAN_R1: RL3.2 UL1.6
VGA1_BLUE_L: CV56.1 DV6.2 JCRT1.3 LV18.2
VGA1_GREEN_L: CV55.1 DV5.3 JCRT1.2 LV17.2
VGA1_HSYNC_L: CV59.1 JCRT1.13 LV19.2 RV38.2
VGA1_RED_L: CV54.1 DV5.2 JCRT1.1 LV16.2
VGA1_VSYNC_L: CV58.1 JCRT1.14 LV20.2 RV37.2
VGA_ID: RE84.1 RE85.1 UE1.B59
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR607.1 RC152.2 RC153.2
VIDALERT_N_A: PR604.2 PR607.2 PR625.1
VIDALERT_N_B: PR625.2 PU602.36
VIDSCLK: PR606.1 UC1.A63
VIDSCLK_A: PR601.2 PR606.2 PR618.1
VIDSCLK_B: PR618.2 PU602.37
VIDSOUT: PR609.1 RC157.2 UC1.D64
VIDSOUT_A: PR605.2 PR609.2 PR626.1
VIDSOUT_B: PR626.2 PU602.35
VMM3320_LPM_DIS: RV79.1 RV516.1 UC1.BA8 UV8.B2
VRALERT#: RC73.1 RC343.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5085: CE38.1 RE77.1 UE2.A17
WIGIG_32KHZ: JNGFF1.42 RZ56.2
WLAN_DISBL#: UE1.B68 UL2.4
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RPE12.2 UE1.A1
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.48
WWAN_PWR_EN: JNGFF2.6 RZ43.2
WWAN_RADIO_DIS#: DZ5.1 RPE12.4 UE1.A53
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 RE38.2 UE1.B43
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.2 RC290.1 UC12.1
XDP_JTAGX: RC87.1 RC328.2 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN: CC21.1 RC46.2 UC1.E37 YC1.3
XTAL24_OUT: RC46.1 RC295.1 UC1.E35
XTAL24_OUT_R: CC22.1 RC295.2 YC1.1
XTALI: CL14.2 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.2 RL34.1 YL1.3
Z2805: RL18.1 TL1.22
Z2806: RL16.1 TL1.16
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N40459: QV2.1 RV5.2
N43975: QN1.5 QN1.6 RN2.2
N46665: CA29.1 UA1.35
N46669: CA29.2 UA1.36
N46677: CA25.1 UA1.31
N46697: CA27.1 RA12.1
N46705: CA28.1 RA13.1
N46713: QA2.5 QA2.6 RA21.2
N46735: CA33.1 RA17.2
N70289: JDEG1.9 RE74.2 RE305.2 RE306.2
N70739: JDEG1.1 RE71.2
N70745: RE64.1 UE2.B61
N70747: CE34.1 RE66.2
N70757: RE57.1 RE58.1 UE2.A59
N75571: DZ3.2 DZ4.2 QZ3.1 RZ24.2
N75591: QZ4.1 RZ27.1
N75595: DZ3.1 QZ3.3
N13388109: PQ906.2 PR916.2
N13388133: PQ906.1 PQ909.2 PR915.2
N13388149: PD901.2 PQ909.1
N13388161: PQ909.3 PR913.2 PR915.1
N15438178: PD801.1 PD802.1 PD803.1 PR811.1
N15438627: PC815.1 PR812.1 PR813.1 PU801.6
N15439163: PR815.2 PU801.5
N15439291: PC823.2 PR816.2 PU801.7
N15439295: PC824.2 PR819.2 PU801.8
N15439512: PR820.2 PR822.2 PU801.9
N15440461: PR818.2 PU801.10
N15440728: PR827.2 PR829.1 PU801.16
N15441413: PR825.1 PU801.18
N15441884: PC828.1 PR826.1 PU801.17
N15442134: PC829.2 PC830.1 PR823.3 PU801.20
N15442185: PC830.2 PC831.1 PR823.2 PU801.19
N15443707: PR814.1 PU801.25
N17156946: PC5.1 PQ1.4 PQ5.4 PR1.2 PR14.1 PR15.1
N17156948: PQ1.1 PQ1.2
N17252180: PC902.2 PQ904.4 PR906.1
N17252838: PQ911.5 PR919.2
N18339814: DA5.1 RA25.2
N18339816: DA4.1 RA24.2
N18431888: DA2.2 JHP1.5 RA1.2
N18490882: RI14.2 UI3.16
N18609334: QV7.1 QV8.2 RV6.2
N18754440: QA3.3 RA27.2
N18754442: QA3.6 RA28.2
N18779977: C319.1 R273.2
N18779979: C43.1 R41.2
N18779981: C42.1 R6.2
N19651849: CE9.1 RE27.2
N19651850: RE24.1 UE1.B19
N19817114: PC904.1 PQ901.1 PQ901.2 PQ901.3 PQ905.1 PQ905.2 PQ905.3 PR910.2
N19957038: PC904.2 PD904.1 PQ901.4 PQ905.4 PR910.1 PR912.1
N20360585: CA49.2 UA1.34
N20361305: CA35.2 UA1.25
N20363962: CA51.1 RA44.1 UA1.21
N20363967: CA52.1 UA1.39
N20363972: CA53.1 UA1.7
N20880735: PC307.2 PR308.1
N20899585: RV600.1 UV26.20
N20899609: CV605.1 UV26.17
N20987678: PD905.1 PQ910.3 PR911.2
N20987955: PQ902.5 PQ902.6 PR903.2
N20987996: PQ902.3 PR902.2 PR904.1
N20988471: PQ907.6 PR909.1 PU903.1
N21135665: PR821.1 PU801.21
N24606174: PC313.1 PU301.5
N25124064: RA45.1 UA1.22
N26452800: PL4.1 PQ3.1 PR5.1 PR8.2
N26661962: PC510.1 PR507.2 PR509.1 PR511.2 PU502.8
N26661997: PC509.2 PR508.2 PR510.1 PU502.2
N27447034: QE4.2 RE70.2
N27829830: CZ77.1 RZ63.1
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.2 SW1.2
N28742882: PR835.2 PU801.12
N28742885: PR836.2 PU801.11
N28769860: PR421.2 PR422.2 PU401.5
N28771761: PR404.2 PR425.2 PU401.14
N28771835: PR410.2 PR426.2 PU402.14
N28810563: CZ23.1 UZ2.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857237: T14.1(TP-1) UC1.AK13
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N28938912: CC8.2 RC29.1
N28938914: CC7.2 RC28.1
N29198215: RZ82.1 RZ83.1 UZ20.4
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708599: T128.1(TP-1) UC1.AU5
N29708601: T129.1(TP-1) UC1.AT5
N29708639: T130.1(TP-1) UC1.BB5
N30342894: QV4.2 RV19.2
N30404696: CZ90.1 UZ5.12
N30404698: CZ91.1 UZ5.10
N30957347: RV121.2 UV16.8
N31877076: JEDP1.21 LV1.1
N32114561: PC821.2 PR814.2
N32198964: PC1504.1 PR1500.2 PR1502.1 PU1500.8
N32198997: PC1502.2 PR1501.2 PR1503.1 PU1500.2
N32427314: CZ46.1 UZ3.12
N32427416: CZ37.1 UZ3.10
N32452041: CZ45.1 UZ4.12
N32452300: CZ38.1 UZ2.12
N32454707: RZ70.2 RZ71.2 UZ3.5
N32604731: CZ42.1 UZ8.6
N32630676: CZ69.1 UZ4.10
N32860357: RZ64.2 RZ65.2 UZ4.5
N32875032: CZ100.1 UZ23.6
N33000410: CL17.1 TL1.4
N33000412: CL16.1 TL1.3
N33000445: CL20.1 TL1.9
N33000449: CL21.1 TL1.10
N33025707: RC320.2 UC13.4 UZ19.4
N33199744: JDIMM1.165 T51.1(TP-1)
N33290988: CD54.2 RD25.1
N33292056: CD36.2 RD21.1
N33298471: JDIMM2.165 T55.1(TP-1)
N33803532: JDIMM1.162 T50.1(TP-1)
N33905280: JDIMM2.162 T54.1(TP-1)
N34357818: QC3.2 RC339.1 RC340.1
N34532908: RZ62.1 UZ12.27
N34764637: RC337.1 UC1.AG3
N34764640: RC338.1 UC1.AG4
N35091599: RZ90.2 RZ112.2 UZ12.29
N35325357: QZ9.2 RZ113.2
N36315919: QE11.3 RE70.1 RE90.2
N36446510: RV661.2 UV29.1
N36618758: CV619.1 RV662.1 UV29.10
N36624941: RE312.1 RE313.1 UE2.A57
N36682340: RZ120.2 UC14.4 UZ26.4
N39294024: PR423.1 PR424.1 PU402.5
N39307859: PC205.1 PR202.1
N39307882: PR210.2 PU201.7
N39307950: PC207.2 PR201.1 PU201.12
N39307975: PR207.2 PU201.9
N39352217: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N39352229: PC102.1 PR100.2
N39352417: PC119.1 PU102.16 PU102.17
N39352440: PC114.1 PR111.2
N39352447: PC113.2 PR108.1
N39352755: PC127.2 PR117.1
N39361921: PR101.1 PU101.4
N39431037: PL603.3 PR661.1
N39431059: PC671.1 PR672.1
N39431065: PR672.2 PU605.6
N39431067: PC671.2 PU605.7
N39431108: PR671.1 PU605.1
N39431132: PC655.1 PR660.1
N39431138: PR660.2 PU603.6
N39431140: PC655.2 PU603.7
N39431166: PR659.1 PU603.1
N39433959: PC647.2 PR650.2
N39434015: PC629.2 PR639.1
N39434922: PH601.2 PR610.1 PR631.2
N39435160: PC627.1 PR632.2
N39435223: PH603.2 PR635.1 PR647.2
N39435244: PR679.1 PU606.7
N39435256: PH602.1 PR628.2
N39435262: PC631.1 PR630.2
N39435305: PC632.1 PR636.1 PU602.28
N39435330: PC627.2 PR638.2 PU602.8
N39435350: PC617.2 PR621.1
N39435414: PR678.2 PU602.38
N39435438: PC611.2 PU606.2
N39435440: PC611.1 PR619.1
N39435497: PC630.1 PR640.1 PU602.20
N39435571: PC640.1 PR646.2
N39435587: PC601.1 PR652.2
N39435611: PC630.2 PR644.1
N39435615: PC632.2 PR641.1
N39435631: PH604.1 PR642.2
N39435662: PR616.2 PU602.40
N39435668: PR612.2 PR614.2 PU602.39
N39435690: PC621.2 PR623.1
N39435692: PR621.2 PR622.2 PR623.2 PU602.5
N39435712: PH605.1 PR657.2
N39435768: PC616.2 PR617.2 PU602.4
N39435770: PC614.2 PR617.1
N39435786: PR610.2 PU602.3
N39435815: PC613.2 PR613.2 PU602.2
N39435886: PC603.1 PR602.1 PU602.34
N39435890: PC604.1 PR603.1 PU602.33
N39435969: PR608.1 PU602.32
N39435973: PR611.1 PU602.31
N39435987: PC639.2 PR645.1
N39630753: PC4.1 PQ2.2 PR4.2
N39645644: PR620.2 PU602.1
N39649009: PC808.2 PC809.1 PR806.2 PU801.2
N39649495: PC802.2 PQ801.2 PQ803.2 PR804.2
N39649980: PC809.2 PC810.1 PR807.2 PU801.1
N39660507: PR905.2 PR907.2 PU902.2
N48705653: PQ3.3 PR5.2 PR7.1
N48705663: PQ4.2 PR8.1 PR10.2
N48705665: PQ3.2 PQ4.1 PR9.2 PR11.1
N48716673: PR933.1 PU901.28
N49522215: PQ804.2 PQ805.2 PR808.2 PR809.2 PR810.2
N49522729: PQ803.1 PR802.2
N49522731: PQ801.1 PR802.3
N49522780: PQ802.4 PR803.1
N78957489: PQ908.1 PR912.2
N78967043: PQ908.2 PU903.4
N79002827: PQ902.2 PU902.4
N79023703: PR927.1 PU901.19
N79030038: PQ911.2 PQ911.3 PR917.2
N79030087: PQ911.6 PR936.2
N79030091: PQ910.2 PR911.1 PR936.1
N79030745: PD904.2 PQ910.1
N79114801: PD4.2 PQ2.1

Pads without a net: DV6 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 16 20; JHDMI1 14; JIR1 4; JKBTP1 4 11; JNGFF1 6 8 9 36 38 40; JNGFF2 10 12 14 16 17 20 30 36 38 40 48 50 51 52 53 54 55 56 57 59 60; JNGFF3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JSATA1 8 20; JSIM1 4 6 8; JSPI1 4; PBATT1 11 12; PD3 2; PRP1 4 5; PU100 10 15; PU102 10; PU201 10; PU301 2; PU401 4; PU402 4; PU501 5; PU502 7; PU602 13; PU801 4; PU901 20 29 30 31 35 36; PU1500 7; QL2 3 4 5; QZ7 1 2 6; RPC5 4 5; RPE5 1 8; UA1 4; UC1 A3 A4 A11 A19 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A65 A69 AB1 AB4 AB12 AB13 AB62 AC1 AC2 AC63 AD4 AE62 AE63 AF11 AF12 AF13 AG62 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK62 AK70 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AN8 AP1 AP2 AP3 AP4 AP7 AP8 AP13 AP56 AR56 AU56 AU58 AU63 AW1 AW20 AW41 AW48 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B7 B11 B19 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA9 BB2 BB4 BB9 BB57 BB66 C2 C4 C7 C8 C11 C12 C16 C27 C28 C29 C31 C32 C33 C36 C37 C38 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D16 D27 D28 D29 D31 D32 D33 D36 D37 D38 D54 D71 E1 E2 E3 E61 F6 F11 F15 F52 F60 F61 F65 G11 G15 G61 G65 H5 H11 H63 J2 J5 J68 J71 K45 K46 L6 M4 N1 N2 N3 N9 N11 P1 P3 P4 P62 U6 U7 V1 V2 V62 W4 W7 W8 W10 W12; UD1 1; UE1 A3 A5 A9 A11 A12 A23 A32 A42 A45 A46 A47 A48 A49 A52 A55 A56 A57 A59 B1 B3 B4 B6 B7 B11 B13 B14 B16 B17 B18 B32 B39 B40 B45 B47 B49 B52 B55 B56 B57 B58 B61 B63 B64 B65 B66; UE2 A15 A23 B15 B16 B23 B38; UE4 1; UI3 9 15; UL4 5; UN4 3; UN5 3; UN7 7; UR2 31; UV8 E10 H3 H11 K2 L2 L10 L11 L12 L13 M1 M2 M10 M11; UV24 3; UV26 2 4 14 58; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; YC1 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 60 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 6025 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 761 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 107 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 68.2
  TOP w0.102: v2(78.32,12.91) 78.4,12.91 78.98,13.49 RD30.1 78.88,13.62 78.27,13.62 77.63,12.98 77.01,12.98 UD1.4
  IN1 w0.089: v2(98.06,38.3) 96.82,38.3 94.74,36.22 94.1,36.22 79.89,22.01 78.27,22.01 74.06,17.8 74.06,15.2 76.36,12.91 v2(78.32,12.91)
  IN4 w0.089: v2(98.06,38.3) 98.06,39.8 96.67,41.19 96.67,43.33 99.86,46.51 99.86,49.6 98.26,51.21 97.06,51.21 96.29,51.98 96.29,55.35 96.58,55.63 96.58,55.63 v2(96.56,55.61)
  BOTTOM w0.102: v3(97.48,55.29) 97.15,55.61 v2(96.56,55.61) 96.33,55.38 PR210.1
1.2V_B+: length 20.7
  IN1 w0.254: v2(97.12,52.66) 96.2,52.66 95.82,53.04 95.82,54.49 95.29,55.02 95.29,57.08 95.62,57.41 95.62,58.7 94.63,59.69 91.55,59.69 90.72,58.86 86.83,58.86 v2(84.95,56.98)
  BOTTOM w0.508: v2(97.12,52.66) 96.61,52.15 PR207.1
  vias: v2(83.17,56.98) v2(84.03,56.98)
1.2V_FB: length 6.4
  TOP w0.203: v2(93.93,58.6) 93.9,58.63 PR209.1
  BOTTOM w0.203: PU201.6 94.35,55.11 94.58,55.34 94.58,57.14 v3(94.21,57.51) 93.93,57.79 v2(93.93,58.6) 93.92,58.59 93.29,58.59 PR206.1 PC212.1
1.5VSP: length 12.7
  BOTTOM w0.254: PR508.1 220.71,96.43 PC509.1 217.38,96.43 217.2,96.25 v1(212.56,96.25) 212.04,96.25 211.87,96.41 211.87,96.99 211.99,97.11 211.99,99.24 212.33,99.58 212.64,99.58
2.5VSP:
  vias: v3(223.54,40.17)
3.3V_CAM_EN#: length 126
  TOP w0.102: v2(130.64,91.53) 130.64,91.52 131.06,91.1 131.52,91.1 133.66,93.24 136.42,93.24 138.47,95.29 147.74,95.29 148.63,94.41 148.63,92.32 v1(150.74,90.21) 152.2,88.74 156.28,88.74 158.34,86.68 161,86.68 162.33,88.01 166.09,88.01 168.01,86.1 168.01,85.92 168.39,85.54 173.64,85.54 174.34,86.24 175.39,86.24 v2(175.52,86.36) ; v2(165.67,58.6) 165.67,59.39 RC311.2
  IN2 w0.122: v2(165.67,58.6) 165.67,59.52 166.41,60.26 166.72,60.26 167.44,60.97 170.43,60.97 171.18,60.22 171.18,60.11 172.82,58.47 176.68,58.47 178.83,60.61 178.83,64.95 179.12,65.24 179.12,69.02 179.12,69.45 178.48,70.09 178.05,70.09 177.08,71.07 177.08,72.82 177.9,73.64 177.9,75.41 177.71,75.6 177.71,80.25 176.97,80.98 176.97,82.13 176.2,82.9 176.2,85.51 175.69,86.01 175.69,86.02 175.52,86.19 v2(175.52,86.36)
  BOTTOM w0.076: UC1.AT15 165.37,58.3 v2(165.67,58.6)
  BOTTOM w0.102: v2(130.64,91.53) 130.66,91.51 130.66,90.75 130.19,90.27 129.14,90.27 127.74,88.88 121.22,88.88 118.94,91.16 116.93,91.16 116.35,91.75 114.69,91.75 114.31,92.13 114.31,93.83 113.48,94.67 111.89,94.67 110.7,93.48 QZ1.2
3.3V_TP_EN: length 16.4
  BOTTOM w0.076: 176.33,58.94 175.96,59.31 173.83,59.31 173.43,59.72 173.43,59.75 173.08,60.1 171.28,60.1 170.69,60.69 UC1.AM5
  BOTTOM w0.102: 176.33,58.94 176.94,58.94 177.73,59.74 v3(177.93,59.74) 178.13,59.74 179.18,58.69 180.26,58.69 180.62,58.32 181.96,58.32 182.37,58.74 184.22,58.74 RC270.2
3.3V_WWAN_EN: length 43.1
  TOP w0.102: UE1.B42 249.14,79.09 248.83,79.4 v2(247.69,79.4) ; RZ40.2 246.94,47.7 246.19,47.7 v3(245.65,48.24) 245.49,48.39 v2(245.02,48.39)
  TOP w0.203: RZ40.2 247.23,48.42 247.47,48.65 UZ2.3
  IN2 w0.122: v2(245.02,48.39) 245.02,48.84 245.23,49.05 245.23,49.95 249.47,54.18 249.88,54.18 250.48,54.18 251.07,54.77 251.07,58.41 249.16,60.32 249.16,63.57 249.52,63.93 249.52,72.76 248.6,73.69 248.6,73.92 247,75.51 246.95,75.51 246.95,77.49 247.74,78.29 247.74,79.35 v2(247.69,79.4)
3V5V_EN: length 22.6
  TOP w0.102: v3(223.49,60.04) 223.78,59.74 v2(224.5,59.74) 224.5,59.39 224.73,59.16 PR114.2
  IN1 w0.122: v2(224.5,59.74) 224.5,60.21 224.96,60.67 225.5,60.67 226.44,61.61 227.23,61.61 227.47,61.85 227.47,64.24 226.81,64.9 225.34,64.9 224.27,65.97 223.35,65.97 v2(222.72,66.6)
  BOTTOM w0.102: PC128.1 PR116.1 225.5,59.66 224.59,59.66 v2(224.5,59.74) 223.61,59.74 223.36,59.99 PU102.12 ; v2(222.72,66.6) 222.72,68.87 222.4,69.19 221.87,69.19 221.63,69.43 PU100.12
3V_FB: length 4
  TOP w0.102: v2(221.14,69.02) 221.14,69.2 v3(221.45,69.51)
  TOP w0.254: PR110.1 PR109.2 221.14,68.38 v2(221.14,69.02)
  BOTTOM w0.254: PU100.13 221.18,69.05 v2(221.14,69.02) 221.34,68.82 PC113.1
3V_SN:
  vias: v3(215.59,65.79)
3V_VIN:
  vias: v2(226.79,71.12) v2(226.87,72.46) v2(227.03,73.3) v2(227,71.73) v2(227.44,72.79) v2(227.39,72.19) v2(227.99,72.21) v2(228.53,71.92) v3(221.3,74.79)
5V_FB: length 4.8
  TOP w0.102: PR115.2 222.55,58.98 221.98,58.42 v3(221.98,58.04)
  TOP w0.254: PR118.1 222.97,59.01 PR115.2 222.95,59.59 v2(223,59.64)
  BOTTOM w0.254: PC127.1 222.97,59.62 v2(223,59.64) 222.91,59.73 PU102.13
5V_SN:
  vias: v3(220.08,58.31)
5V_VIN:
  vias: v2(225.89,66.65) v2(226.25,66.12) v2(226.71,66.63) v2(227.06,66.09) v2(227.6,66.63) v2(227.95,66.09) v3(223.56,65.9)
+0.6V_DDR_VTT: length 195.7
  IN1 w1.016: 145.73,12.35 146.77,12.35 148.8,14.37 155.54,14.37 158.56,11.36 169.35,11.36 169.37,11.38 171.03,11.38 171.03,11.38 180.15,11.38 180.21,11.32 189.74,11.32 189.77,11.35 205.59,11.35 205.6,11.36 206.31,11.36 206.32,11.35 221.63,11.35 222.03,10.96 223.92,10.96 224.47,11.51 225.92,11.51 226.69,12.28
  IN4 w1.016: 145.16,12.42 144.83,12.09 122.59,12.09 122.51,12.02 93.37,12.02 92.81,12.58 91.25,12.58 90.74,13.08 90.41,13.41 90.41,15.02 90.23,15.2 90.23,20.5 97.09,27.36 97.09,39.81 95.99,40.91 95.99,43.61 99.18,46.79 99.18,49.32 97.97,50.53 96.78,50.53 95.46,51.85 95.46,56.07 95.26,56.27 95.26,57.71 95.34,57.79 95.34,58.62 93.84,60.13 91.83,60.13
  vias: v2(89.85,59.82) v2(90.49,59.82) v2(145,13.25) v2(145.6,13.27) v2(227.13,14.14) v2(227.12,13.5) v2(227.63,13.81) v3(227.65,14.49)
+0.6V_P:
  vias: v2(90.28,56.6) v2(90.87,56.6) v3(89.7,56.61)
+0.9V_LAN: length 8.7
  TOP w0.203: CL9.1 266.15,82.5 265.49,83.16 UL1.22 ; 263.09,82.43 UL1.16 ; UL1.40 v2(265.09,90.78) ; UL1.8 260.67,86.33 260.3,85.96 v2(260.11,85.96) ; UL1.11 260.6,85.13 260.36,84.89 v2(260.21,84.89) ; UL1.43 v2(263.89,90.78)
  TOP w0.381: CL9.1 266.37,82.06 v2(266.53,81.89) ; v2(262.44,82.45) 262.47,82.43 263.09,82.43 CL11.1
  vias: v2(260.69,91.77) v2(261.1,91.3) v2(264.72,92.05) v3(261.65,91.4)
+1.0V_AMPHYPLL: length 16.5
  TOP w0.381: v2(165.49,71.32) 166.31,71.32 CC264.1
  IN3 w0.508: v2(166.15,81.54) 166.23,81.46 166.23,80.95 167.04,80.14 167.04,78.34 166.2,77.5 166.2,73.94 166.43,73.71 166.43,72.26 v2(165.49,71.32)
  BOTTOM w0.254: UC1.K15 165.25,71.72 165.49,71.48 165.49,71.32 v2(165.49,71.32) 165.49,71.1 165.28,70.88 UC1.L15
  BOTTOM w0.406: CC219.1 166.08,82.48 167.31,83.71 RC169.2
  BOTTOM w0.508: v2(166.15,81.54) 166.08,81.61 CC219.1
+1.0V_APLLEBB: length 1.6
  TOP w0.254: RC310.2 v3(161.37,70.51)
  BOTTOM w0.254: UC1.N18 163.28,69.95 162.98,69.65 v2(162.98,69.64)
+1.0V_CLK1: length 7
  BOTTOM w0.203: UC1.A14 165.55,77.14 165.57,77.16 165.57,77.48 165.96,77.87 166.28,77.87 166.83,78.42 166.83,78.45
  BOTTOM w0.254: 166.94,79.89 166.94,79.7 166.94,79.7 166.94,78.57 166.83,78.45
  BOTTOM w0.406: v3(167.36,80.83) 168.39,81.87 168.39,82.09 RC302.2
  BOTTOM w0.508: v3(167.36,80.83) 166.94,80.42 166.94,79.89
+1.0V_CLK2: length 10.8
  TOP w0.508: 163.26,76.61 163.26,76.74 163.99,77.47 163.99,80.75 163.38,81.36 163.08,81.36 v2(162.88,81.56)
  BOTTOM w0.254: UC1.K19 162.95,71.4 v2(162.95,71.3)
  BOTTOM w0.508: v2(162.88,81.56) 162.67,81.36 162.17,81.36 161.14,82.39 CC220.1 160.78,83.11 RC170.2
  vias: v3(162.6,76.52)
+1.0V_CLK3: length 13.2
  IN2 w0.508: 163.82,75.62 163.82,76.84 163.64,77.02 163.64,85.56 163.92,85.84 v2(163.92,86.64)
  BOTTOM w0.254: UC1.L21 v2(161.65,71.3)
  BOTTOM w0.508: v2(163.92,86.64) 163.78,86.64 163.16,87.27 RC303.2
+1.0V_CLK4: length 20.6
  IN2 w0.508: v2(157.06,81.36) 157.06,81.21 156.7,80.85 156.7,78.77 157.21,78.26 157.21,75.16 157.72,74.65 157.72,72.86 158.75,71.83 158.75,70.81 160.54,69.02 161.21,69.02 161.65,69.45 v2(161.65,69.63)
  BOTTOM w0.254: UC1.N20 v2(161.65,69.63)
  BOTTOM w0.508: RC173.2 159.38,84.35 CC226.1 157.57,81.87 v2(157.06,81.36)
+1.0V_CLK5: length 31.8
  TOP w0.508: v2(156.63,85.12) 156.86,84.89 157.53,84.89 v3(157.89,85.24) 157.89,85.78 157.42,86.25 RC52.2
  IN1 w0.254: v2(151.69,79.3) 153.68,79.3 154.21,79.82 155.45,79.82 160.07,75.2 161.1,75.2 161.28,75.38 162.03,75.38 162.49,74.92 162.49,73.25 162.5,73.24 162.5,71.53 v2(162.29,71.33)
  IN4 w0.508: v2(156.63,85.12) 156.12,85.12 155.64,84.64 155.64,83.85 154.03,82.23 152.63,80.84 152.63,80.24 v2(151.69,79.3)
  BOTTOM w0.254: v2(162.29,71.33) 162.29,71.23 162.63,70.89 UC1.L19
  BOTTOM w0.508: RC171.2 158.06,85.36 CC221.1 156.84,85.36 156.63,85.15 v2(156.63,85.12)
+1.0V_CLK6:
  vias: v3(170.74,80.58)
+1.0V_DTS:
  vias: v3(175.53,69.66)
+1.0V_MPHYAON: length 1.1
  BOTTOM w0.254: 163.93,71.69 163.98,71.69 164.2,71.48 164.2,71.33 v2(164.22,71.3) ; 163.93,71.69 v2(163.59,71.35) ; 163.93,71.69 UC1.K17
  vias: v2(176.39,74.79) v2(176.39,74.18) v2(176.4,73.54) v2(176.99,74.8) v2(176.99,74.19) v3(177,72.94)
+1.0V_MPHYGT: length 2.3
  TOP w0.203: v2(166.84,81.52) v3(166.84,82.14)
  TOP w0.381: 165.93,69.4 166.07,69.26 CC281.1
  BOTTOM w0.508: v2(166.84,81.52) 166.85,81.52 166.9,81.56 166.91,81.56 167.6,82.25 RC169.1
  vias: v2(164.22,69.6) v2(164.86,69.63) v2(165.49,69.63) v2(169.25,75.04) v2(172.64,84.58) v2(173.23,84.59) v2(173.81,84.59) v2(173.87,84) v2(174.4,84.57)
+1.0V_PRIM: length 114.4
  TOP w0.508: v2(167.12,67.52) 167.17,67.57 LC2.1 ; v2(89.29,37.13) 88.99,37.43 RC216.1 ; CC286.1 209.22,52.17 v3(209,52.39) 209,54.06 210.01,55.07 v2(210.55,55.07)
  IN2 w0.508: 157.03,44.76 155,42.73 106.38,42.73 102.01,38.36 98.98,38.36 98.32,37.69 94.76,37.69 94.16,38.29 91.88,38.29 90.72,37.13 v2(89.29,37.13)
  IN4 w0.508: v2(187.16,64.85) 187.3,64.71 187.3,63.72 187,63.41 185.33,63.41 183.89,64.86 180.33,64.86 178.4,62.93 177.71,62.93 176.91,63.73 176.45,63.73 175.91,64.28 175.3,64.28 174.97,63.95 173.96,63.95 173.02,64.89 173.02,65.6 171.3,67.31 167.33,67.31 v2(167.12,67.52)
  BOTTOM w0.254: v2(160.13,67.97) 160.13,68.05 160.87,68.79 162.86,68.79 UC1.P18 ; v2(160.68,62.38) 160.94,62.12 161.52,62.12 UC1.AK20 ; UC1.Y18 163.28,66.68 163.59,66.37 v2(163.59,66.27) 163.59,66.19 UC1.AB17
  BOTTOM w0.356: RC301.1 180.19,70.69 v2(180.33,70.55)
  BOTTOM w0.508: CC225.1 189.27,64.89 189.1,64.71 188.37,64.71 188.23,64.85 v2(187.16,64.85)
  vias: v2(159.55,87.87) v2(159.95,88.31) v2(160.27,88.84) v2(161.66,65.49) v2(162.3,65.49) v2(162.95,65.49) v2(168.62,86.06) v2(169.25,86.06) v2(170.39,86.06) v2(172.78,86.01) v2(173.37,86.01) v2(178.62,71.96) v2(178.85,74.17) v2(178.82,73.57) v2(179.26,71.91) v2(179.41,73.59) v2(179.84,71.94) v2(200.77,59.85) v2(201.23,59.41) v2(201.54,59.92) v2(201.84,59.41) v2(202.17,59.95) v2(202.48,59.41) v2(210.6,54.46) v2(211.21,55.07) v2(211.26,54.46) v2(211.85,55.07) v2(211.9,54.46) v2(212.61,55.07) v2(212.66,54.46)
+1.0V_PRIM_CORE: length 2.9
  BOTTOM w0.203: 160.95,67.53 UC1.V21 161.33,67.15 ; 161.58,67.13 UC1.V20 162.37,67.13
  BOTTOM w0.254: UC1.AF18 163.28,64.18 163.59,64.49 v2(163.59,64.56) ; v2(162.93,64.56) 162.93,64.48 UC1.AF19
  vias: v2(160.84,64.98) v2(161.66,64.55) v2(197.22,65.92) v2(197.21,65.22) v2(197.2,64.54) v2(197.83,65.23) v2(197.8,64.57) v2(197.86,65.9) v3(163.26,65.01)
+1.0V_PRIM_COREP: length 11.9
  TOP w0.254: v2(200.77,65.56) 203.92,65.56 204.3,65.94 204.3,68.41 v3(204.05,68.66) v2(202.88,68.66)
  BOTTOM w0.254: 200.24,66.42 200.24,67.44 199.73,67.95 PR423.2 ; v2(202.88,68.66) 202.32,68.66 202.22,68.76 PU402.1
+1.0V_PRIM_XDP: length 83.5
  TOP w0.254: v2(89.83,49.97) 90.11,49.68 JXDP1.44
  TOP w0.279: JXDP1.43 v2(90.09,40.97)
  TOP w0.508: RC138.1 82.54,40.75 v2(82.36,40.92) ; v2(77.13,85.45) 77.13,86.1 CC29.1
  IN1 w0.508: v2(77.13,85.45) 77.13,85 75.89,83.76 75.89,82.59 76.69,81.78 76.69,77.6 72.63,73.54 72.63,70.16 73.19,69.6 74.14,69.6 74.59,70.05 v2(75.45,70.05) ; v2(90.09,40.97) 88.87,39.75 83.07,39.75 82.36,40.47 v2(82.36,40.92)
  IN4 w0.508: 90.69,50.68 93.64,50.68 94.35,51.39 94.35,55.62 94.14,55.82 94.14,57.18 93.46,57.87 91.27,57.87 90.33,58.8 89.42,58.8 89.01,59.21 87.21,59.21 86.78,59.64 82.74,59.64 82.2,59.11 79.16,59.11 77.3,60.96 77.3,63.97 76.42,64.86 76.42,68.71 75.45,69.68 v2(75.45,70.05) ; v2(90.09,40.97) 89.78,41.29 89.78,49.03
  BOTTOM w0.508: v2(89.83,49.97) 89.45,49.97 88.89,49.41 RC115.2
+1.0V_RUN_VMM: length 16
  TOP w0.254: v2(223.74,81.63) 223.33,81.63 v3(223.05,81.35)
  IN1 w1.016: 235.12,95.2 232.35,95.2 231.42,94.28 230.37,94.28 230.01,93.91 225.83,93.91 224.18,92.27 224.18,90.86 225.34,89.7
  vias: v2(225.25,88.74) v2(225.83,88.74) v2(235.73,96.19) v2(236.31,96.19)
+1.0V_RUN_VMM_P:
  vias: v3(226.81,91.56)
+1.0V_SRAM: length 3.6
  TOP w0.457: v2(160.59,64.37) 160.23,64.72 CC217.1
  BOTTOM w0.254: v2(160.59,64.37) 160.79,64.16 161.31,64.16 UC1.AF21 161.44,64.06 161.86,64.06 UC1.AF20 ; v2(161.66,67.95) 161.66,68.1 161.93,68.37 UC1.T20 162.03,68.43 162.57,68.43 UC1.T19
  vias: v2(172.43,79.86) v2(172.94,80.18)
+1.0V_VCCAPLL: length 2.1
  TOP w0.457: LC2.2 166.1,68.13 165.94,67.97 v2(165.59,67.97) 165.48,68.08 CC311.1
  BOTTOM w0.254: UC1.V15 165.59,67.9 v2(165.59,67.97)
+1.0V_VCCST: length 228
  TOP w0.508: RC218.1 91.02,35.95 91.82,35.14 94.32,35.14 v3(94.96,35.78) 95.69,36.51 95.69,42.24 v2(94.73,43.21) ; CC202.1 160.49,69.98 v2(160.74,70.23) ; v2(75.73,68.41) 75.7,68.41 75.5,68.61 74.95,68.61 74.54,69.02 74.54,69.02 74.48,69.07 73.37,69.07 72.88,68.58 PC602.1 72.86,68.36 PR605.1 PR604.1 PR601.1
  IN1 w0.508: v2(76.74,47.07) 76.61,46.94 74.76,46.94 74.21,47.5 74.21,51.13 73.7,51.64 71.59,51.64 70.83,52.41 70.83,58.69 73.25,61.12 75.7,61.12 75.73,61.14 76.24,61.14 76.26,61.12 76.57,61.12 76.98,61.53 77.63,62.18 77.63,64.37 76.59,65.41 76.59,67.54 v2(75.73,68.41) 76.02,68.41 77.57,69.96 79.31,69.96 79.92,70.57 79.92,72.33 78.51,73.74 78.51,77.54 77.91,78.13 77.91,80.38 78.79,81.26 81.95,81.26 82.52,81.83 82.52,82.54 80.85,84.2 80.85,84.72 v2(81.51,85.38) ; v2(162.93,82.22) 162.57,82.22 160.54,84.26 159.24,84.26 158.84,84.66 v2(158.84,85.04)
  IN2 w0.508: v2(158.84,85.04) 157.89,84.09 157.89,80.4 158.6,79.69 158.6,79.33 158.91,79.02 158.91,76.89 159.9,75.9 159.9,75.49
  IN3 w0.508: v2(162.93,82.22) 163.44,82.22 163.89,82.68 163.89,84.46 161.71,86.64 161.71,92.41 159.37,94.75 151.22,94.75 149.47,93 147.72,93 146.13,94.59 144.5,94.59 143.56,93.65 v2(135.72,93.65)
  IN4 w0.508: v2(81.51,85.38) 81.51,85.89 82.27,86.64 95.26,86.64 96.3,85.6 96.3,84.66 96.81,84.15 97.93,84.15 98.88,85.11 101.17,85.11 101.71,84.56 101.99,84.56 106.29,84.56 108.54,86.81 115.09,86.81 116.12,85.78 119.43,85.78 121.87,88.22 125.06,88.22 125.72,87.56 v2(128,87.56)
  BOTTOM w0.203: UC1.A18 163.07,77.49 163.59,78.01 163.59,78.39
  BOTTOM w0.254: v2(160.74,70.23) 160.92,70.41 160.92,71.32 UC1.K21 161.36,71.76 161.46,71.76 161.84,71.76 161.84,71.72 UC1.K20 ; 163.51,81.94 163.59,81.87 163.59,78.39
  BOTTOM w0.508: 163.51,81.94 163.23,82.22 v2(162.93,82.22) 162.85,82.22 ; RC80.1 RC152.1 128.99,84.53 129.47,84.05 129.47,83.6 RC157.1 ; 128.97,87.61 128.97,88.67 129.56,89.26 130.61,89.26 132.72,91.37 134.29,91.37 135.34,92.42 135.34,93.27 v2(135.72,93.65) ; v2(76.74,47.07) 77.1,47.07 78.84,45.33 80.59,45.33 81.06,44.86 93.08,44.86 v2(94.73,43.21)
+1.0V_VCCST_C:
  vias: v3(164.53,84.95)
+1.0V_VCCSTG: length 145.8
  TOP w0.508: v2(143.36,90.45) 144.75,90.45 145.1,90.8 145.1,91.93 144.7,92.32 143.97,92.32 143.3,92.99 137.68,92.99 137.03,92.34 133.98,92.34 128.54,86.9 125.19,86.9 v2(124.73,87.36) ; v2(160.64,77.8) 160.16,78.29 160.16,83.27 CC199.1 162.34,85.45 162.34,87.06 v2(162.41,87.13) 162.63,87.35 165.42,87.35 RC143.2 ; RC135.1 100.39,39.2 v3(100.22,39.36) 100.17,39.41 v2(100.17,40) ; v2(102.32,41.48) 102.58,41.74 103.52,41.74 RC131.1 RC134.1
  IN1 w0.508: v2(117.72,82.73) 117.72,77.97 121.93,73.75 121.93,70.84 119.74,68.65 119.74,67.56 v2(119.48,67.31) ; v2(162.41,87.13) 162.41,87.82 160.69,89.54 157.92,89.54 157.42,89.03 149.85,89.03 148.34,90.54 143.44,90.54 v2(143.36,90.45)
  IN3 w0.508: v2(124.73,87.36) 124.83,87.26 124.83,86.8 124.15,86.12 124.14,86.11 122.84,86.11 119.46,82.73 v2(117.72,82.73) ; v2(100.17,40) 100.18,40.01 101.74,40.01 102.32,40.59 v2(102.32,41.48)
  IN4 w0.508: v2(102.32,41.48) 101.59,42.22 101.59,44.68 104.71,47.81 108.43,47.81 111.66,51.04 111.66,56.54 119.44,64.32 119.44,67.27 v2(119.48,67.31)
  BOTTOM w0.203: v2(160.64,77.8) 160.64,77.69 160.59,77.64 UC1.A22
  BOTTOM w0.508: v2(162.41,87.13) 162.41,88.79 161.91,89.3 RC238.1 ; RC83.1 125.27,86.82 v2(124.73,87.36) ; RC130.1 RC82.1 142.84,85.04 RC87.2 RC81.1 144.42,87.52 144.42,88.2 143.4,89.22 143.4,89.71 143.36,89.76 v2(143.36,90.45)
