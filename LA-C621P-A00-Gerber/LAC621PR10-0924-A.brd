# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18339816: length 3
  TOP w0.254: v3(278.77,25.58) 278.93,25.42 DA4.1
  TOP w0.381: DA4.1 280,24.97 280.58,24.39 RA24.2
N18431888: length 27
  TOP w0.102: v2(293.16,27) 293.16,26.8 293.77,26.19 DA2.2 294.32,26.94 293.87,27.39 v3(293.87,27.8) 293.87,27.98 294.42,28.53 RA1.2
  IN3 w0.122: v2(293.16,27) 293.16,25.58 292.09,24.5 292.09,19.89 290.59,18.39 290.59,16.56 291.17,15.98 291.17,11.81 290.56,11.21 290.56,9.99 291.79,8.76 292.91,8.76 JHP1.5
N18490882: length 5
  TOP w0.102: v3(278.69,64.05) 279.17,64.53 279.57,64.53 RI14.2 280.35,65.03 281.24,65.92 282.05,65.92 282.29,65.68 UI3.16
N18609334: length 39.3
  TOP w0.102: RV6.2 96.35,100.32 v2(97.17,101.13) 98,100.29 98,97.85 QV7.1
  IN3 w0.122: v2(114.77,97.74) 112.82,95.79 107.43,95.79 107.16,96.06 106.65,96.17 106.54,96.21 106.43,96.21 104.78,96.54 104.75,96.54 104.73,96.57 104.72,96.58 104.67,96.64 99.77,101.54 97.58,101.54 v2(97.17,101.13)
  BOTTOM w0.102: QV8.2 115.1,92.26 115.38,91.98 116.44,91.98 116.52,91.9 117.46,91.9 117.87,92.31 117.87,94.64 v3(115.68,96.83) v2(114.77,97.74)
N18754440: length 6.6
  TOP w0.102: v3(274,22.82) 274.52,22.3 276.11,22.3 276.86,23.05 276.86,23.55 QA3.3 277.05,24.36 276.73,24.36 275.94,25.15 RA27.2
N18754442: length 3.8
  TOP w0.102: RA28.2 275.35,24.72 275.86,24.72 276.2,24.38 276.2,22.97 275.98,22.75 QA3.6
N18779977: length 2.4
  TOP w0.102: v3(163.18,99.95) 164.27,101.04 R273.2 C319.1
N18779979: length 2.7
  TOP w0.102: v3(154.56,105.46) 154.34,105.68 154.34,106.85 154.27,106.92 C43.1 R41.2
N18779981: length 2.2
  TOP w0.102: C42.1 R6.2 157,108.11 v3(157.9,107.2)
N19651849: length 2.6
  TOP w0.102: v3(241.35,79.61) 241.18,79.77 RE27.2 CE9.1
N19651850: length 9.1
  TOP w0.102: v2(241.59,84.94) 241.12,85.41 v3(240.66,85.41) 240.28,85.41 239.1,84.23 RE24.1 ; UE1.B19 245.58,86.13 v2(245.76,85.96)
  IN1 w0.089: v2(245.76,85.96) 244.72,85.96 244.12,85.36 242.01,85.36 v2(241.59,84.94)
N19817114:
  vias: v3(76.73,21.59)
N19957038: length 17.6
  TOP w0.102: v3(79.34,25.45) 78.84,25.95 PR910.1
  TOP w0.254: PQ901.4 74.08,26.27 73.55,25.74 73.55,20.68 73.53,20.65 ; 73.53,20.65 74.44,20.65 PQ905.4 ; 73.53,20.65 71.53,18.66 70.14,18.66 68.44,16.95 PD904.1
N20360585: length 2.6
  TOP w0.102: UA1.34 282.64,34.88 283.03,35.27 283.75,35.27 CA49.2
N20361305: length 3.7
  TOP w0.203: CA35.2 283.26,29.67 282.79,30.14 282.79,31.06 282.57,31.28 UA1.25
N20363962: length 6.3
  TOP w0.102: UA1.21 280.11,29.43 280.38,29.16 281.02,29.16 281.79,28.4 282.92,28.4 283.04,28.27 CA51.1 283.59,27.83 283.68,27.92 283.68,28.17 283.78,28.27 RA44.1
N20363967: length 6.1
  TOP w0.203: CA52.1 284.64,38.51 281.95,38.51 280.51,37.07 UA1.39
N20363972: length 3.2
  TOP w0.127: UA1.7 275.73,33.28 275.11,32.66 274.91,32.66
  TOP w0.203: 274.91,32.66 v3(274.59,32.66) 273.77,31.83 CA53.1
N20880735: length 1.9
  BOTTOM w0.102: PC307.2 v3(228.06,49.64)
  BOTTOM w0.254: PR308.1 226.27,49.64 PC307.2
N20899585: length 4.2
  BOTTOM w0.102: UV26.20 198.77,88.01 199.29,88.54 201.06,88.54 v3(201.08,88.56) 201.56,89.04 RV600.1
N20899609: length 7.2
  BOTTOM w0.102: UV26.17 197.05,88.43 198.48,89.86 198.62,89.86 198.97,90.22 CV605.1 198.97,90.5 198.51,90.96 198.51,91.74 198.71,91.95 198.71,93.54 v3(199.07,93.89)
N20987678: length 4.8
  TOP w0.102: v3(61.21,13.21) 61.21,11.48 PD905.1 61.63,11.05 PR911.2 62.57,11.23 64.04,11.23 PQ910.3
N20987955: length 4.8
  BOTTOM w0.102: PR903.2 254.57,93.41 v3(254.57,95.11)
  BOTTOM w0.508: PR903.2 254.31,92.35 PQ902.6 PQ902.5
N20987996: length 3.9
  BOTTOM w0.102: PQ902.3 256.58,94.31 PR902.2 ; v3(257.8,96.05) 257.57,95.82 PR902.2 ; PR902.2 257.57,93.45 PR904.1
N20988471: length 3.5
  TOP w0.102: v3(72.39,14.4) 72.35,14.36 PR909.1 72.01,13.42 71.5,13.93 PQ907.6 PU903.1
N21135665: length 4.4
  BOTTOM w0.203: PU801.21 64.09,87.33 64.71,86.71 64.71,85.69 v3(64.89,85.51) 65.23,85.17 PR821.1
N24606174: length 4.2
  TOP w0.254: v2(225.06,50.42) 225.71,50.42 226.03,50.1 v3(226.03,49.63) 225.84,49.44 224.92,49.44 PC313.1
  BOTTOM w0.254: PU301.5 225.14,50.5 v2(225.06,50.42)
N25124064: length 14.8
  TOP w0.102: RA45.1 284.87,25.3 285.2,24.97 285.2,23.18 v3(284.95,22.92)
  TOP w0.203: v2(280.52,29.59) 280.51,29.61 UA1.22
  TOP w0.508: v2(286.14,27.89) 286.14,27.75 286.16,27.73 286.16,26.78 285.93,26.56 285.29,26.56 284.69,25.96 RA45.1
  IN3 w0.508: v2(286.14,27.89) 286.14,28.25 285.61,28.78 283.53,28.78 282.79,28.05 281.34,28.05 280.52,28.87 v2(280.52,29.59)
N26452800: length 8.9
  TOP w0.254: PR5.1 PR8.2 54.44,95.79 54.62,95.61 54.88,95.61 55.31,95.18 55.31,93.94 PL4.1 54.91,93.27 v3(54.91,92.29) 54.91,91.94 55.14,91.72 55.84,91.72 56.53,92.41 PQ3.1
N26661962: length 8
  TOP w0.254: PR507.2 PC510.1 219.09,105.04 218.86,105.27 v2(218.58,105.27)
  BOTTOM w0.254: v2(218.58,105.27) 218.58,105.81 PR509.1 219.66,105.98 v1(219.86,105.78) 220.36,105.27 PU502.8 220.37,104.07 PR511.2
N26661997: length 6.1
  BOTTOM w0.102: PR510.1 222.18,97.92 v1(223.78,97.92)
  BOTTOM w0.254: PR510.1 221.58,97.32 PR508.2 220.71,97.34 PC509.2 219.09,98.07 PU502.2
N27447034: length 6.4
  BOTTOM w0.102: v3(135.12,81.48) 134.62,81.98 133.65,81.98 133.2,82.44 QE4.2 133.2,82.8 131.98,84.02 131.98,85.59 RE70.2
N27829830: length 2
  TOP w0.102: RZ63.1 190.13,75.26 CZ77.1 190.13,76.87 v3(190.34,77.08)
N28424999: length 13.5
  TOP w0.102: T113.1 126.33,46.26 129.09,49.02 129.42,49.35 129.42,50.19 129.55,50.32 129.55,53.01 130.01,53.47 v2(130.01,54.56)
  BOTTOM w0.076: v2(130.01,54.56) 130.4,54.96 130.4,55.01 131.57,56.18 132.61,56.18 UC1.AW71
N28425002: length 13.5
  TOP w0.102: v2(130.57,54.33) 130.57,53.71 130.19,53.33 129.78,52.92 129.78,50.22 129.65,50.09 129.65,49.26 129.32,48.93 127.68,47.28 T114.1
  BOTTOM w0.076: UC1.AW70 133.17,56 131.63,56 130.99,55.36 130.57,54.94 v2(130.57,54.33)
N28489601: length 4
  BOTTOM w0.102: SW1.2 245.69,95.44 245.66,95.41 RC222.2 244.86,95.41 v3(243.93,94.48)
N28742882: length 2.5
  BOTTOM w0.203: PU801.12 62.1,91.48 62.52,91.9 62.85,91.9 PR835.2
N28742885: length 2.1
  BOTTOM w0.203: PU801.11 61.7,91.64 PR836.2
N28769860: length 3.2
  BOTTOM w0.254: PU401.5 202.78,55 202.27,55.51 v3(202.27,55.72) PR421.2 202.22,56.69 PR422.2
N28771761: length 3.7
  TOP w0.102: v3(202.48,49.75) 203.01,49.75 203.25,49.98 PR425.2
  TOP w0.254: v2(203.62,50.63) 203.47,50.48 PR425.2 203.48,49.97 PR404.2
  BOTTOM w0.254: PU401.14 203.78,50.79 v2(203.62,50.63)
N28771835: length 4.2
  TOP w0.102: PR410.2 v3(205.4,71.01)
  TOP w0.254: PR410.2 205.38,71.97 PR426.2 204.49,71.22 204.28,71.01 v2(203.89,71.01)
  BOTTOM w0.254: v2(203.89,71.01) 203.75,70.87 PU402.14
N28810563: length 1.8
  TOP w0.203: UZ2.10 248.26,52.31 CZ23.1
N28856399: length 16.1
  TOP w0.102: v2(129.47,54.35) 129.47,53.25 129.32,53.11 129.32,50.41 129.2,50.28 129.2,49.45 128.87,49.12 125.28,45.53 T16.1
  BOTTOM w0.076: UC1.BA70 133.51,55.01 133.51,54.4 133.32,54.21 131.39,54.21 131.09,53.92 129.9,53.92 129.5,54.31
  BOTTOM w0.102: 129.5,54.31 v2(129.47,54.35)
N28856402: length 13.1
  TOP w0.102: v2(131.58,54.69) 131.58,53.62 130.06,52.09 130.01,52.04 130.01,50.13 129.88,50 129.88,49.16 129,48.28 T17.1
  BOTTOM w0.076: v2(131.58,54.69) 131.58,55.24 131.84,55.49 132.45,55.49 132.6,55.34 133.01,55.34 133.13,55.47 133.7,55.47 UC1.BA68
N28857231: length 18.6
  TOP w0.102: v2(128.56,53.62) 128.56,50.12 122.83,44.39 T12.1
  BOTTOM w0.076: 129.5,53.19 130.83,53.19 131.52,53.88 133.62,53.88 134.27,54.53 UC1.BB68
  BOTTOM w0.102: v2(128.56,53.62) 128.56,53.62 128.56,53.62 128.99,53.19 129.5,53.19
N28857234: length 16.9
  TOP w0.102: v2(129.06,53.92) 129.06,50.47 128.97,50.38 128.97,49.62 124.14,44.79 T13.1
  BOTTOM w0.076: 129.5,53.56 130.96,53.56 131.46,54.05 133.39,54.05 133.84,54.5 UC1.BB69
  BOTTOM w0.102: 129.5,53.56 129.42,53.56 v2(129.06,53.92)
N28857237: length 1.5
  TOP w0.102: v2(166.37,62.37) 166.33,62.33 166.32,62.33 166.07,62.08 T14.1
  BOTTOM w0.076: v2(166.37,62.37) 166.37,62.34 166.07,62.05 UC1.AK13
N28857240: length 2.2
  TOP w0.102: T15.1 168.26,62.34 v2(166.95,62.34)
  BOTTOM w0.076: v2(166.95,62.34) 166.95,62.25 166.72,62.02 UC1.AK12
N28861827: length 15
  BOTTOM w0.076: 130.8,80 131.56,79.24 131.81,79.24 131.96,79.09 135.84,79.09 136.7,78.22 136.7,77.61 136.93,77.38 136.93,76.31 UC1.C64
  BOTTOM w0.102: 130.8,80 129.91,80.89 129.91,81.46 129.45,81.92 129.45,82.91 v3(128.86,83.5) 128.15,84.2 RC120.1
N28938912: length 0.9
  TOP w0.102: RC29.1 194.98,65.26 CC8.2
N28938914: length 0.9
  TOP w0.102: RC28.1 CC7.2
N29198215: length 7.2
  BOTTOM w0.102: RZ83.1 RZ82.1 172.73,90.63 172.55,90.45 169.35,90.45 v3(169.07,90.17) 169.07,89.11 168.81,88.84 UZ20.4
N29708559: length 25.5
  BOTTOM w0.076: 175.02,54.12 174.68,54.46 173.44,54.46 173.04,54.86 171.97,54.86 171.76,55.07 171.76,55.36 UC1.AY4
  BOTTOM w0.102: T126.1 190.06,48.25 188.46,48.25 187.63,47.42 187.63,47.25 187.06,46.68 181.19,46.68 177.71,50.16 177.71,50.28 177.71,50.47 177.71,50.47 177.71,51.43 175.02,54.12
N29708561: length 26.1
  BOTTOM w0.076: UC1.BB3 172.56,54.21 174.49,54.21 174.81,53.9
  BOTTOM w0.102: T127.1 192.2,49.1 191.44,48.34 190.83,48.34 188.94,46.45 181.09,46.45 177.38,50.16 177.38,51.33 174.81,53.9
N29708599: length 10.7
  BOTTOM w0.076: UC1.AU5 171.03,57.98 171.03,58.44 171.25,58.66 171.29,58.7 172.76,58.7 172.85,58.79 173.52,58.79 173.69,58.96 175.69,58.96 176.36,58.28 177.89,58.28 178.25,57.93 179.37,57.93
  BOTTOM w0.102: 179.37,57.93 180.09,57.93 T128.1
N29708601: length 8.9
  BOTTOM w0.076: UC1.AT5 170.69,58.49 171.06,58.86 171.06,59.13 171.28,59.36 173.54,59.36 173.75,59.15 175.76,59.15 175.77,59.14
  BOTTOM w0.102: T129.1 178.2,58.64 176.27,58.64 175.77,59.14
N29708639: length 15.5
  TOP w0.102: v2(175.7,51.11) 175.88,50.93 175.88,50.51 176.24,50.15 176.45,50.15 179.19,47.42 180.27,47.42 181.45,46.24 T130.1
  BOTTOM w0.076: UC1.BB5 171.47,53.88 173.83,53.88 173.98,53.74
  BOTTOM w0.102: 173.98,53.74 175.68,52.04 175.68,51.13 v2(175.7,51.11)
N30342894: length 2.9
  TOP w0.102: RV19.2 77.96,98.17 QV4.2 v3(77.32,99.8)
N30404696: length 2.3
  TOP w0.102: CZ90.1 274.49,48.48 274.79,48.18 UZ5.12
N30404698: length 1.7
  TOP w0.102: UZ5.10 275.59,48.18 CZ91.1
N30957347: length 2
  TOP w0.102: UV16.8 235.81,89.61 235.99,89.42 235.99,89.11 235.62,88.74 RV121.2
N31877076: length 3.8
  TOP w0.102: LV1.1 87.21,86.52 87.21,85.72 v2(87.82,85.11)
  BOTTOM w0.102: JEDP1.21 87.25,85.68 v2(87.82,85.11)
N32114561: length 1.3
  BOTTOM w0.102: PR814.2 63.07,82.76 v3(63.31,83)
N32198964: length 4.2
  TOP w0.102: PR1500.2 229.17,46.66 PC1504.1 ; PU1500.8 228.89,46.38 PC1504.1 ; PC1504.1 229.15,47.1 229.12,47.12 PR1502.1 229.12,48.28 v3(228.9,48.5)
N32198997: length 4.7
  TOP w0.102: v1(220.58,46) 221.09,45.48 PR1503.1
  TOP w0.254: PU1500.2 222.06,44.12 PC1502.2 221.12,44.17 PR1501.2 PR1503.1
N32427314: length 3
  TOP w0.102: v3(251.81,34.74) 251.29,35.25 CZ46.1 250.71,36.35 250.71,36.54 250.42,36.83 UZ3.12
N32427416: length 3.1
  TOP w0.102: UZ3.10 249.62,36.42 249.87,36.17 249.87,35.89 250,35.77 CZ37.1 250.35,35.24 v3(249.93,34.81)
N32452041: length 2.6
  TOP w0.102: UZ4.12 240.81,46.04 CZ45.1 240.58,45.3 v1(240.1,44.82)
N32452300: length 1.8
  TOP w0.203: UZ2.12 247.47,52.22 CZ38.1
N32454707: length 2.7
  TOP w0.102: UZ3.5 249.62,40.37 RZ71.2 RZ70.2
N32604731: length 1.3
  TOP w0.254: UZ8.6 247.8,41.72 CZ42.1
N32630676: length 1.4
  TOP w0.102: UZ4.10 241.13,46.84 241.02,46.94 CZ69.1
N32860357: length 2.9
  TOP w0.102: RZ64.2 RZ65.2 245.38,46.74 245.17,46.94 244.44,46.94 244.33,46.84 UZ4.5
N32875032: length 1.5
  TOP w0.102: UZ23.6 264.54,28.98 264.83,28.68 CZ100.1
N33000410: length 10.7
  IN3 w0.254: v2(282.54,84.14) 282.45,84.05 282.45,83.11 282.13,82.79 278.45,82.79 277.51,83.73 v2(277.51,84.2)
  BOTTOM w0.254: CL17.1 282.43,84.03 v2(282.54,84.14) ; TL1.4 276.18,85.53 v2(277.51,84.2)
N33000412: length 6.5
  IN3 w0.254: v2(278.1,84.21) 278.91,83.4 v2(281.47,83.4)
  BOTTOM w0.254: TL1.3 277.45,85.46 278.1,84.81 v2(278.1,84.21) ; CL16.1 281.83,83.05 v2(281.47,83.4)
N33000445: length 4.7
  TOP w0.254: CL20.1 272.13,84.04 v2(272.42,83.76)
  BOTTOM w0.254: v2(272.42,83.76) 270.86,83.76 269.83,84.79 TL1.9
N33000449: length 4.7
  TOP w0.254: CL21.1 271.23,84.04 270.76,84.51 269.1,84.51 v2(269.03,84.57)
  BOTTOM w0.254: TL1.10 268.56,85.04 v2(269.03,84.57) v3(269.58,84.03)
N33025707: length 2.8
  BOTTOM w0.102: UZ19.4 168.36,91.05 168.53,91.22 RC320.2 169.53,91.22 169.79,90.96 UC13.4
N33199744: length 5.1
  TOP w0.102: v2(122.65,16.21) 123.28,15.58 T51.1
  BOTTOM w0.102: JDIMM1.165 121.87,18.95 122.31,18.51 122.31,17.15 122.65,16.81 v2(122.65,16.21)
N33290988: length 5.3
  TOP w0.102: CD54.2 72.84,13.51 72.84,14.77 72.37,15.24 v1(72.37,16.33)
  TOP w0.508: RD25.1 73.34,12.12 CD54.2
N33292056: length 2.2
  TOP w0.102: CD36.2 123.4,11.79 123.4,12.63 RD21.1
N33298471: length 6.2
  TOP w0.102: T55.1 202.86,15.27 203.41,15.83 v2(203.62,15.83)
  BOTTOM w0.102: JDIMM2.165 203.87,16.26 203.62,16.01 v2(203.62,15.83)
N33803532: length 3.2
  TOP w0.102: v2(121.37,14.13) 120.99,14.51 T50.1
  BOTTOM w0.102: JDIMM1.162 121.12,13.03 121.37,13.28 v2(121.37,14.13)
N33905280: length 3.4
  TOP w0.102: v2(203.62,13.21) 203.19,13.64 T54.1
  BOTTOM w0.102: JDIMM2.162 203.12,12.52 203.62,13.01 v2(203.62,13.21)
N34357818: length 3.8
  TOP w0.102: QC3.2 RC340.1 RC339.1 182.64,37.86 v1(181.88,37.86)
N34532908: length 2.4
  TOP w0.102: RZ62.1 185.76,68.05 185.91,67.9 186.4,67.9 186.67,68.17 UZ12.27
N34764637: length 12.7
  TOP w0.102: v2(166.56,66.5) 166.27,66.79 166.27,66.81 RC337.1
  IN3 w0.122: v2(171.24,62.53) 171.24,62.95 171.42,63.13 171.42,63.67 171.13,63.96 168.08,63.96 167.4,64.63 166.36,64.63 165.98,65.02 165.98,65.57 165.49,66.07 165.49,66.75 165.8,67.06 166,67.06 v2(166.56,66.5)
  BOTTOM w0.076: UC1.AG3 171.83,63.04 171.31,62.53 v2(171.24,62.53)
N34764640: length 8.8
  TOP w0.102: v2(165.7,63.1) 165.13,62.53 164.3,62.53 RC338.1
  BOTTOM w0.076: UC1.AG4 170.85,63.04 170.79,63.1 170.51,63.1 170.45,63.03 170.12,63.03 170.04,63.11 169.87,63.11 169.74,62.98 169.53,62.98 169.45,63.07 169.2,63.07 169.17,63.03 168.85,63.03 168.8,63.08 168.52,63.08 168.37,62.93 168.37,62.71 168.13,62.47 167.81,62.47 167.71,62.58 167.71,63.01 167.3,63.41 166.02,63.41 v2(165.7,63.1)
N35091599: length 3.1
  TOP w0.102: RZ112.2 185.13,66.32 RZ90.2 185.22,66.93 v1(186.05,66.93) 186.44,66.93 186.67,67.17 UZ12.29
N35325357: length 6.2
  TOP w0.102: RZ113.2 196,64.73 197.05,63.68 197.05,62.8 QZ9.2 v1(200,61.71)
N36315919: length 2.5
  BOTTOM w0.102: RE90.2 130.45,87.69 QE11.3 131.35,86.79 RE70.1
N36446510: length 1.6
  TOP w0.102: RV661.2 233.67,95.75 UV29.1
N36618758: length 3.9
  TOP w0.102: UV29.10 228.48,95.75 228.07,95.35 CV619.1 RV662.1 226.94,94.31 v1(226.94,93.63)
N36624941: length 16.1
  TOP w0.102: v2(266.22,55.11) 266.15,55.18 UE2.A57 ; v2(261.2,51.62) RE313.1 260.44,51.62 259.55,52.51 259.03,52.51 258.35,51.83 257.27,51.83 256.29,50.86 RE312.1
  BOTTOM w0.102: v2(261.2,51.62) 261.2,52.02 v1(261.42,52.24) 261.6,52.42 261.6,55.1 262.4,55.9 265.43,55.9 v2(266.22,55.11)
N36682340: length 33.9
  TOP w0.102: UZ26.4 160.98,37.8 161.1,37.67 161.71,37.67 RZ120.2 162.15,38.96 v1(162.27,39.08) 165.32,39.08 170.38,34.02 189.28,34.02 189.61,33.69 UC14.4
N39294024: length 2.6
  BOTTOM w0.254: PU402.5 v2(198.9,69.87) 198.35,69.87 PR424.1 PR423.1
N39307859: length 5.6
  BOTTOM w0.254: v3(88.73,59.32) 87.36,57.96 PR202.1
N39307882: length 2.4
  BOTTOM w0.102: v3(95.41,55.82) PR210.2
  BOTTOM w0.203: PU201.7 95.31,54.71 PR210.2
N39307950: length 3.4
  BOTTOM w0.203: PU201.12 92.88,52.01 v2(92.94,51.95)
  BOTTOM w0.254: v2(92.94,51.95) 92.94,51.45 92.7,51.21 PC207.2 PR201.1
N39307975: length 2.6
  BOTTOM w0.203: PR207.2 94.86,52.71 94.86,53.49 94.44,53.91 PU201.9
N39352217: length 1.9
  TOP w0.254: PR105.1 PR104.1 219.01,69.04 v2(219.11,69.14)
N39352229:
  vias: v3(216.75,75.2)
N39352417:
  vias: v3(220.23,60.09)
N39352440: length 1.3
  BOTTOM w0.102: PC114.1 v3(217.83,65.03)
N39352447: length 0.9
  BOTTOM w0.178: PR108.1 222.28,68.35 PC113.2
N39352755: length 1.9
  BOTTOM w0.102: v3(224.81,59.15) 224.64,58.98 PC127.2
  BOTTOM w0.254: PC127.2 223.86,58.96 PR117.1
N39361921: length 2.9
  TOP w0.102: PR101.1 229.75,62.16 229.95,62.36 PU101.4 230.77,62.36 231.19,61.93 v1(231.6,61.93)
N39431037: length 3.8
  TOP w0.254: v2(99.34,73.22) 99.34,73.75 99.33,73.77 PR661.1
  BOTTOM w0.254: PL603.3 98.82,73.74 v2(99.34,73.22)
N39431059: length 2.5
  BOTTOM w0.102: PC671.1 90.85,68 90.19,68.66 v3(89.77,68.66)
N39431065:
  vias: v3(94.5,66.69)
N39431067:
  vias: v3(94.48,68.44)
N39431108: length 2.6
  TOP w0.102: v2(99.99,68.36) 99.99,68.24 v1(100.4,67.83)
  TOP w0.254: PR671.1 99.61,68.36 v2(99.99,68.36)
  BOTTOM w0.203: PU605.1 99.38,67.69 99.94,68.25 99.94,68.36 v2(99.99,68.36)
N39431132: length 1.5
  BOTTOM w0.102: v3(85.2,77.83) 85.87,77.17 PC655.1
N39431138: length 4.1
  BOTTOM w0.381: PR660.2 87.78,75.51 87.18,74.91 85.76,74.91 84.98,75.68 v3(84.98,76.06)
N39431140: length 1.6
  BOTTOM w0.381: PC655.2 87.78,78.37 v3(87.53,78.63)
N39431166: length 2
  TOP w0.254: v2(93.81,76.94) 93.55,77.21 PR659.1
  BOTTOM w0.203: v2(93.81,76.94) 93.74,76.86 PU603.1
N39433959: length 1.8
  TOP w0.102: v3(89.68,63.73) PR650.2
  TOP w0.254: PR650.2 PC647.2
N39434015: length 0.9
  BOTTOM w0.254: PR639.1 PC629.2
N39434922: length 37
  TOP w0.254: v2(75.98,60.53) 75.72,60.79 v1(75.72,61.15) 75.89,61.32 PR631.2 76.77,61.42 PR610.1
  IN1 w0.254: v2(75.98,60.53) 78.12,60.53 80.5,62.92 86.63,62.92 87.01,63.3 87.41,63.3 87.87,62.84 87.87,62.52 88.84,61.55 90.49,61.55 90.77,61.83 90.77,63.09 90.23,63.63 90.23,65.13 90.66,65.56 90.66,65.73 93.04,68.1 98.11,68.1 98.87,68.86 100.32,68.86 100.57,68.61 v2(100.57,68.38)
  BOTTOM w0.254: PH601.2 100.06,69.04 100.57,68.53 v2(100.57,68.38)
N39435160: length 1.9
  BOTTOM w0.102: v3(83.96,60.47) 83.82,60.33 PC627.1
  BOTTOM w0.254: PC627.1 PR632.2
N39435223: length 50
  IN1 w0.254: v2(89.37,62.41) 88.48,63.3 88.48,65.71 88.99,66.22 89.75,66.22 89.8,66.17 90.54,66.17 90.82,66.45 90.82,66.55 91.17,66.91 93.51,69.24 105.05,69.24 107,71.19 107,75.04 107.35,75.4 107.35,76.53 107.35,77.16 106.03,78.49 105.94,78.49 105.63,78.49 105.62,78.49 100.73,78.49 99.95,77.72 95.91,77.72 95.11,76.92 94.65,76.92 94.22,77.35 v2(94.22,77.47)
  BOTTOM w0.254: v2(89.37,62.41) 89.96,61.82 v3(89.96,61.13) 89.74,60.91 PR647.2 PR635.1 ; PH603.2 93.71,77.98 v2(94.22,77.47)
N39435244: length 1.7
  BOTTOM w0.203: 101.05,83.53 PU606.7
  BOTTOM w0.254: PR679.1 102,84.35 101.51,83.87 101.39,83.87 101.05,83.53
N39435256: length 1
  BOTTOM w0.254: PH602.1 97.65,59.25 PR628.2
N39435262: length 2.1
  TOP w0.102: v3(83.86,71.09) 83.37,71.58 PC631.1
  TOP w0.254: PC631.1 82.92,71.56 PR630.2
N39435305: length 8.4
  TOP w0.203: v2(76.07,70.05) 76.5,69.61 v3(76.7,69.61) 78.87,69.61 79.08,69.82 80.05,69.82 80.32,69.55 80.32,69.52 80.79,69.52 81.43,68.88 PU602.28
  BOTTOM w0.254: v2(76.07,70.05) 75.91,70.21 PC632.1 PR636.1
N39435330: length 3.7
  TOP w0.203: v2(83.91,62.01) 83.43,62.48 PU602.8
  BOTTOM w0.254: PR638.2 82.94,61.22 PC627.2 83.37,61.24 83.91,61.78 v2(83.91,62.01)
N39435350: length 1.9
  BOTTOM w0.102: v3(76.57,60.44) 76.69,60.56 PC617.2
  BOTTOM w0.254: PR621.1 78.4,60.56 PC617.2
N39435414: length 2.3
  TOP w0.203: PU602.38 78.45,64.67 v2(78.4,64.72)
  BOTTOM w0.254: PR678.2 v2(78.4,64.72)
N39435497: length 6
  TOP w0.203: PU602.20 85.39,67.47 85.84,67.92
  TOP w0.254: PR640.1 87.72,68.15 87.29,67.72 86.75,67.72 86.3,68.18 v2(86.3,68.38) 85.84,67.92
  BOTTOM w0.254: PC630.1 87.49,67.62 87.1,67.62 87.01,67.71 86.73,67.71 86.3,68.14 v2(86.3,68.38)
N39435571: length 1.9
  TOP w0.102: v3(77.48,74.42) PC640.1
  TOP w0.254: PC640.1 PR646.2
N39435587: length 2
  TOP w0.102: PC601.1 81.08,72.5 v3(81.22,72.63)
  TOP w0.254: PC601.1 80.15,71.63 PR652.2
N39435611: length 3.1
  BOTTOM w0.254: v3(90.24,65.38) 90.24,65.79 89.66,66.37 PR644.1 88.71,66.35 PC630.2
N39435615: length 1.8
  BOTTOM w0.102: v3(75.02,72.53) PR641.1
  BOTTOM w0.254: PC632.2 75.88,71.58 PR641.1
N39435631: length 0.9
  BOTTOM w0.254: PH604.1 PR642.2
N39435662: length 2.2
  TOP w0.203: v2(78.98,63.86) 78.99,63.87 PU602.40
  BOTTOM w0.254: PR616.2 78.6,63.48 v2(78.98,63.86)
N39435668: length 6.8
  TOP w0.203: v2(78.4,64.11) 78.52,64.11 78.73,64.32 79.44,64.32 79.48,64.27 PU602.39
  BOTTOM w0.102: PR614.2 75.48,61.81 v3(75.33,61.66)
  BOTTOM w0.254: PR614.2 PR612.2 75.48,63.55 76.03,64.11 v2(78.4,64.11)
N39435690: length 0.9
  BOTTOM w0.254: PR623.1 PC621.2
N39435692: length 6.4
  TOP w0.203: PU602.5 82.23,62.16 81.9,61.83 81.42,61.83 v2(81.34,61.9)
  BOTTOM w0.203: PR622.2 PR621.2 PR623.2 79.34,61.65 79.83,62.14 81.1,62.14 v2(81.34,61.9)
N39435712: length 0.9
  BOTTOM w0.254: PH605.1 PR657.2
N39435768: length 2.5
  TOP w0.203: v2(81.75,62.34) 81.75,62.35 81.83,62.43 PU602.4
  BOTTOM w0.254: PC616.2 81.75,63.91 PR617.2 v2(81.75,62.34)
N39435770: length 0.9
  BOTTOM w0.254: PR617.1 PC614.2
N39435786: length 4
  TOP w0.203: PR610.2 78.98,61.42 79.69,62.13 80.89,62.13 81.29,62.53 81.29,62.54 81.43,62.68 PU602.3
N39435815: length 4.3
  TOP w0.203: v2(79.23,62.41) 79.29,62.46 80.76,62.46 80.96,62.67 80.96,62.67 81.03,62.74 PU602.2
  BOTTOM w0.254: PR613.2 PC613.2 79.87,63.05 79.51,62.69 v2(79.23,62.41)
N39435886: length 5.6
  TOP w0.203: PR602.1 76.87,67.24 77.73,67.24 77.76,67.27 78.29,67.27 78.75,66.81 v2(78.75,66.35) 78.83,66.27 PU602.34
  BOTTOM w0.254: v2(78.75,66.35) 78.75,66.22 PC603.1
N39435890: length 4.9
  TOP w0.203: PU602.33 79.35,66.67 78.43,67.6 78.17,67.6 v2(78.04,67.73) 78.03,67.72 PR603.1
  BOTTOM w0.254: v2(78.04,67.73) 79.02,66.76 PC604.1
N39435969: length 2.2
  TOP w0.203: PU602.32 79.47,67.07 78.89,67.66 v2(78.89,67.78)
  BOTTOM w0.254: PR608.1 78.9,67.8 v2(78.89,67.78)
N39435973: length 2.8
  TOP w0.203: v2(78.79,68.42) 79.11,68.42 79.37,68.16 79.37,67.67 79.56,67.47 PU602.31
  BOTTOM w0.254: v2(78.79,68.42) 79.35,68.42 PR611.1
N39435987: length 1.9
  BOTTOM w0.102: PC639.2 89.66,63.71 v3(89.7,63.67)
  BOTTOM w0.254: PC639.2 88.73,63.68 PR645.1
N39630753: length 6.3
  TOP w0.102: v3(53.89,16.05) 53.73,15.89 PC4.1 ; PQ2.2 54.58,13.12 54.37,13.34 54.37,14.05 PC4.1 ; PC4.1 52.93,14.69 52.77,14.52 52.77,13.9 52.95,13.72 PR4.2
N39645644: length 3.5
  TOP w0.203: PU602.1 80.63,62.95 80.48,62.79 79.88,62.79 79.74,62.93 78.97,62.93 78.57,62.53 v2(78.57,62.39)
  BOTTOM w0.254: v2(78.57,62.39) 78.37,62.59 PR620.2
N39649009: length 5.2
  TOP w0.102: v3(57.83,86.73) 57.84,86.74 57.84,86.89 58.69,87.73 v2(58.69,87.73)
  TOP w0.254: v2(58.69,87.73) 58.7,87.71 PC808.2
  BOTTOM w0.203: PU801.2 v2(58.69,87.73)
  BOTTOM w0.254: PR806.2 PC809.1 57.77,87.68 58.64,87.68 v2(58.69,87.73)
N39649495: length 11.8
  TOP w0.254: PR804.2 42.18,75.7 PC802.2 43.45,75.72 PQ801.2 43.95,74.17 44.39,73.74 45.98,73.74 v3(47.46,75.23) 49.03,76.79 PQ803.2
N39649980: length 5.5
  TOP w0.254: v3(59.66,85.33) 59.4,85.6 PC810.1 58.86,87.1 v2(58.71,87.1)
  BOTTOM w0.203: v2(58.71,87.1) 58.94,87.33 PU801.1
  BOTTOM w0.254: v2(58.71,87.1) 58.61,87.2 57.64,87.2 PC809.2 56.65,87.05 PR807.2
N39660507: length 3.4
  TOP w0.102: PU902.2 255.04,92.85 254.77,93.12 254.21,93.12 253.83,92.74 PR907.2 PR905.2
N48705653: length 4
  TOP w0.102: v3(55.26,97.32) 55.35,97.24 PR7.1
  TOP w0.254: PR7.1 56.32,96.37 PR5.2 56.25,95.84 56.32,95.76 56.32,94.62 PQ3.3
N48705663: length 8.4
  TOP w0.254: PQ4.2 v2(58.43,97.71) ; v2(53.48,97.08) 52.95,97.08 52.62,96.75 PR10.2 PR8.1
  BOTTOM w0.254: v2(58.43,97.71) 57.02,97.71 56.4,97.08 v1(55.27,97.08) v2(53.48,97.08)
N48705665: length 6.1
  TOP w0.102: PR9.2 60.57,97.89 v3(60.34,98.11)
  TOP w0.254: PR11.1 60.59,97.16 PR9.2 59.6,97.18 PQ4.1 58.39,95.97 PQ3.2
N48716673: length 3.2
  TOP w0.254: PU901.28 22.84,83.29 v2(22.54,82.99)
  BOTTOM w0.508: PR933.1 23.18,82.35 v2(22.54,82.99)
N49522215: length 11.6
  BOTTOM w0.102: PR808.2 v3(42.56,80.2)
  BOTTOM w0.254: PR809.2 46.19,78.54 PQ805.2 45.07,76.28 43.57,76.28 42.46,77.4 PQ804.2 ; PR810.2 41.16,77.5 41.26,77.4 PQ804.2 ; PQ804.2 42.1,78.77 PR808.2
N49522729: length 6.5
  TOP w0.254: PQ803.1 46.95,77.75 46.67,78.03 v1(46.67,79.89) 46.67,81.69 46.85,81.87 PR802.2
N49522731: length 6.7
  TOP w0.254: PQ801.1 45.99,77.3 46.24,77.55 46.24,81.72 46.09,81.87 PR802.3
N49522780: length 1.9
  TOP w0.254: 41.26,81.17 41.69,81.61 41.69,82.73 v3(41.56,82.87)
N78957489: length 3.2
  TOP w0.102: PR912.2 76.32,28.36 PQ908.1 75.73,28.98 76.32,29.56 v3(76.74,29.56)
N78967043: length 31.7
  TOP w0.102: PU903.4 69.91,11.3 70.21,11.6 v2(70.55,11.6) ; v2(77.82,19.31) 77.82,19.33 79.83,21.35 v1(79.83,23.22) 79.83,27.83 77.45,30.21 75.03,30.21 PQ908.2
  IN2 w0.122: v2(70.55,11.6) 71.33,11.6 72.1,12.37 72.1,17.35 72.38,17.64 73.73,18.98 74.77,18.98 75.4,19.61 77.51,19.61 v2(77.82,19.31)
N79002827: length 3.1
  TOP w0.102: v3(256.89,93.51) 256.68,93.72 256.12,93.72 255.84,93.43 v2(255.68,93.43) 255.69,93.45 PU902.4
  BOTTOM w0.102: v2(255.68,93.43) 255.87,93.62 PQ902.2
N79023703: length 2.1
  TOP w0.254: PU901.19 28.68,86.1 PR927.1
N79030038: length 4.3
  TOP w0.102: v3(67.55,17.87) 66.75,17.87 PR917.2 66.56,17.35 67.07,16.84 PQ911.3 67.6,16.52 67.78,16.34 67.78,16.05 67.6,15.87 PQ911.2
N79030087: length 3.4
  TOP w0.102: PQ911.6 64.82,15.22 64.37,14.76 v2(64.37,14.75) 64.37,14.66 63.68,13.97 63.4,13.97 63.17,13.75 PR936.2
N79030091: length 2.6
  TOP w0.102: PR911.1 PR936.1 62.71,13.15 PQ910.2
N79030745: length 5.5
  TOP w0.102: v3(67.16,10.62) 66.13,11.65 PQ910.1
  TOP w0.254: PQ910.1 66.14,12.2 67.68,12.2 68.44,12.96 PD904.2
N79114801: length 4.8
  TOP w0.102: v3(57.91,14.68) 57.91,14.55 58.32,14.14 59.16,14.14 59.42,13.87 PD4.2 59.09,13.41 58.57,13.41 PQ2.1

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 83.53,57.67 84.04,57.67 84.04,58.22 84.33,58.22 84.33,57.67 84.84,57.67 84.84,58.22 85.18,58.22 86.8,56.6 86.8,55.43 86.7,55.33 81.42,55.33 81.42,56.67 82.97,58.22 83.53,58.22
1.2V_B+ on BOTTOM (solid shape): 86.32,58.42 86.32,56.6 81.6,56.6 81.52,56.67 81.52,57.31 81.6,57.38 82.92,57.92 82.92,58.45 83.02,58.55 86.19,58.55
1.5VSP on BOTTOM (solid shape): 218.25,99.63 218.25,98.26 217.95,97.96 214.44,97.96 214.04,98.36 213.02,98.36 213,98.39 213,98.9 212.97,98.92 212.51,98.92 212.49,98.9 212.49,98.39 212.46,98.36 212.26,98.36 212.23,98.39 212.23,99.46 212.61,99.84 218.05,99.84
2.5VSP on TOP (solid shape): 222.54,43.29 224.54,43.29 224.72,43.1 224.72,40.72 223.45,39.45 222.75,39.45 222.54,39.45 221.62,39.45 221.58,39.47 221.57,39.5 221.57,40.01 221.13,40.01 221.13,39.5 221.11,39.47 221.08,39.45 220.86,39.45 220.81,39.51 220.79,39.56 220.79,40.27 220.79,40.54 221.02,40.77 221.02,42.47 220.79,42.7 220.79,43.49 220.8,43.52 220.84,43.54 222.29,43.54
3V_SN on TOP (solid shape): 217.99,69.93 217.99,67.62 217.98,67.61 217.98,65.62 217.43,65.07 215.12,65.07 214.87,65.32 214.87,69.73 215.18,70.03 217.89,70.03
3V_VIN on TOP (solid shape): 228.96,73.3 228.96,71.24 228.31,70.59 226.2,70.59 225.69,71.1 225.69,73.36 225.69,73.36 225.69,73.54 225.94,73.79 228.47,73.79
3V_VIN on BOTTOM (solid shape): 229.96,72.89 229.96,70.74 229.92,70.7 229.35,70.7 229.33,70.72 229.33,71.25 228.78,71.25 228.78,71.24 228.78,70.71 228.77,70.7 228.54,70.7 228.53,70.71 228.53,71.24 228.53,71.25 227.99,71.25 227.98,71.23 227.98,70.72 227.95,70.69 225.98,70.69 225.67,71.01 225.67,73.5 225.47,73.7 223.39,73.7 222.16,72.47 220.71,72.47 220.59,72.6 220.59,74.74 221.3,75.46 227.39,75.46
5V_SN on TOP (solid shape): 219.32,60.12 220.28,60.12 220.46,59.93 220.46,58.39 220.18,58.11 216.45,58.11 216.23,58.33 216.23,60.04 216.32,60.13 219.32,60.13
5V_VIN on TOP (solid shape): 228.33,66.55 228.33,65.61 227.91,65.19 227.91,64.4 227.8,64.29 227.29,64.29 226.81,64.77 225.56,64.77 225.26,65.08 225.26,66.76 225.39,66.88 228,66.88
5V_VIN on BOTTOM (solid shape): 226.84,67.76 226.84,67.21 227.36,67.21 227.38,67.24 227.38,67.77 227.4,67.79 227.72,67.79 227.78,67.72 227.78,67.26 228.28,66.76 228.28,65.76 227.9,65.37 227.9,64.42 227.74,64.27 227.32,64.27 226.81,64.77 225.34,64.77 224.57,64.01 224.22,64.01 223.94,63.73 223.94,63.28 223.84,63.17 222.39,63.17 222.29,63.27 222.29,63.29 222.29,65.74 222.29,65.76 222.3,65.78 222.67,66.15 224.37,66.15 225.69,67.47 225.69,67.74 225.71,67.77 225.74,67.79 225.98,67.79 226.02,67.77 226.03,67.74 226.03,67.24 226.06,67.21 226.57,67.21 226.58,67.23 226.58,67.74 226.59,67.78 226.63,67.79 226.81,67.79
+0.6V_DDR_VTT on TOP (solid shape): 90.72,60.02 90.72,59.57 90.69,59.54 90.69,59.29 90.64,59.24 90.25,59.24 90.25,58.68 90.02,58.68 90.02,59.24 89.65,59.24 89.57,59.31 89.57,59.97 89.66,60.06 90.68,60.06
+0.6V_DDR_VTT on TOP (solid shape): 227.62,16.46 227.62,15.6 228,15.22 228,13.6 227.16,12.76 227.16,11.16 226.77,10.77 226.21,10.77 226.11,10.86 226.11,14.09 226.22,14.35 226.11,14.62 226.11,16.81 226.15,16.85 227.24,16.85
+0.6V_DDR_VTT on TOP (solid shape): 145.81,13.39 145.81,12.2 145.6,12 144.59,12 143.93,11.33 143.91,11.32 143.89,11.31 141.72,11.31 141.28,10.88 140.55,10.88 140.42,11 140.42,12.84 140.45,12.88 140.48,12.95 140.51,12.97 140.51,13.12 140.55,13.16 141.06,13.16 141.24,12.98 141.25,12.96 141.52,12.64 141.92,12.76 141.93,12.78 141.95,12.78 142.45,12.78 142.71,13.03 143.38,13.03 143.57,12.98 143.75,13.03 143.78,13.03 143.84,13.09 143.88,13.14 144.2,13.46 145.74,13.46
+0.6V_DDR_VTT on BOTTOM (solid shape): 227.86,13.92 227.86,13.23 227.28,12.66 227.28,10.99 227.19,10.9 227.06,10.9 226.97,10.99 226.97,12.64 226.64,12.98 226.64,14.09 226.96,14.42 227.35,14.42
+0.6V_DDR_VTT on BOTTOM (solid shape): 145.84,13.44 145.84,13.1 145.74,13 145.64,13 145.28,12.64 145.28,10.97 145.19,10.88 145.06,10.88 144.97,10.97 144.97,12.88 144.82,13.03 144.82,13.43 144.98,13.58 145.7,13.58
+0.6V_DDR_VTT on IN1 (solid shape): 228.2,14.23 228.2,13.06 226.75,11.61 226.38,11.61 226.02,11.98 226.02,12.9 226.49,13.37 226.49,14.5 226.75,14.76 227.67,14.76
+0.6V_DDR_VTT on IN1 (solid shape): 145.86,13.42 145.86,13.37 145.86,13.33 145.86,11.78 145.76,11.68 144.68,11.68 144.57,11.79 144.57,13.5 144.69,13.61 145.66,13.61
+0.6V_DDR_VTT on IN4 (solid shape): 93.56,60.23 93.56,60.05 93.1,59.59 89.6,59.59 89.39,59.8 89.39,60.51 89.52,60.63 93.15,60.63
+0.6V_DDR_VTT on IN4 (solid shape): 145.83,13.47 145.83,12.09 145.71,11.96 144.91,11.96 144.62,12.26 144.62,13.37 144.81,13.56 145.74,13.56
+0.6V_P on TOP (solid shape): 89.89,58.55 89.91,58.55 90.35,58.55 90.37,58.55 90.37,59.1 90.38,59.11 90.64,59.11 91.1,58.65 91.1,56.44 90.89,56.24 89.67,56.24 89.45,56.47 89.45,58.93 89.62,59.11 89.89,59.11
+0.6V_P on BOTTOM (solid shape): 91.45,57.94 91.45,57.08 92.01,56.52 92.07,56.44 92.15,56.38 92.19,56.34 92.19,55.45 92.14,55.4 92.04,55.4 91.99,55.45 91.99,56.24 91.78,56.44 91.58,56.44 91.45,56.32 91.45,56.32 91.4,56.26 91.4,55.07 91.32,54.99 90.51,54.99 90.49,55.02 90.49,55.99 90.05,56.42 90.05,57.92 90.16,58.02 91.38,58.02
+0.9V_LAN on TOP (solid shape): 266.71,91.05 266.71,89.54 266.66,89.48 266.48,89.48 266.36,89.36 266.2,89.36 266.15,89.41 266.15,89.67 266.22,89.78 266.24,89.9 266.24,90.72 266.14,90.82 266.14,91.08 265.43,91.79 264.65,91.79 264.48,91.95 264.48,92.28 264.55,92.35 265.42,92.35
+0.9V_LAN on TOP (solid shape): 260.86,92.87 260.86,92.12 261.26,91.72 261.81,91.72 262.8,90.73 262.8,89.44 262.75,89.39 262.27,89.39 262.18,89.49 262.18,90.52 262.09,90.6 261.5,90.6 260.49,91.62 260.44,91.68 260.38,91.73 260.17,91.94 260.17,92 260.05,92.12 259.99,92.12 259.92,92.19 259.92,92.79 260.08,92.96 260.77,92.96
+0.9V_LAN on BOTTOM (solid shape): 261.89,92.99 262.8,92.99 262.8,93.01 264.3,93.01 265.37,91.94 265.37,90.69 265.14,90.47 261.94,90.47 261.41,91 260.72,91 260.63,91.04 260.63,91.14 260.53,91.55 260.11,91.59 260.01,91.58 259.96,91.67 259.96,92.83 260.14,93.01 261.87,93.01
+0.9V_LAN on BOTTOM (solid shape): outline of 117 points within 258.11,80.64 267.17,86.22
+0.9V_LAN on IN3 (solid shape): outline of 163 points within 259.4,84.12 262.32,92.14
+1.0V_APLLEBB on TOP (solid shape): 162.89,70.89 162.89,70.11 162.89,70.1 163.23,69.76 163.23,69.46 162.8,69.03 162.5,69.03 162.49,69.02 162.46,69.02 162.46,68.99 162.35,68.88 162.35,68.34 162.31,68.3 162.11,68.3 162.11,68.3 161.73,68.3 161.69,68.34 161.69,69.2 161.84,69.34 162.29,69.34 162.34,69.34 162.63,69.75 162.18,69.97 162.17,69.97 162.05,69.97 161.86,70.16 161.86,70.77 162.06,70.97 162.82,70.97
+1.0V_CLK2 on TOP (solid shape): outline of 289 points within 162.25,71.1 163.61,77.17
+1.0V_CLK3 on IN2 (solid shape): outline of 393 points within 161.43,70.84 164.54,76.13
+1.0V_CLK6 on BOTTOM (solid shape): 171.44,82.35 171.44,80.43 170.89,79.89 170.85,79.89 170.35,79.38 170.35,79.36 168.62,77.64 168.53,77.64 168.25,77.36 168.25,76.75 168.13,76.64 167.75,76.64 167.6,76.79 167.6,77.06 167.61,77.12 167.61,77.2 167.62,77.31 167.89,77.42 168.01,77.72 168.08,77.75 168.35,77.89 168.4,78.18 168.39,78.21 168.48,78.3 168.62,78.38 168.71,78.53 168.77,78.59 168.77,78.8 168.81,78.81 168.94,78.88 169.03,79.01 169.08,79.06 169.16,79.07 169.65,79.34 169.33,79.81 169.25,79.88 169.27,79.98 170.09,80.8 170.09,80.88 170.24,81.18 170.09,81.49 170.09,81.92 169.94,82.07 169.53,82.07 169.48,82.12 169.48,82.53 169.56,82.6 171.18,82.6
+1.0V_DTS on BOTTOM (solid shape): 178.55,70.9 178.55,70.41 178.45,70.31 177.86,70.31 177.35,69.8 176.16,69.8 175.41,69.05 174.47,69.05 174.32,68.9 173.63,68.9 173.62,68.89 173.14,68.89 172.91,68.89 172.81,68.99 172.81,69.14 173.82,69.14 174.41,69.73 174.41,69.73 175.27,70.59 175.3,70.61 175.32,70.62 175.63,70.93 177.12,70.93 177.36,70.83 177.58,70.97 178.47,70.97
+1.0V_MPHYAON on TOP (solid shape): outline of 600 points within 163.38,71.1 177.39,78.48
+1.0V_MPHYAON on BOTTOM (solid shape): 178.32,74.45 178.32,73.49 178.7,73.11 178.7,72.38 178.66,72.35 178.34,72.35 178.34,72.34 178.14,72.34 177.48,71.68 176.1,71.68 175.89,71.78 175.67,71.68 175.55,71.68 175.35,71.49 175.1,71.74 174.31,71.74 174.31,71.74 173.92,71.74 173.88,71.7 173.51,71.7 173.26,71.44 172.96,71.44 172.86,71.54 172.86,71.75 173,71.88 173.66,71.88 173.68,71.91 173.72,71.91 174.84,73.02 175.05,73.02 175.49,72.98 175.67,73.38 175.67,73.41 175.84,73.58 175.84,74.81 176.06,75.02 177.75,75.02
+1.0V_MPHYGT on TOP (solid shape): 165.21,70.74 165.21,70.16 165.44,69.93 165.83,69.93 166.1,69.66 166.1,69.19 166,69.09 164.43,69.09 164.26,69.09 163.99,69.36 163.99,69.78 163.79,69.98 163.66,69.98 163.54,70.11 163.54,70.9 163.61,70.97 164.98,70.97
+1.0V_MPHYGT on BOTTOM (solid shape): 165.75,69.98 165.75,69.54 165.22,69.02 164.5,69.02 164.17,69.35 164.14,69.4 164.1,69.43 164.1,69.45 163.97,69.57 163.97,69.75 163.77,69.96 163.77,70.18 163.87,70.29 165.44,70.29
+1.0V_MPHYGT on BOTTOM (solid shape): outline of 158 points within 171.16,83.32 176.72,88.02
+1.0V_MPHYGT on IN2 (solid shape): outline of 1010 points within 163.92,68.94 174.49,84.87
+1.0V_MPHYGT on IN3 (solid shape): outline of 1408 points within 164.04,68.69 171.97,82.12
+1.0V_MPHYGT on VCC: 168.26,68.2 167.63,68.84 164.2,68.84 163.87,69.12 163.87,71.57 164.87,72.56 164.87,85.64 165.15,85.92 174.11,85.92 175.37,84.66 177.83,84.66 178.01,84.48 178.01,82.86 176.64,81.49 174.73,81.49 172.55,79.31 172.55,69.02 171.74,68.2
+1.0V_PRIM on TOP (solid shape): 163.79,66.36 163.79,65.94 163.7,65.85 163.67,65.86 163.34,65.78 163.21,65.47 163.21,65.45 162.8,65.04 161.64,65.04 161.23,65.46 160.44,65.46 160.18,65.71 160.18,66.32 160.31,66.45 160.97,66.45 161.26,66.16 161.28,66.11 161.28,66.07 161.33,66.02 161.5,65.89 161.72,65.88 161.79,65.9 161.84,65.93 161.87,65.95 161.89,65.97 162.23,65.97 162.32,65.95 162.42,65.97 162.48,65.97 163.06,66.55 163.6,66.55
+1.0V_PRIM on TOP (solid shape): outline of 282 points within 159.06,85.75 174.05,91.4
+1.0V_PRIM on BOTTOM (solid shape): 202.8,61.4 202.8,59.21 202.61,59.02 201.21,59.02 200.97,59.26 199.45,59.26 199.27,59.08 198.41,59.08 198.08,59.41 198.08,61.42 198.33,61.68 202.53,61.68
+1.0V_PRIM on BOTTOM (solid shape): 160.66,88.68 160.66,88.06 160.66,88.05 160.66,86.4 161.25,85.81 161.25,85.17 161,84.92 159.47,84.92 159.26,85.13 159.26,85.67 159.57,85.98 159.57,86.87 159.26,87.18 159.26,88.61 159.64,89 160.34,89
+1.0V_PRIM on BOTTOM (solid shape): 212.94,55.68 212.94,53.93 212.91,53.9 212.79,53.9 212.79,53.8 212.76,53.8 212.76,53.32 212.26,53.32 212.26,53.87 211.51,53.87 211.51,53.8 211.49,53.8 211.49,53.32 211.06,53.32 211.06,53.87 210.31,53.87 210.31,53.8 210.29,53.8 210.29,53.32 209.51,53.32 209.23,53.6 209.23,55.45 209.64,55.86 212.76,55.86
+1.0V_PRIM on BOTTOM (solid shape): 179.81,73.7 180.03,73.47 180.03,73.46 180.31,73.18 180.31,73.07 180.3,73.07 180.3,72.3 180.31,72.3 180.31,72.15 180.3,72.15 180.3,71.52 180.24,71.45 179.83,71.45 179.6,71.68 178.22,71.68 178.22,72.04 178.39,72.21 178.81,72.21 178.81,72.22 179.08,72.22 179.09,72.23 179.24,72.23 179.37,72.37 179.37,73.22 179.27,73.32 178.81,73.32 178.81,73.36 178.7,73.36 178.57,73.49 178.57,74.35 178.73,74.5 179.01,74.5
+1.0V_PRIM on BOTTOM (solid shape): 162.13,66.02 162.32,65.95 162.52,66.02 162.72,66.02 162.75,65.99 163.05,65.7 163.08,65.66 163.18,65.56 163.18,65.38 163.03,65.23 162.81,65.23 162.63,65.3 162.45,65.23 162.16,65.23 161.98,65.3 161.8,65.23 161.51,65.23 161.4,65.33 161.4,65.58 161.43,65.6 161.54,65.68 161.6,65.8 161.6,65.81 161.72,65.93 161.73,65.93 161.81,65.97 161.87,66.02
+1.0V_PRIM on BOTTOM (solid shape): outline of 139 points within 163.79,82.89 176.48,93.7
+1.0V_PRIM on IN2 (solid shape): outline of 3528 points within 156.02,43.56 165.44,68.43
+1.0V_PRIM on IN3 (solid shape): outline of 1297 points within 167.87,71.37 180.95,87.32
+1.0V_PRIM on VCC: 190.66,47.48 188.78,49.36 180.91,49.36 177.36,52.91 172.15,52.91 171.52,53.55 169.12,53.55 168.97,53.54 165.83,56.68 165.4,56.68 164.23,57.86 164.23,60.5 163.47,61.26 163.16,61.26 161.68,61.27 160.49,61.27 160.11,61.65 160.11,66.57 161.86,68.33 167.42,68.33 168.05,67.69 171.95,67.69 173.06,68.81 173.06,79.1 174.95,80.98 176.85,80.98 178.52,82.65 178.52,84.05 179.14,84.66 181.34,84.66 181.85,84.15 185.53,84.15 188.96,80.73 189.85,80.73 190.41,80.16 190.41,79.27 192.75,76.94 192.75,64.24 195.95,61.03 196.03,60.59 196.47,60.51 196.83,60.15 207.5,60.15 207.83,59.82 207.83,56.41 208.87,55.38 214.21,55.38 214.48,55.1 214.48,49.06 214.23,48.8 213.95,48.75 204.46,48.75 203.58,47.87 203.54,47.85 203.54,47.83 203.18,47.48
+1.0V_PRIM_CORE on TOP (solid shape): 163.44,65.19 163.59,65.15 163.73,65.19 163.74,65.19 163.98,65.19 164,65.19 164.01,65.18 164.14,65.1 164.32,65.08 164.34,65.07 164.38,65.03 164.38,64.49 164.3,64.42 164.12,64.42 164.12,64.42 163.79,64.42 163.69,64.32 163.54,64.32 163.49,64.37 162.8,64.37 162.7,64.47 162.7,64.8 162.81,64.91 162.85,64.91 163.13,65.19 163.43,65.19
+1.0V_PRIM_CORE on BOTTOM (solid shape): 199.43,66.63 199.43,66.29 198.88,66.29 198.88,65.74 199.43,65.74 199.43,65.49 198.88,65.49 198.88,64.94 199.43,64.94 199.43,64.55 199.35,64.47 199.35,63.83 199.73,63.45 199.73,62.56 199.35,62.18 198.21,62.18 197.83,61.8 197.24,61.8 196.81,62.23 196.81,65.85 197.7,66.73 199.33,66.73
+1.0V_PRIM_CORE on BOTTOM (solid shape): 161.11,67.67 161.1,67.64 161.25,67.29 161.58,67.48 161.58,67.52 161.72,67.52 161.73,67.48 162.01,67.28 162.23,67.55 162.23,67.57 162.28,67.62 162.35,67.56 162.35,67.54 162.39,67.38 162.52,67.27 162.55,67.26 162.55,67.14 162.36,66.95 162.1,66.95 162.09,66.95 161.89,66.96 161.74,66.84 161.65,66.79 161.57,66.84 161.2,66.94 161.07,66.59 161.08,66.56 161,66.48 161,65.99 161.05,65.94 161.05,65.83 161.05,65.1 161.06,65.1 161.05,65.07 161.16,64.79 161.46,64.77 161.47,64.77 161.77,64.77 161.92,64.62 161.92,64.46 161.89,64.44 161.8,64.4 161.73,64.32 161.72,64.29 161.58,64.29 161.57,64.32 161.38,64.45 161.15,64.39 160.92,64.39 160.91,64.43 160.72,64.67 160.42,64.65 160.38,64.63 159.98,65.03 159.98,67.14 160.52,67.67 160.74,67.67 160.77,67.67 160.87,67.68 160.96,67.71 160.97,67.72 161.06,67.72
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 2674 points within 160.55,57.79 198.26,68.79
+1.0V_PRIM_COREP on BOTTOM (solid shape): 200.93,66.12 204.94,66.12 205.02,66.04 205.02,63.86 204.8,63.64 200.2,63.64 199.56,64.28 199.56,65.06 199.01,65.06 199.01,65.36 199.56,65.36 199.56,65.86 199.01,65.86 199.01,66.16 199.56,66.16 199.56,66.65 200.39,66.65
+1.0V_PRIM_XDP on TOP (solid shape): 90.36,41.1 90.36,40.49 90.11,40.24 89.8,40.24 89.62,40.06 89.62,39.53 89.5,39.4 89.5,38.94 89.42,38.87 88.61,38.87 88.56,38.92 88.56,39.45 88.61,39.5 88.78,39.5 89.01,39.73 89.01,40.03 89.01,40.03 89.01,40.49 89.8,41.28 90.18,41.28
+1.0V_PRIM_XDP on IN4 (solid shape): 91.12,50.99 91.12,50.52 90.97,50.37 90.69,50.37 90.54,50.44 90.38,50.44 90.09,50.15 90.23,49.76 90.23,49.58 90.23,48.64 89.9,48.31 89.67,48.31 89.37,48.62 89.37,50.79 89.78,51.19 90.91,51.19
+1.0V_RUN_VMM on TOP (solid shape): 235.39,99.8 235.4,99.8 235.42,99.78 236.26,99.78 236.59,99.44 236.59,98.7 236.56,98.62 236.49,98.59 236.1,98.21 236.49,97.83 236.56,97.8 236.59,97.73 236.59,96.09 236.34,95.84 235.23,95.84 235.13,95.74 235.09,95.74 235.09,95.7 235.02,95.62 235.02,95.41 234.94,95.34 234.36,95.34 234.26,95.44 234.26,96.95 234.37,97.06 235.04,97.06 235.04,97.07 235.09,97.12 235.09,98.19 234.73,98.56 234.58,98.56 234.57,98.56 234.41,98.6 234.25,98.56 234.24,98.56 234.17,98.56 234.08,98.47 234.01,98.44 233.94,98.47 233.41,98.49 233.37,97.97 233.37,97.75 233.23,97.62 233.23,96.84 232.98,96.59 231.75,96.59 231.65,96.68 231.65,97.94 231.7,97.95 232.03,98.33 231.7,98.71 231.65,98.71 231.65,99.64 231.79,99.78 231.82,99.78 232.09,99.86 232.23,100.1 232.23,100.14 235.04,100.14
+1.0V_RUN_VMM on BOTTOM (solid shape): 225.56,89.29 226.06,89.29 226.06,89.87 226.35,89.87 226.4,89.82 226.4,88.62 226.91,88.11 226.91,86.19 226.78,86.06 224.88,86.06 224.47,85.65 224.47,85.64 224.35,85.52 224.35,80.95 224.12,80.73 219.92,80.73 219.8,80.85 219.8,82.76 221.32,82.76 222.02,83.46 222.02,85.4 223.1,86.48 223.1,89.33 223.17,89.4 224.12,89.4 224.59,89.87 225.56,89.87
+1.0V_RUN_VMM on IN1 (solid shape): 226.11,89.7 226.11,88.72 226.04,88.64 224.96,88.64 224.92,88.68 224.92,89.5 225.2,89.78 226.03,89.78
+1.0V_RUN_VMM on IN1 (solid shape): 236.96,96.26 236.96,94.86 236.66,94.55 236.19,94.55 236.18,94.57 236.13,94.6 236.08,94.63 236.03,94.65 235.98,94.66 235.93,94.66 235.87,94.66 235.82,94.65 235.77,94.63 235.72,94.6 235.68,94.57 235.66,94.55 235.22,94.55 234.88,94.9 234.88,95.4 235.62,95.4 235.63,95.35 235.64,95.29 235.66,95.24 235.69,95.2 235.73,95.15 235.77,95.12 235.82,95.09 235.87,95.06 235.92,95.05 235.98,95.04 236.03,95.04 236.09,95.05 236.14,95.06 236.19,95.09 236.24,95.12 236.28,95.15 236.31,95.2 236.34,95.24 236.36,95.29 236.38,95.35 236.39,95.4 236.38,95.46 236.37,95.52 236.35,95.57 236.33,95.62 236.3,95.66 236.26,95.7 236.21,95.74 236.17,95.76 236.11,95.78 236.06,95.8 236,95.8 235.95,95.8 235.89,95.78 235.84,95.76 235.79,95.74 235.75,95.7 235.71,95.66 235.68,95.62 235.65,95.57 235.63,95.52 235.62,95.46 235.62,95.4 234.88,95.4 234.88,96.33 234.96,96.42 236.8,96.42
+1.0V_RUN_VMM_P on BOTTOM (solid shape): 228.66,92.66 228.66,92.31 228.53,92.17 228.5,92.16 228.46,92.16 228,92.1 227.94,91.63 227.94,91.26 227.95,91.22 227.96,91.16 227.96,90.94 227.98,90.92 227.98,90.12 227.86,90 226.91,90 226.91,90 225.24,90 225.14,90.1 225.14,90.94 225.28,91.08 225.86,91.08 225.9,91.08 226.23,91.16 226.31,91.49 226.31,91.52 226.32,91.54 226.88,92.1 226.88,92.59 227.09,92.79 228.54,92.79
+1.0V_SRAM on BOTTOM (solid shape): 173.64,82.65 173.64,80.42 173.66,80.4 173.66,79.72 173.41,79.47 172.28,79.47 172.26,79.49 172.24,79.49 172.02,79.71 172.02,80.4 172.38,80.75 172.38,82.58 172.53,82.73 173.55,82.73
+1.0V_SRAM on IN2 (solid shape): outline of 432 points within 161.38,67.03 173.74,80.41
+1.0V_SRAM on IN4 (solid shape): outline of 158 points within 160.23,63.71 161.94,68.23
+1.0V_VCCST on BOTTOM (solid shape): 129.32,87.58 129.32,85.75 129.2,85.63 127.95,85.63 127.8,85.78 127.8,87.3 127.72,87.38 127.72,87.68 127.98,87.94 128.97,87.94
+1.0V_VCCST on BOTTOM (solid shape): 161.95,88.16 161.95,87.01 162.77,86.19 162.77,85.39 162.32,85.39 162.32,84.95 162.77,84.95 162.77,83.22 162.65,83.09 162.65,83.08 162.64,83.06 162.6,82.88 162.64,82.7 162.65,82.69 162.65,82.68 162.87,82.45 162.88,82.45 162.99,82.35 163.03,82.35 163.11,82.27 163.11,82.02 163.03,81.94 162.72,81.94 162.52,81.74 162.32,81.74 161.76,82.31 161.76,83.52 161.63,83.65 161.63,85.81 160.83,86.61 160.83,88.13 160.96,88.26 161.85,88.26
+1.0V_VCCST on IN2 (solid shape): outline of 216 points within 159.35,69.96 161.3,76.45
+1.0V_VCCST_C on BOTTOM (solid shape): 166.81,86 166.81,85.67 166.46,85.32 165.78,85.32 165.09,84.63 165.09,84.14 164.89,83.94 163.83,83.94 163.67,84.1 163.21,84.1 163.03,84.28 163.03,84.79 162.98,84.84 162.98,85.07 162.9,85.07 162.9,85.08 162.44,85.08 162.44,85.26 162.9,85.26 162.9,85.27 163,85.27 163,85.63 163.24,85.87 163.42,85.87 163.59,86.03 164.29,86.03 164.5,86.25 166.56,86.25
+1.0V_VCCSTG on BOTTOM (solid shape): 161.61,91.16 161.61,90.68 161.66,90.63 162.11,90.63 162.13,90.65 162.13,91.2 162.14,91.21 162.38,91.21 162.4,91.2 162.4,90.27 162.16,90.03 162.16,89.51 162.67,89 162.67,87.03 162.52,86.88 162.3,86.88 162.15,87.03 162.15,88.62 161.89,88.89 161,88.89 160.9,88.99 160.9,91.05 161.07,91.21 161.56,91.21
+1.0V_VCCSTG_C on BOTTOM (solid shape): 165.2,93.04 165.2,91.7 165.04,91.54 162.56,91.54 162.39,91.37 161.98,91.37 161.97,91.37 161.97,90.84 161.95,90.81 161.83,90.81 161.8,90.84 161.8,91.37 161.79,91.37 161.35,91.37 161.28,91.44 161.28,92.05 161.52,92.28 163.43,92.28 163.62,92.47 163.62,92.95 163.86,93.19 165.05,93.19
+1.0V_VMM_VDD on BOTTOM (solid shape): outline of 619 points within 212.8,80.98 219.67,91.1
+1.0V_VMM_VDD on IN3 (solid shape): outline of 1431 points within 213.75,82.84 221.56,93.98
+1.0V_VMM_VDDTX on BOTTOM (solid shape): 219.19,87.11 219.19,87.1 219.1,86.87 219.19,86.64 219.19,86.5 219.19,86.48 219.18,86.47 219.1,86.08 219.43,85.86 219.49,85.86 219.67,85.68 219.67,85.4 219.67,85.17 220.12,84.73 220.12,83.33 219.67,82.88 219.66,82.88 219.66,82.24 219.42,82 218.91,82 218.28,82.63 218.28,85.51 218.48,85.72 218.48,86.75 218.47,86.75 218.47,86.98 218.48,87.01 218.49,87.01 218.55,87.06 218.6,87.13 218.64,87.19 218.71,87.2 218.83,87.19 218.95,87.23 218.96,87.24 219.07,87.24
+1.0V_VMM_VDDTX on IN1 (solid shape): outline of 1423 points within 213.12,85.25 220.52,94.02
+1.0VS_VCCIO on TOP (solid shape): 197.3,58.04 197.3,57.69 196.75,57.69 196.75,57.14 197.3,57.14 197.3,56.89 196.75,56.89 196.75,56.34 197.3,56.34 197.3,55.99 197.19,55.88 195.24,55.88 195.08,56.04 195.08,58.09 195.29,58.3 197.04,58.3
+1.0VS_VCCIO on TOP (solid shape): 149.34,63.15 149.34,62.77 149.16,62.59 149.16,61.78 149.29,61.65 149.82,61.65 149.95,61.52 149.95,61.01 150.33,60.63 150.33,60.41 150.18,60.25 149.01,60.25 148.8,60.46 148.8,60.68 148.55,60.94 148.22,60.94 148.12,61.04 148.12,63.28 148.3,63.45 149.03,63.45
+1.0VS_VCCIO on TOP (solid shape): 157.49,65.49 157.49,60.96 157.41,60.89 157.35,60.88 157.3,60.86 157.14,60.86 156.86,60.58 156.86,60.43 156.7,60.28 155.49,60.28 155.38,60.38 155.38,60.63 155.48,60.73 155.49,60.74 155.82,60.74 155.84,60.76 155.94,60.86 155.94,62.46 155.74,62.67 155.74,62.78 155.85,62.89 155.99,62.89 156.78,63.68 156.78,65.55 156.88,65.65 157.33,65.65
+1.0VS_VCCIO on BOTTOM (solid shape): 228,95.38 228,94.9 228.23,94.67 229.4,94.67 229.53,94.54 229.53,93.27 229.25,92.99 226.81,92.99 226.66,92.84 226.66,92.08 226.3,91.72 225.58,91.72 225.35,91.81 225.12,91.72 224.62,91.22 224.62,90.26 224.49,90.12 222.48,90.12 222.46,90.14 222.46,90.83 225.34,93.7 225.56,93.7 225.67,93.81 225.67,94.47 226.68,95.48 227.9,95.48
+1.0VS_VCCIO on BOTTOM (solid shape): outline of 165 points within 155.38,60.28 157.42,62.97
+1.0VS_VCCIO on IN3 (solid shape): 226.73,92.84 226.73,92.13 226.4,91.8 225.56,91.8 225.35,91.86 225.14,91.8 224.65,91.8 224.5,91.95 224.5,92.92 224.8,93.22 226.35,93.22
+1.0VS_VCCIO on IN3 (solid shape): outline of 12227 points within 131.23,39.86 205.55,67.09
+1.0VS_VCCIO on IN4 (solid shape): outline of 267 points within 143.11,70.62 145.27,75.8
+1.2V_LDO on TOP (solid shape): 260.95,41.1 260.95,41 260.87,40.92 259.98,40.92 259.45,40.39 259.45,39.81 258.99,39.35 257.95,39.35 257.72,39.58 257.72,40.8 257.77,40.85 258.43,40.85 258.56,40.72 259.4,40.72 259.44,40.76 259.45,40.77 259.59,40.86 259.68,40.99 259.68,41 259.83,41.15 260.9,41.15
+1.2V_MEM on TOP (solid shape): 106.25,22.1 91.25,22.1 91.25,32.1 106.25,32.1
+1.2V_MEM on TOP (solid shape): 129.56,33.76 121.56,33.76 121.56,41.76 129.56,41.76
+1.2V_MEM on TOP (solid shape): 136.38,22.95 128.38,22.95 128.38,30.95 136.38,30.95
+1.2V_MEM on TOP (solid shape): 208.64,50.18 209.6,50.18 209.72,50.06 209.72,49.03 209.64,48.95 208.16,48.95 208.03,49.08 208.03,50.14 208.14,50.26 208.56,50.26
+1.2V_MEM on TOP (solid shape): outline of 12990 points within 69.1,10.04 223.63,63.55
+1.2V_MEM on BOTTOM (solid shape): 71.76,45.32 72.51,45.32 72.51,45.85 72.96,45.85 72.96,45.32 73.71,45.32 73.71,45.85 75.73,45.85 76.7,44.88 76.91,44.88 77.97,43.83 78.94,43.83 79.15,43.63 79.15,41.08 77.88,39.81 72.53,39.81 71.18,41.15 71.18,45.8 71.23,45.85 71.76,45.85
+1.2V_MEM on IN1 (solid shape): outline of 87 points within 102.32,10.02 136.74,11.89
+1.2V_MEM on IN3 (solid shape): 208.99,50.11 208.99,47.99 208.83,47.83 208.41,47.83 208,48.24 208,50.29 208.06,50.35 208.75,50.35
+1.2V_MEM on IN3 (solid shape): 236.29,25.95 236.55,25.95 236.72,25.78 236.72,24.02 236.62,23.92 235.5,23.92 235.34,24.08 235.34,25.85 235.45,25.96 236.28,25.96
+1.2V_MEM on IN3 (solid shape): 218.47,48.94 218.5,48.87 218.47,48.8 218.38,48.47 218.58,48.2 218.61,48.19 218.61,47.35 218.45,47.19 217.25,47.19 217.22,47.22 217.22,48.1 217.25,48.18 217.34,48.2 217.79,48.43 217.62,48.9 217.6,48.94 217.61,48.98 217.65,49.02 218.39,49.02
+1.2V_MEM on IN3 (solid shape): outline of 1494 points within 72.68,18.7 224.04,43.92
+1.2V_MEM on IN4 (solid shape): 235.19,26.16 235.53,25.97 235.86,26.16 236.6,26.16 236.71,26.05 236.71,25.36 236.52,25.17 234.68,25.17 234.44,25.41 234.44,25.91 234.69,26.16
+1.2V_MEM on IN4 (solid shape): outline of 332 points within 217.79,33.33 233.74,49.2
+1.2V_MEM on IN4 (solid shape): outline of 809 points within 162.01,10.02 219.76,11.64
