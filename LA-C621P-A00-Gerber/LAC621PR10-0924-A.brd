# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P2_R: length 3.9
  BOTTOM w0.094: JEDP1.13 91.25,85.75 91.4,85.6 91.4,85.13 91.9,84.64 93.05,84.64 93.15,84.54 93.15,84.43 92.98,84.26 LZ1.3
USB20_P3: length 205.4
  IN1 w0.076: v2(175.67,61.19) 175.67,60.95 175.73,60.89 176.01,60.89 176.05,60.85 176.05,60.65 175.72,60.33 175.01,60.33 174.79,60.54 173.9,60.54 173.53,60.18 171.02,60.18 170.63,60.57 170.06,60.57 169.7,60.21 168.95,60.21 168.66,60.49 168.66,60.94 168.01,61.59 168.01,62.12 167.19,62.94 166.17,62.94 165.96,62.73 165.27,62.73 165.1,62.55 164.58,62.55 164.52,62.5 163.46,62.5 162.53,63.43 160.65,63.43 159.59,62.37 159.59,62.05 159.55,62.01 159.55,61.9
  IN1 w0.112: 159.55,61.9 159.55,61.79 159.43,61.68 154.96,61.68 154.77,61.49 153.59,61.49 153.27,61.81 139.7,61.81 139.43,62.07 139.43,62.86 138.98,63.32 137.6,64.69 132.86,64.69 130.69,66.86 130.3,67.25 130.3,69.33 130.3,69.34 130.3,70.43 130.3,70.89 130.69,71.28 130.86,71.45 130.86,73.29 130.86,74.08 128.8,76.14 121.69,76.14 119.67,78.16 119.67,84.99 118.6,86.06 116.25,86.06 115.3,87.02 107.86,87.02 105.59,84.75 102.51,84.75 101.88,85.39 99.25,85.39 97.64,83.79 96.74,83.79 93.52,80.56 91.38,80.56 91.11,80.83 91.11,81.87 89.11,83.87 85.62,83.87 84.43,85.05 84.43,85.35 83.35,86.44 76.83,86.44 74.64,84.25 68.57,84.25 67.47,85.35 67.47,88.37 66.11,89.73 65.37,89.73 64.27,90.83 60.48,90.83 59.08,92.23 57.49,92.23 56.95,91.69 52.94,91.69 47.41,86.16 40.9,86.16 38.36,88.7 35.09,88.7 33.84,87.46 31.58,87.46 30.01,89.03 28.09,89.03 27.39,88.32 27.39,87.63 25.08,85.31 23.77,85.31 v2(23.51,85.58)
  BOTTOM w0.076: v2(175.67,61.19) 175.81,61.33 175.81,61.39 175.58,61.61 174.69,61.61 174.39,61.92 173.58,61.92 173.49,62.01 173.3,62.01 173.22,61.97 173.13,61.93 173.12,61.94 172.96,61.94 172.74,62 172.65,62 172.47,61.93 172.31,61.94 172.02,62.01 171.8,62.01 171.72,61.92 171.72,61.8 171.8,61.72 UC1.AJ3
  BOTTOM w0.094: v2(23.51,85.58) 24.22,85.58 25.18,84.61 25.18,84.01 24.95,83.78 LI3.4
USB20_P3_R: length 9.8
  BOTTOM w0.094: JUSB1.3 16.31,85.03 16.71,85.03 16.74,84.99 17.33,84.99 17.36,85.03 19.61,85.03 20.11,84.53 20.11,84.28 DI2.3 21.07,84.09 21.16,84.18 21.7,84.18 21.97,83.91 22.31,83.91 22.45,83.78 LI3.3
USB20_P4: length 123.7
  IN1 w0.076: 159.71,64.98 159.72,64.99 159.72,65.04 159.89,65.22 159.89,65.78 160.44,66.33 161.02,66.33 161.35,66.65 165.07,66.65 165.34,66.39 165.34,66.27 166.72,64.88 168.09,64.88 168.22,64.88 168.39,64.72 168.39,64.62 v2(168.24,64.47)
  IN1 w0.112: 159.71,64.98 159.46,64.73 157.26,64.73 156.9,64.37 147.46,64.37 147.28,64.55 146.85,64.55 146.48,64.93 146.48,66.09 145.73,66.84 139.54,66.84 137.89,68.48 132.85,68.48 132.29,69.04 132.29,69.96 133.14,70.81 133.14,74.78 133.34,74.98 133.34,76.05 133.55,76.26 133.55,76.46 133.55,77.97 126.65,84.87 124.43,84.87 124.43,84.86 124.12,84.86 121.08,87.91 119.9,87.91 118.96,88.85 117.77,88.85 116.86,89.76 106.86,89.76 105.47,91.15 105.24,91.38 102.43,91.38 97.85,86.8 90.23,86.8 89.85,87.18 89.85,89.21 89.06,90 80.91,90 79.67,88.76 77.9,88.76 75.08,85.94 74.78,85.94 74.48,85.65 v2(74.48,85.48)
  BOTTOM w0.076: UC1.AD10 168.02,64.68 v2(168.24,64.47)
  BOTTOM w0.094: v2(74.48,85.48) 74.2,85.76 73.54,85.76 73.39,85.61 LI4.4
USB20_P4_R: length 19.7
  BOTTOM w0.094: JUSB2.3 64.32,98.9 64.32,98.49 64.89,97.92 65.71,97.92 66.14,97.49 66.14,97.44 66.56,97.02 66.6,97.02 v4(67.64,95.98) 68.06,95.57 68.06,94.74 68.81,93.99 68.81,92.94 70.84,90.91 70.84,89.99 71.71,89.12 71.71,88.85 71.44,88.57 DI3.3 71.28,88.09 71.28,87.01 71.11,86.83 71.11,86.06 71.4,85.76 71.53,85.76 71.69,85.61 LI4.3
USB20_P5: length 71.6
  IN2 w0.122: v2(155.71,103.18) 155.71,102.54 156.07,102.19 156.07,101.65 156.32,101.4 156.91,101.4 157.03,101.27 157.03,101.03 156.91,100.91 156.32,100.91 156.07,100.65 156.07,98.82 162.82,92.07 162.82,90.56 163.08,90.3 163.48,90.3 163.74,90.56 163.74,90.94 163.87,91.06 164.12,91.06 164.25,90.94 164.25,90.5 164.51,90.23 164.95,90.23 165.3,89.88 165.3,88.93 167.65,86.58 170.44,86.58 170.58,86.44 172.01,86.44 174.25,86.44 175.45,85.25 175.52,85.18 175.52,82.59 176.29,81.81 176.29,80.46 175.87,80.04 175.87,78.72 176.12,78.46 176.43,78.46 176.55,78.34 176.55,78.09 176.21,77.75 176.21,75.65 175.73,75.17 175.73,73.15 175.83,73.05 175.83,68.98 176.29,68.52 177.61,68.52 177.96,68.18 177.96,65.72 176.72,64.48 176.72,62.63 175.94,61.84 174.98,61.84 174.62,61.48 174.6,61.48 v2(174.28,61.16)
  BOTTOM w0.076: v2(174.28,61.16) 173.96,61.48 173.56,61.48 173.5,61.42 173.23,61.42 173.2,61.45 172.93,61.72 UC1.AJ2
  BOTTOM w0.094: JDOCK1.72 153,107.87 153.15,107.73 153.15,106.84 153.69,106.29 153.69,105.28 155.05,103.93 155.45,103.93 155.84,103.53 155.84,103.31 v2(155.71,103.18)
USB20_P6: length 73
  IN2 w0.122: v2(153.67,102.95) 153.78,102.84 153.78,101.66 154.17,101.27 155.26,101.27 155.38,101.14 155.38,100.74 154.57,99.93 154.57,98.5 155.27,97.8 156.16,97.8 162.11,91.85 162.11,89.54 162.48,89.18 164.12,89.18 166.79,86.51 166.79,85.83 167.35,85.27 174.5,85.27 174.86,84.9 174.86,82.3 175.12,82.04 175.12,75.66 174.64,75.17 174.64,73.98 174.53,73.87 174.53,72.16 175.12,71.57 175.12,70.09 174.84,69.81 174.84,68.27 176.05,67.07 176.05,62.89 175.66,62.5 174.39,62.5 174.2,62.31 173.41,62.31 173.02,62.7 173.02,63.38 172.22,64.18 171.57,64.18 171.48,64.09 170.76,64.09 170.53,63.86 170.53,63.59 170.37,63.43 v2(170.25,63.43)
  BOTTOM w0.076: UC1.AF7 170.05,63.85 170.25,63.65 v2(170.25,63.43)
  BOTTOM w0.094: v2(153.67,102.95) 153.86,103.15 153.86,103.62 153.75,103.73 152.22,103.73 151.97,103.97 151.97,105.52 151.63,105.87 151.63,107.69 151.5,107.82 JDOCK1.66
USB20_P7: length 129.1
  TOP w0.094: JUSH1.18 268.46,8.16 268.54,8.08 268.67,8.08 268.74,8 268.74,7.92 267.37,6.55 267.07,6.55 v2(266.69,6.93)
  IN4 w0.112: v2(266.69,6.93) 266.55,6.93 266.43,6.81 266.43,6.68 266.33,6.57 266.19,6.57 265.42,6.71 265.02,6.71 263.71,7.25 263.68,7.25 263.59,7.27 255.73,7.27 254.52,6.06 253.86,6.06 253.03,6.9 253.03,7.13 253.03,7.13 253.03,7.33 248.1,12.26 247.96,12.4 244.26,12.4 243.29,13.38 243.29,13.74 243.29,13.74 243.29,14.26 242.91,14.64 242.48,14.64 241.64,15.48 241.19,15.48 240.4,16.27 235.84,16.27 232.29,19.82 231.35,19.82 229.79,21.38 229.79,22.6 228.09,24.3 228.09,25.25 226.69,26.65 226.69,27.26 223.32,30.63 223.32,31.86 222.11,33.07 220.67,33.07 219.24,34.5 218.75,34.5 218.08,35.17 218.08,36.14 216.55,37.66 216.55,38.01 215.17,39.4 214.5,39.4 212.42,41.47 212.11,41.47 209.45,44.14 209.03,44.14 206.9,46.27 206.55,46.27 203.04,49.78 200.08,49.78 199.76,49.46 194.54,49.46 192.89,51.11 191.72,51.11 190.62,52.21 189.56,52.21 188.99,52.78 188.99,53.92 188.76,54.16 188.76,55.94 187.01,57.69 181.03,57.69 179.95,58.77 179.32,58.77 177.46,60.63 177.46,61.06 v2(177.57,61.17)
  BOTTOM w0.076: UC1.AH2 172.76,62.6 172.85,62.65 174.67,62.65 174.97,62.35 176.93,62.35 177.57,61.71 v2(177.57,61.17)
USB20_P8: length 141.9
  IN1 w0.076: v2(168.98,63.41) 169.21,63.18 169.21,63.01 169.44,62.78 170.77,62.78 170.89,62.9 172.06,62.9 173.28,64.11 175.19,64.11 175.31,64.23 176.54,64.23 176.62,64.15
  IN1 w0.112: v2(239.1,52.45) 239.25,52.61 239.25,52.99 239.07,53.17 235.63,53.17 232.76,50.3 230.14,50.3 229.22,49.39 229.22,46.79 228.08,45.65 224.94,45.65 222.72,47.86 222.62,47.86 221.55,47.86 221.31,47.63 219.71,47.63 219.26,47.18 216.25,47.18 215.71,47.71 215.14,47.71 213.95,48.9 210.2,48.9 207.53,51.57 206.25,51.57 204.3,49.62 198.96,49.62 198.21,50.37 197.58,50.37 197.52,50.31 195.79,50.31 195.29,50.81 195.29,51.63 194.51,52.41 194.51,54.65 193.49,55.68 192.14,55.68 190.92,56.9 182.9,56.9 181.49,58.31 180.38,58.31 179.5,59.19 179.5,62.86 178.2,64.15 176.62,64.15
  BOTTOM w0.076: v2(168.98,63.41) 168.69,63.85 UC1.AF9
  BOTTOM w0.094: v2(239.1,52.45) 239.1,52.44 239.73,51.81 241.5,50.03 241.5,45.85 241.72,45.63 241.72,42.98 241.63,42.89 241.63,42.18 241.09,41.64 241.09,39.54 241.91,38.72 241.91,34.3 239.73,32.12 239.4,32.12 239.4,32.12 238.88,32.12 237.08,30.32 237.08,29.88 235.8,28.6 234.85,28.6 233.83,27.59 233.83,25.1 234.19,24.74 234.19,23.28 235.35,22.12 235.35,20.64 238.26,17.73 243.14,17.73 244.32,16.56 244.32,15.97 244.2,15.85 JNGFF1.3
USB20_P9: length 86.8
  IN1 w0.076: 159.7,63.22 159.71,63.22 159.75,63.27 159.92,63.27 160.46,63.81 162.73,63.81 163.29,63.25 164.55,63.25 164.81,63.5 167.32,63.5 168.39,62.43 168.39,62.02 169.41,61 170.96,61 171.3,60.66 172.7,60.66 174.5,62.46 v2(174.5,63.04)
  IN1 w0.112: 159.7,63.22 159.49,63.22 158.23,61.96 155.36,61.96 154.65,62.67 150.73,62.67 150.23,62.17 146.61,62.17 146.44,62.34 145.4,62.34 145.4,62.34 145.1,62.34 144.72,62.71 140.87,62.71 138.37,65.21 138.37,65.9 137.84,66.42 131.72,66.42 130.87,67.28 130.72,67.42 130.72,69.51 130.72,70.72 130.87,70.86 131.28,71.28 131.28,71.56 131.28,71.56 131.28,71.64 131.28,73.47 131.28,73.77 131.28,74.22 131.28,74.26 130.64,74.91 130.49,75.05 130.49,76.64 130.49,76.74 128.15,79.08 128.15,81.49 126.37,83.27 123.07,83.27 119.82,86.52 116.54,86.52 115.48,87.58 115.48,88.4 v2(115.45,88.42)
  BOTTOM w0.076: v2(174.5,63.04) 174.44,63.04 173.98,63.5 173.36,63.5 173.12,63.44 173.07,63.44 172.7,63.07 UC1.AG2
  BOTTOM w0.094: v2(115.45,88.42) 115.57,88.42 115.85,88.14 115.85,88.07 115.66,87.88 115.29,87.88 115.07,88.09 114.8,88.09 114.65,88.24 LV27.3
USB20_P9_R: length 24.4
  BOTTOM w0.094: JEDP1.3 96.25,87.83 97.91,89.49 97.91,89.74 97.91,89.9 98.48,90.47 98.86,90.47 101.33,92.93 102.3,92.93 102.36,92.99 102.95,92.99 102.99,92.96 v4(104.31,92.96) 106.02,92.96 108.79,90.19 109.4,90.19 109.64,90.43 DV4.3 109.87,90.71 109.87,90.37 110.81,89.43 110.81,88.48 111.2,88.09 112.54,88.09 112.69,88.24 LV27.4
USB20_P10: length 128
  IN1 w0.076: v2(169.61,62.32) 169.61,61.72 169.77,61.55 171.62,61.55 173.62,63.55 174.68,63.55 175.02,63.21 175.02,62.8 175.45,62.37 177.76,62.37 177.8,62.33 177.82,62.33
  IN1 w0.112: v2(242.43,55.59) 242.29,55.44 242.29,54.9 242.21,54.82 242.21,53.84 241.39,53.02 241.39,52.09 240.43,51.13 239.1,51.13 237.77,52.46 235.88,52.46 233.06,49.64 230.46,49.64 229.93,49.12 229.93,46.56 228.31,44.94 224.66,44.94 222.88,46.72 221.27,46.72 221.02,46.96 219.98,46.96 219.53,46.51 216.18,46.51 215.97,46.51 215.44,47.05 214.86,47.05 214.15,47.76 209.61,47.76 209.01,48.36 208.29,48.36 207.66,48.98 207.66,50.35 207.13,50.88 206.54,50.88 205.7,50.04 205.7,48.63 205.34,48.26 204.27,48.26 203.89,47.88 199.94,47.88 199.39,48.42 195.23,48.42 192.4,51.25 192.4,51.75 191.49,52.66 191.49,55.13 191.27,55.34 189.63,55.34 189.16,54.88 187.38,54.88 186.03,56.23 182.4,56.23 181.03,57.61 180.01,57.61 178.81,58.8 178.81,61.82 178.31,62.33 177.82,62.33
  BOTTOM w0.076: UC1.AH8 v2(169.61,62.32)
  BOTTOM w0.094: v2(242.43,55.59) 242.43,56.38 241.66,57.15 238.7,57.15 238.06,57.79 238.06,58.86 238.75,59.54 238.75,60.68 239.71,61.65 239.71,72.34 236.1,75.95 234.86,75.95 234.76,76.05 JNGFF2.7
USB_OC0#: length 166.2
  TOP w0.102: v2(203.69,87.18) 203.69,86.69 203.54,86.54 201.56,86.54 200.85,87.25 200.85,87.56 200.56,87.85 199.58,87.85 198.58,86.85 194.79,86.85 193.62,85.68 182.6,85.68 v3(181.88,86.4) 181.57,86.71 177.85,86.71 174,82.86 174,81.36 v2(174.02,81.36) ; UI3.13 283.79,66.77 v2(283.48,67.09) 282.82,67.09 281.88,66.15 281.14,66.15 280.45,65.46 279.43,65.46 CI33.1
  IN2 w0.122: v2(255.79,83.22) 255.37,83.64 255.37,86.99 254.71,87.65 254.71,90.18 254.35,90.53 254.35,91.35 252.67,93.03 247.25,93.03 246.36,92.14 244.65,92.14 244.3,92.49 242.37,92.49 241.89,92.49 241.23,91.84 240.46,91.06 240.46,91.06 240.03,90.63 240.03,88.84 239.26,88.07 234.68,88.07 234.04,87.42 229.29,87.42 228.71,88 224.14,88 222.26,86.12 222.26,85.94 220.39,84.07 211.71,84.07 210.5,85.27 206.34,85.27 204.43,87.18 v2(203.69,87.18)
  IN3 w0.122: v2(283.48,67.09) 282.87,67.69 282.87,70.08 281.65,71.3 277.45,71.3 276.84,70.69 270.04,70.69 267.47,73.26 265.21,73.26 264.83,73.64 263.64,73.64 263.35,73.35 263.35,72.74 262.85,72.24 260.87,72.24 259.49,73.62 259.49,75.27 256.61,78.15 252.63,78.15 252.38,78.4 252.38,80.21 252.56,80.39 253.77,80.39 255.01,81.63 255.01,82.43 255.79,83.21 v2(255.79,83.22)
  BOTTOM w0.076: 170.73,79.18 170.7,79.18 170.69,79.16 170.64,79.16 168.7,77.23 UC1.A9
  BOTTOM w0.102: 174,81.36 174,79.63 173.54,79.18 170.73,79.18 ; 174,81.36 174.01,81.37 174.01,81.69 174.47,82.15 RPC3.4 ; 174,81.36 v2(174.02,81.36)
USB_OC1#: length 203.7
  TOP w0.102: CI34.1 22.94,89.11 22.4,89.11 v2(22.01,89.5)
  IN3 w0.122: v2(175.35,93.17) 175.35,95.27 170.6,100.02 164.79,100.02 164.22,100.59 162.11,100.59 160.79,101.91 160.79,102.95 160.51,103.23 157.94,103.23 157.06,104.12 155.13,104.12 154.67,104.58 153.68,104.58 152.33,103.22 143.66,103.22 141.07,100.63 139.27,100.63 138.17,99.53 138.17,99.42 135.85,97.11 123.31,97.11 120.27,94.07 119,94.07 116.36,91.43 108.43,91.43 107.71,92.15 105.73,92.15 105.31,92.56 101.62,92.56 99.73,94.45 89.1,94.45 88.85,94.7 73.51,94.7 71.49,92.68 70.79,92.68 69.98,93.49 68.78,93.49 68.66,93.36 64.38,93.36 62.67,95.07 62.67,95.11 61.66,96.13 55.34,96.13 45.39,86.18 40.25,86.18 37.51,88.92 30.12,88.92 28.18,86.97 25.28,86.97 24.1,88.15 23.36,88.15 v2(22.01,89.5)
  BOTTOM w0.102: UC1.C9 168.7,76.07 169.36,76.73 169.36,77.4 170.71,78.74 173.76,78.74 174.84,79.82 174.84,81.81 175.08,82.05 175.31,82.05 175.47,82.21 RPC3.2 175.47,83.01 175.6,83.14 176.04,83.14 177.4,84.49 177.4,84.95 177.07,85.28 177.07,88.57 176.54,89.1 176.54,90.72 v3(175.66,91.61) 175.35,91.92 v2(175.35,93.17) ; v2(22.01,89.5) 21.59,89.5 21.28,89.81 UI1.3
USB_OC2#: length 146.5
  TOP w0.102: UI2.3 70.58,92.12 71.22,91.48 73.62,91.48 CI35.1 75.11,90 78.55,90 79.81,91.25 82.19,91.25 v2(82.99,92.05)
  IN2 w0.122: v2(135.57,97.57) 133.92,97.57 132.73,96.37 128.48,96.37 125.71,93.59 125.26,93.59 123.7,93.59 122.79,92.68 110.35,92.68 109.99,93.04 107.24,93.04 106.68,93.42 106.39,93.54 106.29,93.58 106.19,93.62 106.02,93.69 105.86,93.76 105.55,93.91 105.3,93.91 105.29,93.92 104.93,93.99 104.55,94.06 103.76,94.06 101.74,94.06 101.52,94.28 84.72,94.28 84.72,94.28 84.56,94.28 82.99,92.72 v2(82.99,92.05)
  IN3 w0.122: v2(175.93,93.17) 175.93,95.04 170.66,100.31 165.06,100.31 164.38,100.99 162.98,100.99 162.19,101.78 162.19,103.31 161.76,103.74 161.02,103.74 160.77,103.48 158.69,103.48 156.89,105.28 153.55,105.28 151.74,103.47 143.56,103.47 140.97,100.88 138.45,100.88 136.99,99.43 136.99,99.01 135.57,97.58 v2(135.57,97.57)
  BOTTOM w0.076: UC1.D9 168.7,75.38 169.17,75.85 169.34,75.85 169.56,76.06 169.56,76.99 169.55,77
  BOTTOM w0.102: v2(175.93,93.17) 177,92.1 v3(177,90.34) 176.77,90.11 176.77,89.2 177.33,88.64 177.33,85.34 177.62,85.04 177.62,84.4 176.34,83.11 176.34,82.66 176.24,82.56 RPC3.1 175.97,82.18 175.86,82.06 175.11,81.32 175.11,79.77 173.87,78.53 170.76,78.53 169.55,77.32 169.55,77
USB_OC3#: length 10.4
  BOTTOM w0.076: 170.73,78.97 170.68,78.97 169.07,77.36 169.07,76.88 UC1.B9
  BOTTOM w0.102: 170.73,78.97 173.66,78.97 174.43,79.74 v3(174.43,80.66) 174.43,81.47 174.43,81.73 174.97,82.26 RPC3.3
USB_PWR_EN1#: length 297.8
  TOP w0.102: RPE9.2 253.19,73.97 253.33,74.1 253.33,74.11 253.33,74.11 253.33,74.13 253.33,74.13 253.33,74.65 253.02,74.96 v2(252.94,74.96) ; v2(250.22,78.76) 250.14,78.69 UE1.B44
  IN3 w0.122: v2(22.59,89.53) 23.08,89.04 25.92,89.04 26.2,88.76 27.8,88.76 28.31,89.27 28.31,89.45 28.83,89.97 37.7,89.97 40.61,87.06 45.02,87.06 54.97,97.01 62.12,97.01 62.67,96.45 89.4,96.45 89.74,96.11 92.78,96.11 93.56,96.89 101.17,96.89 104.12,93.94 105.89,93.94 106.3,93.53 110.28,93.53 110.92,92.9 115.55,92.9 116.8,94.14 116.8,95.59 117.2,95.99 117.71,96.5 117.92,96.5 119.61,96.5 119.91,96.79 119.91,96.8 127.55,104.44 127.55,108.3 129.16,109.91 132.7,109.91 135.67,106.94 148.73,106.94 149.49,107.7 156.8,107.7 158.76,109.66 160.09,109.66 161.65,108.11 166.22,108.11 166.89,107.44 166.89,106.53 167.8,105.62 167.8,104.09 168.93,102.96 170.92,102.96 176.73,97.15 188.65,97.15 191.97,93.83 200.07,93.83 200.14,93.9 201.71,93.9 207.54,99.73 207.54,100.89 209.23,102.57 213.45,102.57 214.32,103.44 227.53,103.44 228.84,102.13 230.26,102.13 230.41,102.28 231.75,102.28 232.29,101.74 236.78,101.74 237.41,101.11 243.42,101.11 244.2,100.33 245.26,100.33 245.42,100.17 246,99.59 248.93,96.66 248.93,95.34 251.05,93.22 252.9,93.22 255.27,90.85 255.27,90.44 255.01,90.19 255.01,85.24 254.27,84.49 254.27,83.1 253.78,82.61 252.54,82.61 250.38,80.45 250.38,80.24 249.78,79.64 249.78,79.2 v2(250.22,78.76)
  BOTTOM w0.102: v2(22.59,89.53) 22.59,89.23 22.45,89.09 21.59,89.09 21.28,88.79 UI1.4 ; v2(250.22,78.76) 251.34,77.64 251.73,77.64 252.94,76.42 v2(252.94,74.96)
USB_PWR_EN2#: length 240.2
  TOP w0.102: RPE9.3 252.69,74.07 252.92,74.3 v2(252.92,74.28) ; UE1.A33 245.89,76.46 v2(245.87,76.43) ; v2(69.79,93.07) 70.09,92.76 70.09,91.52 70.58,91.03 UI2.4
  IN1 w0.089: v2(245.87,76.43) 246.11,76.43 248.61,78.93 248.61,85.36 248.96,85.71 248.96,86.7 248.33,87.33 247.98,87.33 246.66,88.65 246.66,89.21 248.23,90.78 v2(248.31,90.78)
  IN3 w0.122: v2(69.79,93.07) 70.48,92.38 71.86,92.38 73.93,94.45 88.75,94.45 89,94.2 99.5,94.2 101.39,92.31 105.21,92.31 105.62,91.9 107.58,91.9 108.29,91.18 116.46,91.18 119.02,93.74 120.29,93.74 123.42,96.86 135.96,96.86 138.41,99.32 138.41,99.42 139.38,100.38 139.94,100.38 141.17,100.38 143.76,102.98 152.63,102.98 153.75,104.09 154.65,104.09 154.9,103.85 154.9,103.82 154.91,103.8 156.97,103.8 157.79,102.98 158.8,102.98 161.77,100.02 164.18,100.02 164.49,99.71 170.48,99.71 174.74,95.44 174.74,93.14 175.12,92.75 176.18,92.75 176.41,92.98 176.41,93.88 177.67,95.14 178.55,96.02 188.14,96.02 192.09,92.07 201.65,92.07 208.79,99.21 208.79,100.37 209.75,101.33 213.97,101.33 214.84,102.2 227.02,102.2 228.88,100.33 229.83,100.33 230.42,99.74 243.03,99.74 243.68,99.08 244.65,99.08 247.6,96.13 247.6,91.29 248.12,90.78 v2(248.31,90.78)
  BOTTOM w0.102: v2(252.92,74.28) 252.69,74.04 249.95,74.04 248.3,75.69 248.3,76.55 247.88,76.97 v3(247.03,76.97) 246.4,76.97 v2(245.87,76.43)
USB_PWR_SHR_EN#: length 67.7
  TOP w0.102: UE1.A8 249.89,88.29 249.56,88.63 249.08,88.63 248.99,88.72 248.99,89.05 248.65,89.39 v2(248.37,89.39) ; UI3.6 282.79,61.78 281.79,60.77 v3(281.29,60.77) 281.08,60.77 280.57,61.28 v2(280.57,61.34) ; v2(252.38,74.5) 252.39,74.5 252.39,74.5 252.2,74.31 RPE9.4
  IN1 w0.089: v2(252.49,62.63) 252.91,62.2 252.91,62.06 253.34,61.63 253.67,61.63 254.34,62.3 256.86,62.3 257.49,61.68 260.5,61.68 261.62,62.8 263.1,62.8 263.14,62.75 268.37,62.75 268.48,62.86 270.33,62.86 270.69,62.5 279.41,62.5 v2(280.57,61.34) ; v2(252.38,74.5) 251.71,75.17 250.33,75.17 249.9,75.6 249.9,76.79 249.17,77.52 249.17,84.95 249.45,85.23 249.45,87.37 248.12,88.7 248.12,89.02 248.26,89.16 248.26,89.28 v2(248.37,89.39)
  IN2 w0.122: v2(252.38,74.5) 252.39,74.5 252.39,74.12 252.82,73.68 252.82,68.11 253.36,67.56 253.36,67.22 253.12,66.97 252.89,66.97 252.74,66.82 252.74,65.79 253.1,65.43 253.1,63.23 v2(252.49,62.63)
USB_PWR_SHR_VBUS_EN: length 55.8
  TOP w0.102: RPE9.1 253.69,74.26 v2(253.73,74.3) ; v2(280.56,61.97) 280.88,61.97 281.51,61.34 281.98,61.34 282.29,61.66 UI3.5 ; v2(252.79,78.74) 253.14,78.39 UE1.B50
  IN1 w0.089: v2(253.73,74.3) 255.33,74.3 256.56,75.53 263.27,75.53 264.14,76.4 265.45,76.4 270.59,71.27 272.3,71.27 272.76,70.8 276.35,70.8 277.19,71.65 277.37,71.65 277.55,71.65 277.66,71.53 283.63,71.53 284.08,71.09 284.08,69.9 v2(283.58,69.4)
  IN3 w0.122: v2(283.58,69.4) 283.47,69.29 283.47,67.8 283.89,67.38 283.89,66.85 283.54,66.49 283.54,65.48 281.61,63.55 281.61,62.82 280.77,61.97 v2(280.56,61.97)
  BOTTOM w0.102: v2(253.73,74.3) 254.8,75.37 254.8,76.13 255.05,76.38 255.05,77.47 253.79,78.74 v2(252.79,78.74)
USBCOMP: length 17.7
  TOP w0.203: v1(184.16,69.34) 184.1,69.34 183.3,68.55 183.3,68.49 RC44.1
  TOP w0.381: RC44.1 183.25,68.33 182.76,67.83 182.48,67.83 v2(182.09,67.44)
  IN3 w0.381: v2(170.29,66.61) 170.29,66.81 170.9,67.42 172.5,67.42 173.6,68.51 174.75,68.51 175.48,67.78 176.09,67.78 176.69,68.38 177.99,68.38 179.31,67.06 181.45,67.06 181.83,67.44 v2(182.09,67.44)
  BOTTOM w0.254: v2(170.29,66.61) 170.63,66.28 UC1.AB6
USH_DET#: length 124.8
  TOP w0.102: UE1.A16 245.89,88.62 245.76,88.75 245.55,88.75 245.1,88.29 v2(245.1,87.84) ; RZ87.1 257.8,14.52 DZ7.2 258.28,14.04 258.28,11.8 259.26,10.83 v2(259.74,10.83)
  IN2 w0.122: v2(265.72,75.49) 265.72,74.58 270.09,70.21 271.2,70.21 272.29,69.13 272.29,68.9 272.29,68.9 272.29,68.76 272.29,68.76 272.29,67.38 272.26,67.35 272.26,67.15 272.12,67 271.92,66.8 271.77,66.65 271.33,66.21 271.33,52.58 271.61,52.3 271.61,48.63 269.03,46.05 269.03,44.19 269.03,43.63 268.17,42.77 268.17,40.54 267.7,40.06 267.7,35.39 267.32,35.02 267.32,31.22 266.04,29.93 266.04,24.13 265.1,23.19 264.07,23.19 263.2,22.32 259.62,22.32 259,21.7 259,21.53 258.99,21.52 258.99,20.66 258.71,20.37 258.71,17.06 259.6,16.17 259.6,12.34 259.53,12.27 259.53,11.04 v2(259.74,10.83)
  BOTTOM w0.102: v2(245.1,87.84) 245.1,87.56 RC281.2 243.98,86.44 243.98,85.69 244.59,85.08 244.59,84.52 242.97,82.9 241.95,82.9 241.39,82.33 241.39,80.03 242.14,79.28 246.23,79.28 247.06,80.1 247.88,80.1 248.88,81.11 251.98,81.11 252.26,80.83 253.52,80.83 253.85,80.5 256.02,80.5 256.23,80.29 256.23,79.85 255.95,79.57 255.95,79.21 256.16,79 263.82,79 v3(265.34,77.48) 265.72,77.1 v2(265.72,75.49)
USH_DET#_R: length 9.7
  TOP w0.102: JUSH1.1 259.96,9.79 257.9,11.85 257.32,11.85 257.23,11.76 256.44,11.76 256.07,12.13 v3(256.07,12.59) 256.89,13.4 256.89,13.78 256.66,14.01 DZ7.1 256.89,14.49 RZ87.2
USH_PWR_STATE#: length 106.1
  TOP w0.102: v2(245.91,75.85) 245.91,75.87 246.39,76.36 UE1.A34 ; JUSH1.5 261.96,9.22 v3(260.94,10.24) 260.56,10.61 RZ10.2 260.06,11.94 v2(259.96,11.94)
  IN2 w0.122: v2(259.96,11.94) 259.96,12.77 259.85,12.88 259.85,16.36 258.96,17.25 258.96,20.27 259.24,20.55 259.24,20.65 259.25,20.66 259.25,21.6 259.72,22.07 262.9,22.07 263.44,21.54 265.25,21.54 265.56,21.85 265.56,23.11 266.29,23.84 266.29,29.83 267.6,31.14 267.6,34.95 267.94,35.29 267.94,39.96 268.42,40.43 268.42,42.66 269.28,43.53 269.28,45.95 271.86,48.53 271.86,51.86 272.22,52.23 272.22,53.93 271.58,54.57 271.58,66.11 271.87,66.4 272.02,66.55 272.16,66.7 272.37,66.9 272.51,67.04 272.51,67.25 272.54,67.27 272.54,68.66 272.54,69.23 271.31,70.46 270.2,70.46 267.07,73.59 v2(267.07,74.02)
  BOTTOM w0.102: v2(245.91,75.85) 246.27,75.85 248.53,73.59 253.92,73.59 255.31,74.98 255.31,75.78 255.68,76.15 256.15,76.15 256.64,76.64 259.09,76.64 259.56,76.17 263.24,76.17 265.39,74.02 v2(267.07,74.02)
USH_RST#: length 93.1
  TOP w0.102: v2(265.24,16.66) 265.36,16.55 265.36,15.33 265.07,15.05 265.07,14.92 264.55,14.39 263.55,14.39 RZ115.1 ; v2(255.79,85.6) 255.57,85.38 UE1.A62
  IN1 w0.089: v2(270.53,71.99) 260.81,81.71 260.81,82.91 260.27,83.45 259.3,83.45 258.13,84.61 256.4,84.61 255.79,85.23 v2(255.79,85.6)
  IN2 w0.122: v2(265.24,16.66) 265.24,21.18 265.83,21.76 265.83,23.02 266.54,23.74 266.54,29.73 267.85,31.03 267.85,34.84 268.19,35.19 268.19,38.62 269.13,39.57 269.13,41.53 269.82,42.22 269.82,42.9 269.54,43.18 269.54,44.59 269.53,44.59 269.53,45.85 272.11,48.42 272.11,51.76 273.27,52.92 273.27,56.72 274.55,58 v2(274.55,59.33)
  BOTTOM w0.102: v2(270.53,71.99) 270.53,71.66 v1(273.43,68.76) 274.56,67.64 274.56,66.84 277.66,63.74 277.66,59.13 277.07,58.54 276.58,58.54 276.25,58.87 275.01,58.87 v2(274.55,59.33)
USH_SMBCLK: length 58.9
  TOP w0.102: RZ8.2 v2(267.7,14.74) 267.74,14.77 268.34,14.77 268.66,14.46 v3(268.66,13.67) 268.77,13.56 268.77,10.98 267.94,10.15 267.93,10.14 267.7,9.91 267.46,9.67 JUSH1.16 ; UE2.A50 262.65,55.34 v2(262.47,55.16)
  IN4 w0.089: v2(267.7,14.74) 266.26,16.17 266.26,23.02 266.65,23.41 266.65,29.26 266.65,29.65 265.67,30.64 265.67,33.89 265.43,34.13 265.43,34.96 265.65,35.19 265.65,36.25 264.94,36.96 264.94,38.43 263.62,39.75 262.01,39.75 260.69,41.07 260.69,44.97 258.36,47.3 258.36,48.92 257.25,50.03 257.25,52.4 257.87,53.02 259.01,53.02 261.15,55.16 v2(262.47,55.16)
USH_SMBDAT: length 61.2
  TOP w0.102: UE2.B53 262.4,57.62 v2(262.62,57.84) ; RZ9.2 267.7,12.35 v2(267.83,12.22) 268.18,12.22 268.29,12.12 268.29,11.34 v3(267.52,10.57) 266.96,10.02 JUSH1.15
  IN4 w0.089: v2(267.83,12.22) 267.83,13.77 265.79,15.8 265.79,23.22 266.18,23.61 266.18,29.46 265.2,30.44 265.2,33.7 264.96,33.94 264.96,35.16 265.18,35.38 265.18,36.05 264.47,36.76 264.47,38.23 263.43,39.28 261.82,39.28 260.22,40.88 260.22,44.77 257.89,47.1 257.89,48.73 256.78,49.83 256.78,52.59 257.68,53.49 258.81,53.49 262.62,57.3 v2(262.62,57.84)
VCI_IN2#: length 13.5
  TOP w0.102: UE2.B63 267.4,57.6 267.71,57.91 v2(267.71,58.4) ; v3(276.22,57.85) 276.43,58.07 v2(276.8,58.07) 277.13,57.73 RPE5.4
  IN1 w0.089: v2(276.8,58.07) 276.55,57.82 273.44,57.82 272.73,57.11 269.11,57.11 268.85,57.37 268.85,57.42 267.87,58.4 v2(267.71,58.4)
VCT_LAN_R1: length 5.3
  TOP w0.102: v1(257.83,85.49) 257.83,85.77 258.98,86.92 v2(260.13,86.92) 260.34,87.13 UL1.6
  BOTTOM w0.102: RL3.2 260.49,86.57 v2(260.13,86.92)
VGA1_BLUE_L: length 12
  BOTTOM w0.102: LV18.2 237.67,97.49 CV56.1 237.47,97.69 237.47,98.76 237.09,99.13 DV6.2 238.24,102.58 v3(238.24,103.24) 238.24,105.8 JCRT1.3
VGA1_GREEN_L: length 11.8
  BOTTOM w0.102: LV17.2 235.13,97.51 CV55.1 235.21,100.01 234.83,100.39 DV5.3 234.83,102.19 235.37,102.73 v3(235.37,103.27) 235.37,104.02 236.05,104.7 236.05,105.9 JCRT1.2
VGA1_HSYNC_L: length 8.3
  BOTTOM w0.102: LV19.2 v3(240.71,99.91) 240.13,100.49 240.13,101.17 240.58,101.62 240.74,101.62 RV38.2 240.88,101.98 240.07,102.78 CV59.1 240.07,105.27 JCRT1.13
VGA1_RED_L: length 12.4
  BOTTOM w0.102: LV16.2 231.97,97.13 231.88,97.21 CV54.1 231.88,97.62 232.19,97.93 232.19,99.25 232.9,99.95 DV5.2 232.9,102.36 232.25,103.01 v3(232.25,103.29) 232.25,104.39 JCRT1.1
VGA1_VSYNC_L: length 8
  BOTTOM w0.102: JCRT1.14 242.68,104.95 CV58.1 242.68,102.62 242.66,102.6 RV37.2 243.09,101.76 243.22,101.63 v3(243.22,99.83) 242.99,99.61 LV20.2
VGA_ID: length 15.1
  TOP w0.102: RE85.1 256.12,82 v2(255.81,82) ; v3(259.98,77.74) v2(259.98,77.14) 260.11,77.02 RE84.1 ; v2(253.26,81.32) 253.63,81.7 253.63,81.93 253.83,82.13 UE1.B59
  IN1 w0.089: v2(255.81,82) 253.93,82 v2(253.26,81.32) 253.26,80.9 256.48,77.68 259.41,77.68 259.94,77.14 v2(259.98,77.14)
VID0_PRIM_CORE: length 8.9
  TOP w0.102: v3(198.42,75.07) 197.95,74.61 PR418.2
  TOP w0.254: PR418.2 198.08,73.99 199,73.08 199.6,73.08 v2(199.81,72.88) 200.17,72.88 200.49,72.55 200.49,72.55 PR420.1
  BOTTOM w0.254: PU402.9 200.72,72.34 200.47,72.59 200.09,72.59 v2(199.81,72.88) 199.68,73 199.19,73 198.72,73.47 198.72,74.1 198.71,74.12 198.71,74.14 PR408.2
VID0_VCCIO: length 3.5
  BOTTOM w0.254: PU401.9 205.49,53.84 v3(206.18,54.53) 206.77,55.12 PR416.1 PR414.2
VID1_PRIM_CORE: length 5.6
  TOP w0.254: PR419.1 199.2,72.19 v2(199.02,72.37) 198.31,73.08 PR417.2
  BOTTOM w0.254: PU402.8 199.71,71.37 199.51,71.57 199.51,71.88 v2(199.02,72.37) 199.02,72.61 198.22,73.42 PR411.2
VID1_VCCIO: length 3.2
  BOTTOM w0.254: PU401.8 204.28,55.11 v3(204.89,55.72) 204.99,55.82 PR415.1 205.85,56.65 PR413.2
VIDALERT_N: length 69.2
  IN4 w0.089: v2(130.23,84.39) 121.14,84.39 117.89,81.14 117.89,78.31 116.62,77.04 109.86,77.04 109.69,77.21 108.92,77.21 106.83,79.3 101.84,79.3 101.14,80.01 99.19,80.01 90.97,80.01 87.36,76.41 87.24,76.41 86.49,75.66 84.56,73.73 82.39,73.73 82.01,73.35 79.24,73.35 77.05,71.15 v2(77.05,70.67)
  BOTTOM w0.102: v2(77.05,70.67) 77.15,70.57 77.15,70.03 77.16,70.02 77.16,69.63 76.52,68.99 75.3,68.99 PR607.1 ; RC153.2 130.87,83.85 130.44,84.28 130.44,84.28 130.34,84.39 v2(130.23,84.39) 129.91,84.71 RC152.2
VIDALERT_N_A: length 4.9
  TOP w0.102: PR604.2 74.94,66.58 v2(74.99,66.63)
  BOTTOM w0.102: PR625.1 75.09,66.53 v2(74.99,66.63) 74.94,66.58 74.51,66.58 74.18,66.91 PR607.2
VIDALERT_N_B: length 3.7
  TOP w0.102: PU602.36 78.58,65.47 78.24,65.82 77.63,65.82 v2(77.28,66.17)
  BOTTOM w0.102: v2(77.28,66.17) 77.02,66.17 PR625.2
VIDSCLK: length 84.2
  IN4 w0.089: v2(131.38,81.64) 130.73,82.29 130.73,84.56 130.43,84.86 121.72,84.86 120.95,84.86 117.42,81.33 117.42,78.5 116.43,77.51 110.06,77.51 109.89,77.68 109.24,77.68 107.14,79.77 106.77,79.77 106.21,80.33 103.7,80.33 103.48,80.11 101.74,80.11 101.37,80.48 99,80.48 91.7,80.48 91.69,80.48 90.92,80.48 90.65,80.48 86.02,75.85 84.37,74.2 82.2,74.2 81.82,73.82 79.05,73.82 76.58,71.35 76.58,71.12 v2(76.53,71.07)
  BOTTOM w0.076: 132.15,81.35 132.15,80.77 132.09,80.72 132.09,79.94 132.45,79.58 136.04,79.58 137.2,78.43 137.2,77.82 137.46,77.56 137.46,77.29 UC1.A63
  BOTTOM w0.102: PR606.1 v3(73.62,67.76) 73.62,69.09 74.01,69.49 76.32,69.49 76.63,69.8 76.63,70.28 76.53,70.38 v2(76.53,71.07) ; v2(131.38,81.64) 131.89,81.64 132.15,81.38 132.15,81.35
VIDSCLK_A: length 4.8
  TOP w0.102: PR601.2 74.69,65.69 v2(74.97,65.41)
  BOTTOM w0.102: PR618.1 75.2,65.64 v2(74.97,65.41) 74.53,65.41 74.17,65.76 PR606.2 73.37,65.51 v3(73.37,64.74)
VIDSCLK_B: length 3.7
  TOP w0.102: PU602.37 78.62,65.07 78.34,65.36 v2(78.02,65.36)
  BOTTOM w0.102: v2(78.02,65.36) 77.84,65.18 77.1,65.18 76.67,65.61 PR618.2
VIDSOUT: length 78.9
  IN4 w0.089: v2(77.63,70.64) 77.64,70.65 77.64,71.08 79.44,72.88 82.21,72.88 82.59,73.26 84.76,73.26 86.96,75.46 87.44,75.94 87.56,75.94 91.16,79.54 100.94,79.54 101.65,78.83 106.63,78.83 108.73,76.74 109.5,76.74 109.67,76.57 116.82,76.57 118.36,78.11 118.36,80.94 121.22,83.8 v2(130.24,83.8)
  BOTTOM w0.076: UC1.D64 137.05,75.77 137.35,76.06 137.35,76.31 137.13,76.52 137.13,77.42 136.87,77.68 136.87,78.29 135.9,79.25 132.24,79.25 131.2,80.29 131.19,80.29 131.14,80.34
  BOTTOM w0.102: v2(77.63,70.64) 77.63,70.23 78.02,69.84 v3(78.02,69.33) 78.02,69.05 PR609.1 ; v2(130.24,83.8) 130.39,83.65 130.39,82.68 RC157.2 130.39,81.77 130.39,81.09 131.14,80.34
VIDSOUT_A: length 3.3
  TOP w0.102: PR605.2 73.82,67.54 75.02,67.54 v2(75.14,67.42)
  BOTTOM w0.102: PR609.2 76.47,68.15 PR626.1 75.17,67.44 v2(75.14,67.42)
VIDSOUT_B: length 4.2
  TOP w0.102: PU602.35 78.58,65.87 78.39,66.07 78.14,66.07 v2(77.96,66.25)
  BOTTOM w0.102: PR626.2 76.9,67.21 77.43,67.21 77.68,66.96 77.68,66.53 v2(77.96,66.25)
VMM3320_LPM_DIS: length 109.4
  TOP w0.076: v2(212.76,85.88) 213.67,84.98 214.02,84.98 214.17,85.13 214.17,85.51 UV8.B2
  TOP w0.102: RV516.1 208.77,84.87 210.53,84.87 RV79.1 211.49,84.41 211.87,84.79 211.87,85.12 212.64,85.88 v2(212.76,85.88)
  IN2 w0.122: v2(192.14,48.47) 191.73,48.47 189.83,50.37 189.44,50.37 188.55,51.27 188.55,53.87 184.14,58.28 184.14,64.77 185.87,66.5 186.77,66.5 187.57,67.3 187.57,68.52 187.44,68.65 187.44,68.73 185.7,70.47 185.7,71.57 184.87,72.39 184.87,73.21 187.29,75.63 191.73,75.63 193.94,73.42 194.33,73.42 v2(195.11,72.65)
  IN3 w0.122: v2(212.76,85.88) 213.03,85.62 213.03,84.26 213.71,83.58 213.71,82.04 208.16,76.49 198.07,76.49 196.21,74.63 196.21,73.74 v2(195.11,72.65)
  BOTTOM w0.076: UC1.BA8 169.05,55.48 169.05,54.06 169.83,53.28 170.8,53.28 171.08,53 172.09,53 172.64,52.45 172.65,52.45 173,52.09
  BOTTOM w0.102: v2(192.14,48.47) 191.46,47.79 191.46,47.73 189.69,45.96 180.86,45.96 177.76,49.06 175.28,49.06 174.64,49.7 174.64,51.2 173.89,51.95 173.15,51.95 173,52.09
VRALERT#: length 21.7
  TOP w0.102: v2(169.33,60.58) 169.76,61.01 v1(170.3,61.01) 170.39,60.92 170.92,60.92 172.83,59.01 178.95,59.01 179.22,58.74 184.45,58.74 RC73.1 184.33,59.55 RC343.1
  BOTTOM w0.076: UC1.AM11 167.36,60.9 167.68,61.22 168.08,61.22 168.72,60.58 v2(169.33,60.58)
VSA_SEN+: length 110.8
  TOP w0.254: RC168.2 160.77,70.92 160.79,70.95 160.82,70.95 161.02,71.15 161.02,71.5 161.76,72.24 v2(162.04,72.24) ; v2(79.23,70.84) 79.11,70.84 78.37,71.58 PC650.1 78.37,72.47 PR649.2 77.51,72.5 PC640.2
  IN4 w0.254: v2(162.04,72.24) 162.04,71.96 161.89,71.81 161.48,71.81 160.82,71.15 158.96,71.15 158.81,71.3 158.81,71.59 158.24,72.17 157.47,72.17 157.03,72.6 157.03,74.43 156.25,75.21 155.1,75.21 154.9,75.42 154.13,75.42 153.33,74.62 153.33,73.68 152.02,72.37 149.85,72.37 149.52,72.03 149.52,70.92 148.45,69.85 146.78,69.85 145.76,68.84 138.33,68.84 138.05,68.56 122.71,68.56 121.22,70.05 121.22,71.63 121.22,73.81 119.65,75.38 107.18,75.38 106.72,75.85 106.72,76.64 105.73,77.63 101.17,77.63 100.84,77.96 92.9,77.96 92.09,77.14 90.45,77.14 88.05,74.75 87.93,74.75 84.53,71.35 79.74,71.35 v2(79.23,70.84)
  BOTTOM w0.254: UC1.H20 162.37,72.58 162.37,72.55 162.04,72.22 v2(162.04,72.24) ; PC652.1 v3(82.66,69.59) 82.43,69.83 82.14,69.83 81.55,70.41 79.67,70.41 v2(79.23,70.84)
VSA_SEN-: length 108.7
  TOP w0.254: v2(160.54,71.68) 160.54,71.73 160.49,71.78 RC166.1 ; PC650.2 77.51,71.61 78.27,70.84 78.35,70.84 v2(78.45,70.74) ; v2(82.1,69.32) 82.23,69.19 PU602.26
  IN4 w0.254: v2(160.54,71.68) 160.54,71.73 160.16,72.11 159.02,72.11 158.61,72.52 157.65,72.52 157.42,72.75 157.42,74.63 155.82,76.23 154.38,76.23 153.76,75.6 153.76,75.58 152.39,74.22 152.39,73.28 151.86,72.75 149.69,72.75 149.14,72.19 149.14,71.08 148.34,70.29 146.67,70.29 145.6,69.22 138.17,69.22 137.89,68.94 122.87,68.94 121.6,70.21 121.6,71.78 121.6,73.97 119.81,75.76 107.34,75.76 107.1,76.01 107.1,76.79 105.87,78.03 101.31,78.03 101,78.34 92.74,78.34 91.93,77.52 90.29,77.52 87.89,75.13 87.77,75.13 84.37,71.73 79.44,71.73 v2(78.45,70.74)
  BOTTOM w0.254: v2(160.54,71.68) 160.54,71.73 160.57,71.76 160.77,71.76 161.33,72.32 161.36,72.32 161.53,72.49 UC1.H21 ; PC649.1 81.77,68.99 v2(82.1,69.32) 81.39,70.03 79.16,70.03 v2(78.45,70.74)
VSET_5085: length 4.1
  TOP w0.102: v3(269.23,70.63) 269.4,70.45 CE38.1 RE77.1 269.48,68.71 269.48,67.43 269.65,67.26 UE2.A17
WIGIG_32KHZ: length 3
  TOP w0.102: RZ56.2 256.19,20.55 v2(256.07,20.44)
  BOTTOM w0.102: JNGFF1.42 255.95,20.56 v2(256.07,20.44)
WLAN_DISBL#: length 40
  TOP w0.102: UE1.B68 253.8,86.63 253.25,86.08 v2(253.25,85.58)
  IN1 w0.089: v2(280.76,74.35) 280.76,74.25 280.27,73.76 278.62,73.76 278.5,73.64 277.12,73.64 276.82,73.94 275.41,73.94 274.99,74.36 274.23,74.36 271.65,76.94 269.25,76.94 265,81.2 265,83.16 264.05,84.11 262.58,84.11 260.3,86.39 259.85,86.39 259.24,87.01 259.19,87.01 258.83,87.37 255.04,87.37 v2(253.25,85.58)
  BOTTOM w0.102: v2(253.25,85.58) 253.25,85.89 v3(254.47,87.11) ; v2(280.76,74.35) 281.21,74.81 UL2.4
WLAN_WIGIG60GHZ_DIS#: length 112.6
  TOP w0.102: UE1.A1 253.39,88.37 253.61,88.59 253.61,90.41 253.28,90.75 253.28,90.78 252.67,91.39 252.67,94.05 251.55,95.17 v2(251.55,95.23) ; v2(265.21,75.9) 265.21,75.3 265,75.09 263.56,75.09 263.37,75.28 RPE12.2 ; DZ1.1 254.72,24.32 255.13,23.92 v2(255.13,23.65)
  IN2 w0.122: v2(251.55,95.23) 251.55,95.23 251.96,95.64 253.66,95.64 253.84,95.46 254.38,95.46 255.23,94.61 256.28,94.61 258.25,92.64 260.77,92.64 261.86,91.55 261.86,91.44 262.42,90.88 262.42,89.21 262.51,89.13 262.51,88.78 262.42,88.69 262.42,86.68 262.64,86.45 262.64,85.75 263.88,84.51 263.88,82.6 265.21,81.27 v2(265.21,75.9) 265.21,74.74 269.99,69.96 271.1,69.96 272.04,69.02 272.04,67.48 272.02,67.46 272.02,67.25 271.87,67.11 271.67,66.9 271.08,66.32 271.08,56.9 270.53,56.35 270.15,56.35 269.5,55.71 269.5,54.12 270.83,52.79 270.83,52.37 270.85,52.35 271.11,52.09 271.11,48.84 268.53,46.26 268.53,43.98 268.53,43.84 267.67,42.97 267.67,40.74 267.2,40.27 267.2,35.6 266.75,35.15 266.75,34.43 266.34,34.02 265.87,34.02 265.54,33.7 265.54,25.98 264.38,24.81 264.38,24.21 262.99,22.82 260.54,22.82 259.66,23.7 256.58,23.7 256.02,23.14 255.33,23.14 255.13,23.35 v2(255.13,23.65)
WLAN_WIGIG60GHZ_DIS#_R: length 8.7
  TOP w0.102: v3(254.09,26.86) v2(254.09,26.27) 254.24,26.12 DZ1.2
  BOTTOM w0.102: JNGFF1.48 257.45,25.9 256.63,26.72 254.55,26.72 v2(254.09,26.27)
WWAN_PWR_EN: length 6.6
  TOP w0.102: v2(240.07,75.44) 240.24,75.62 241.79,75.62 242.02,75.85 RZ43.2
  BOTTOM w0.102: v2(240.07,75.44) 240.07,75.65 240.72,76.3 JNGFF2.6 242.74,76.3 v3(243.44,77)
WWAN_RADIO_DIS#: length 31.5
  TOP w0.102: DZ5.1 240.43,73.8 v2(240.17,73.54) ; UE1.A53 255.33,80.88 255.81,80.4 v2(255.81,80.09) ; RPE12.4 262.37,76.54 v2(262.29,76.61)
  IN1 w0.089: v2(262.29,76.61) 262.29,76.71 261.43,77.58 259.82,77.58 259.5,77.89 256.57,77.89 255.81,78.65 v2(255.81,80.09)
  BOTTOM w0.102: v2(255.81,80.09) 253.94,80.09 253.43,80.6 252.44,80.6 251.83,79.99 v3(250.99,79.99) 249.11,79.99 246.98,77.86 246.23,77.86 244.59,76.21 244.59,74.78 243.17,73.36 241.32,73.36 241.14,73.54 v2(240.17,73.54)
WWAN_RADIO_DIS#_R: length 5.2
  TOP w0.102: v2(240.17,74.76) 240.17,74.91 240.46,75.2 DZ5.2
  BOTTOM w0.102: v2(240.17,74.76) 240.49,75.08 240.49,75.57 240.72,75.8 JNGFF2.8 242.58,75.8 242.83,75.55 242.83,74.95 v3(243,74.79)
WWAN_WAKE#: length 30.4
  TOP w0.102: v2(250.2,79.38) 250.13,79.38 249.64,78.9 UE1.B43 ; v2(250.94,74.45) 251.04,74.35 RE38.2
  IN2 w0.122: v2(240.32,72.95) 240.72,72.55 240.72,72.52 240.73,72.52 240.73,71.92 240.45,71.64 239.77,71.64 239.76,71.65 235.44,71.65 v2(235.24,71.85)
  BOTTOM w0.102: v2(235.24,71.85) 234.98,71.85 234.78,72.05 JNGFF2.15 ; v2(250.94,74.45) 250.94,76.61 v3(249.98,77.57) 249.74,77.81 249.74,78.91 v2(250.2,79.38) 249.82,79.76 249.29,79.76 247.13,77.6 246.39,77.6 244.97,76.18 244.97,74.58 243.52,73.13 240.5,73.13 v2(240.32,72.95)
XCLK_BIASREF: length 18.7
  TOP w0.102: RC52.1 155.82,86.1 v3(155.82,85.31) 155.69,85.18 155.69,81 153.81,79.12 153.81,77.7 152.72,76.61 150.94,76.61 149.49,75.16 v2(149.49,74.91) 149.49,73.89 148.37,72.77 RC324.1
  BOTTOM w0.076: v2(149.49,74.91) 149.66,74.74 UC1.E42
XDP_DBRESET#: length 222.7
  TOP w0.102: JXDP1.48 91.11,49.72 v2(91.02,49.81) 91.11,49.91 91.45,49.91 91.54,49.99 91.54,49.99 91.78,50.23 92.3,50.23 92.31,50.25 92.32,50.25 92.34,50.27 92.75,50.68 97.45,50.68 RC137.2
  IN1 w0.089: v2(77.99,85.39) 77.99,84.97 76.32,83.29 76.32,82.76 77.12,81.96 77.12,80.82 77.43,80.5 77.43,78.01 78.08,77.35 78.08,73.89 75.91,71.71 75.91,70.95 76.55,70.3 76.55,69.84 76.36,69.65 75.69,69.65 74.21,68.17 74.21,65.6 74.8,65.01 75.89,65.01 77.18,63.72 77.18,62.33 76.98,62.13 76.47,61.62 74.39,61.62 74.31,61.54 73.08,61.54 70.4,58.87 70.4,52.15 71.4,51.15 72.34,51.15 72.57,50.92 72.57,48.24 74.29,46.52 77.34,46.52 79.11,48.28 90.69,48.28 91.02,48.61 v2(91.02,49.81)
  IN2 w0.122: v2(180.28,86.08) 179.45,86.9 177.92,86.9 176.29,88.53 173.29,88.53 172.88,88.53 172.3,89.11 169.75,89.11 168.84,90.02 167.93,90.02 161.7,96.25 160.92,96.25 158.36,98.81 158.36,99.37 157.94,99.79 157.94,101.65 158.23,101.94 158.23,103.09 157.65,103.67 157.65,105.91 157.51,106.05 156.85,106.71 154.24,106.71 151.83,104.3 151.83,104.17 151.02,103.36 148,103.36 147.88,103.23 147.83,103.23 145.68,101.08 145.68,99.08 144.85,98.25 140.42,93.82 136.93,93.82 134.68,91.57 132.22,91.57 131.23,90.58 130.57,90.58 130.32,90.33 127.32,90.33 126.53,89.53 122.13,89.53 121.14,88.55 117.23,88.55 116.48,89.3 109.17,89.3 105.83,85.96 105.71,85.96 105.27,85.52 105.2,85.45 105.05,85.42 102.42,85.42 102.27,85.45 101.64,86.07 100.91,86.81 98.71,86.81 97.48,86.81 96.61,85.94 94.1,85.94 93.95,85.79 93.41,85.25 93.41,85.2 92.17,83.95 85.54,83.95 84.75,84.73 83.31,84.73 82.53,83.95 79.43,83.95 v2(77.99,85.39)
  BOTTOM w0.102: UC12.1 180.06,91.23 RC290.1 180.73,92.62 v3(180.97,92.85) 181.48,92.85 182.16,92.18 182.16,87.96 180.28,86.09 v2(180.28,86.08) ; CC32.1 90.66,49.46 v2(91.02,49.81)
XDP_JTAGX: length 25
  TOP w0.102: v2(139.41,81.19) 139.12,81.19 138.82,80.89 137.81,80.89 136.82,79.9 135.72,79.9 134.43,81.18 132.36,81.18 131.97,80.79 131.44,80.79 130.97,81.26 130.97,82.71 131.54,83.28 RC328.2
  BOTTOM w0.076: 140.07,78.48 140.07,77.19 UC1.A59
  BOTTOM w0.102: 140.07,78.48 139.63,78.91 139.63,79.04 139.63,79.2 139.27,79.55 138.69,79.55 138.6,79.65 138.4,79.65 138.34,79.71 138.34,80.13 v2(139.41,81.19) 139.52,81.31 139.52,81.84 141.42,83.74 141.42,84.54 RC87.1
XDP_OBS0: length 4.1
  TOP w0.102: JXDP1.21 84.61,40.89 84.32,40.59 83.73,40.59 v3(83.46,40.31) 83.46,39.52 RC239.2
XDP_OBS0_R: length 95.7
  TOP w0.102: v2(142.28,79.61) 142.28,79.59 140.92,78.24 140.57,78.24 140.22,77.89 140.22,76.67 139.56,76.01 138.34,76.01 136.59,74.26 136.59,74.01 136.21,73.63 135.38,73.63 134.73,72.97 134.73,72.18 132.3,69.75 132.3,65.03 133.17,64.16 133.17,63.06 128.87,58.75 128.01,58.75 126.88,57.62 126.88,55.43 126.99,55.32 126.99,55.2 127.08,55.07 127.18,54.97 127.97,54.18 127.97,50.1 124.99,47.12 v3(118.74,47.12) 117.51,47.12 104.11,33.72 90.61,33.72 88.43,35.9 87.41,35.9 87.18,36.13 85.74,36.13 83.58,38.29 RC239.1
  BOTTOM w0.076: v2(142.28,79.61) 142.01,79.34 UC1.C55
XDP_OBS1: length 3.5
  TOP w0.102: RC240.2 84.7,39.63 85.11,40.04 v2(85.11,40.81) JXDP1.23
XDP_OBS1_R: length 93.8
  TOP w0.102: RC240.1 84.47,37.98 85.89,36.55 87.33,36.55 87.58,36.31 88.6,36.31 90.78,34.13 v3(101.31,34.13) 103.94,34.13 117.83,48.01 117.83,54.29 124.7,61.17 130.7,61.17 132.76,63.23 132.76,63.9 131.89,64.78 131.89,69.92 134.17,72.2 134.17,73.04 135.57,74.43 135.57,74.68 136.02,75.14 136.55,75.14 138.01,76.6 138.87,76.6 139.81,77.54 139.81,78.06 140.4,78.64 140.69,78.64 141.63,79.58 v2(141.69,79.58)
  BOTTOM w0.076: v2(141.69,79.58) 142.09,79.98 142.46,79.98 142.68,79.76 142.68,79.41 142.19,78.92 142.19,76.46 142.33,76.32 142.33,76.05 142.01,75.73 UC1.D55
XDP_OBS2_R: length 5.8
  BOTTOM w0.076: T10.1 142.51,80.82 143.11,80.23 143.11,79.13 142.67,78.69 142.67,77.48 142.84,77.31 142.84,76.78 UC1.B54
XDP_OBS3_R: length 7
  BOTTOM w0.076: T11.1 140.92,81.83 141.85,80.9 141.85,80.26 141.32,79.74 141.32,78.92 141.71,78.53 141.71,76.3 141.45,76.03 UC1.C56
XDP_PRSNT_PIN1: length 12.5
  TOP w0.102: JXDP1.1 79.61,41.05 v3(85.28,35.39) 85.89,34.77 RC121.1 87.84,34.77 RC122.1
XDP_TMS: length 18.2
  TOP w0.102: UC8.9 101.67,43.53 101.81,43.39 103.31,43.39 RC228.1 ; v3(104.66,42.78) 104.33,42.78 RC228.1 ; RC228.1 103.52,44.17 103.29,44.4 v2(102.81,44.4) ; v2(95.74,47.81) 95.44,48.11 95.34,48.11 94.43,49.02 94.43,49.47 94.24,49.65 93.86,49.65 93.61,49.41 JXDP1.58
  IN2 w0.122: v2(102.81,44.4) 102.4,44.81 98.94,44.81 96.61,47.15 96.4,47.15 v2(95.74,47.81)
XTAL24_IN: length 13
  BOTTOM w0.076: UC1.E37 152.19,74.65 152.19,75.33 152.21,75.35 152.21,75.72 152.19,75.74 152.19,75.98 152.22,76.01 152.22,77.32 152.5,77.6 152.5,78.81 153,79.31
  BOTTOM w0.102: 153,79.31 153.11,79.42 153.11,81.71 RC46.2 152.61,82.93 152.49,83.06 CC21.1 152.49,83.14 152.8,83.46 153.11,83.76 153.11,84.94 YC1.3
XTAL24_OUT: length 9.5
  BOTTOM w0.076: 153.72,79.31 153.72,79.16 152.75,78.2 152.75,77.65 152.78,77.63 152.78,74.98 UC1.E35
  BOTTOM w0.102: RC46.1 RC295.1 154.37,81.84 153.72,81.19 v1(153.72,80.62) 153.72,79.31
XTAL24_OUT_R: length 2.6
  BOTTOM w0.102: RC295.2 155.31,82.22 CC22.1 155.31,83.24 YC1.1
XTALI: length 7.7
  TOP w0.102: YL1.1 258.56,80.86 258.56,81.39 258.48,81.47 258.48,83.39 RL11.2 258.66,83.6 CL14.2 259.68,84.61 259.68,85.09 259.88,85.3 260.35,85.3 260.58,85.53 UL1.10
XTALO: length 3.9
  TOP w0.102: RL34.2 RL11.1 259.7,85.53 260.29,85.53 260.7,85.93 UL1.9
XTALO_R: length 2.4
  TOP w0.102: YL1.3 257.68,83.07 257.77,83.16 RL34.1 CL13.2
Z2805: length 3.7
  TOP w0.508: v2(277.57,96.79) 277.57,95.31 RL18.1
  BOTTOM w0.508: TL1.22 277.45,96.68 v2(277.57,96.79)
Z2806: length 9.1
  TOP w0.102: v2(269.72,96.66) 268.99,97.4 267.44,97.4 v3(265.44,95.4)
  TOP w0.508: v2(269.72,96.66) 270.65,95.73 RL16.1
  BOTTOM w0.508: TL1.16 269.83,96.55 v2(269.72,96.66)
Z2807: length 3.8
  TOP w0.508: v2(276.72,96.82) 276.6,96.69 RL17.1
  BOTTOM w0.508: v2(276.72,96.82) 276.18,96.28 TL1.21
Z2808: length 8.1
  TOP w0.102: RL15.1 267.11,94.91 v3(265.58,93.38)
  TOP w0.508: v2(268.59,96.68) 268.59,95.76 RL15.1
  BOTTOM w0.508: v2(268.59,96.68) 268.56,96.66 TL1.15
N40459: length 4.1
  TOP w0.102: v2(92.39,79.02) 92.7,79.33 v1(92.7,80.18) 92.47,80.41 QV2.1
  BOTTOM w0.102: v2(92.39,79.02) 91.71,79.02 RV5.2
N43975: length 4.2
  TOP w0.102: RN2.2 281.01,17.15 281.14,17.28 281.27,17.28 281.38,17.39 QN1.5 QN1.6 282.49,17.74 283.26,18.51 v3(283.26,19.21)
N46665: length 4.9
  TOP w0.102: CA29.1 285.13,37.16 284.95,36.99 284.95,36.68 284.8,36.53 283.95,36.53 283.84,36.41 283.84,35.8 283.62,35.58 282.99,35.58 282.68,35.28 UA1.35
N46669: length 3.1
  TOP w0.102: UA1.36 282.67,35.68 282.9,35.91 283.1,35.91 v3(283.28,36.08) 283.55,36.36 283.55,36.81 283.91,37.16 CA29.2
N46677: length 6.2
  TOP w0.102: v3(286.83,31.69) 286.32,32.2 284.65,32.2 284.38,32.47 CA25.1 284.38,33.42 284.31,33.48 284.09,33.48 283.65,33.91 282.87,33.91 282.63,33.68 UA1.31
N46697: length 2.5
  TOP w0.102: v3(272.43,29.13) 272.97,29.13 273.32,28.78 CA27.1 273.07,28.03 RA12.1
N46705: length 1
  TOP w0.102: CA28.1 273.07,27.14 RA13.1
N46713: length 2.9
  TOP w0.102: v3(293.61,40.58) 293.61,41 RA21.2 292.67,41.56 292.49,41.74 QA2.5 QA2.6
N46735: length 1.4
  TOP w0.102: RA17.2 271.94,32.92 271.77,32.74 271.77,32.59 271.64,32.47 CA33.1
N70289: length 109.8
  TOP w0.102: v2(303.59,41.94) 303.87,42.22 303.87,43.2 302.77,44.3 JDEG1.9 299.02,44.3 298.21,45.11 298.21,45.9 296.78,47.33 RE74.2 ; RE306.2 252.44,92.45 252.44,90.61 RE305.2 251.14,89.58 v2(250.63,89.06)
  IN1 w0.089: v2(252.41,62.05) 253.04,61.41 254.89,61.41 254.95,61.47 260.41,61.47 260.59,61.47 260.59,61.47 260.8,61.47 261.26,61.92 263.44,61.92 263.95,62.42 268.35,62.42 268.57,62.64 270.09,62.64 270.53,62.2 277.64,62.2 279.23,60.61 279.64,60.61 281.73,58.52 281.73,58.11 282.4,57.44 283.27,57.44 283.56,57.73 286.86,57.73 291.12,53.47 291.12,51.87 291.71,51.29 297.2,51.29 303.87,44.62 303.87,42.21 v2(303.59,41.94)
  IN2 w0.122: v2(250.63,89.06) 251.12,88.57 251.12,86.2 251.99,85.33 251.99,80.18 251.54,79.72 251.54,77.94 252.94,76.53 252.94,75.7 251.96,74.72 251.96,74.14 252.46,73.63 252.46,72.94 252.46,66.86 252.49,66.83 252.49,65.56 252.85,65.2 252.85,64.4 252.59,64.14 252.21,64.14 252.02,63.95 252.02,62.44 v2(252.41,62.05)
N70739: length 3.7
  TOP w0.102: JDEG1.1 298.56,40.3 v3(298.05,39.79) 296.97,39.79 RE71.2
N70745: length 14.8
  TOP w0.102: v2(266,57.94) 266.4,57.54 UE2.B61 ; v2(270.36,51.51) 269.75,50.89 269.75,50.2 269.38,49.84 269.38,49.66 269.3,49.58 RE64.1
  BOTTOM w0.102: v2(266,57.94) 266.56,57.38 267.02,57.38 267.55,56.85 270.37,56.85 270.85,56.37 270.85,54.82 270.36,54.33 v2(270.36,51.51)
N70747: length 3
  TOP w0.102: v3(260.9,71.25) CE34.1 262.5,70.84 262.5,70.37 262.47,70.35 RE66.2
N70757: length 10.3
  TOP w0.279: UE2.A59 267.15,55.19 v2(267.3,55.05)
  TOP w0.381: v2(264.78,52.02) 265.23,51.58 v3(265.25,51.58) 265.66,51.17 265.66,50.17 266.24,49.58 RE58.1 RE57.1
  BOTTOM w0.457: 265.8,52.21 265.43,51.85 264.93,51.85 264.78,52 v2(264.78,52.02)
  BOTTOM w0.508: v2(267.3,55.05) 265.8,53.55 265.8,52.21
N75571: length 10
  BOTTOM w0.102: v1(283.47,68.85) 283.16,69.15 283.16,69.8 282.74,70.23 DZ4.2 283.54,70.3 284.31,71.07 284.92,71.07 285.23,70.76 QZ3.1 285.28,69.98 286.06,69.2 DZ3.2 286.19,68.59 286.55,68.95 RZ24.2
N75591: length 3
  BOTTOM w0.102: QZ4.1 284.49,74.78 RZ27.1 284.49,76.47 285.06,77.03 285.52,77.03 v3(285.52,77.04)
N75595: length 3.9
  BOTTOM w0.102: QZ3.3 283.93,69.65 284.09,69.48 284.47,69.48 284.92,69.03 v1(284.92,68.96) 285.14,68.74 285.14,68.11 DZ3.1
N13388109: length 2.2
  BOTTOM w0.102: v3(36.49,83.56) 36.4,83.47 PR916.2 36.4,82.12 36.51,82.01 PQ906.2
N13388133: length 5.3
  BOTTOM w0.102: v3(35.4,79.19) 36.82,79.19 PQ906.1 37.77,79.52 PR915.2 37.11,78.05 PQ909.2
N13388149: length 24.4
  TOP w0.102: PD901.2 26.05,88.37 26.3,88.12 26.3,88.1 v2(26.55,87.85)
  IN2 w0.122: v2(35.93,76.15) 34.99,77.09 33.82,77.09 33.01,76.28 31.35,76.28 30.87,76.76 30.87,77.8 30.23,78.45 30.23,80.82 30.43,81.02 30.43,85.98 29.2,87.2 27.19,87.2 v2(26.55,87.85)
  BOTTOM w0.102: PQ909.1 36.78,75.3 v2(35.93,76.15) v3(35.08,76.15)
N13388161: length 3.9
  BOTTOM w0.102: PQ909.3 39.04,79.06 PR915.1 39.09,79.59 38.95,79.74 PR913.2 39.25,80.33 v3(40.05,80.33)
N15438178: length 1.7
  BOTTOM w0.508: PD801.1 v3(57.11,81.58)
  vias: v2(55.97,84.92)
N15438627: length 6.8
  TOP w0.254: v2(58.2,89.46) 58.71,89.46 58.99,89.74 PC815.1 PR813.1
  BOTTOM w0.102: v3(55.59,88.92) 55.65,88.85 PR812.1
  BOTTOM w0.203: 58.2,89.49 58.36,89.33 PU801.6
  BOTTOM w0.254: v2(58.2,89.46) 58.2,89.49 58.15,89.54 57.14,89.54 56.6,89.01 PR812.1
N15439163: length 2.3
  TOP w0.254: v2(58.57,88.87) 58.5,88.8 57.64,88.8 PR815.2
  BOTTOM w0.203: PU801.5 58.62,88.93 v2(58.57,88.87)
N15439291: length 4
  TOP w0.254: v2(58.48,90.67) 58.48,90.78 PC823.2
  BOTTOM w0.203: v2(58.48,90.67) 59.42,89.73 PU801.7
  BOTTOM w0.254: v2(58.48,90.67) 57.93,90.12 PR816.2
N15439295: length 5.7
  TOP w0.254: PC824.2 v2(60.16,92.22)
  BOTTOM w0.203: PU801.8 60.5,90.97 60.43,91.05 60.43,91.95 v2(60.16,92.22)
  BOTTOM w0.254: PR819.2 57.7,91.01 58.16,91.47 58.16,91.69 v3(58.68,92.22) 60.15,92.22 v2(60.16,92.22)
N15439512: length 8.5
  TOP w0.254: PR822.2 61.05,92.03 60.87,92.21 v2(60.85,92.21)
  BOTTOM w0.203: PU801.9 60.9,92.16 v2(60.85,92.21)
  BOTTOM w0.254: v2(60.85,92.21) 60.85,92.41 59.27,94 57.91,94 v3(57.75,93.83) 57.52,93.6 PR820.2
N15440461: length 4
  BOTTOM w0.102: v3(60.37,94) 60.37,93.57 PR818.2
  BOTTOM w0.203: PR818.2 61.56,91.98 61.3,91.72 PU801.10
N15440728: length 5.5
  BOTTOM w0.203: PR829.1 PR827.2 67.03,90.31 65.83,90.31 65.54,90.61 v3(64.82,90.61) 64.56,90.34 64.56,89.58 64.31,89.33 PU801.16
N15441413: length 3.2
  BOTTOM w0.203: PR825.1 65.55,87.84 64.86,88.53 PU801.18
N15441884: length 5.8
  BOTTOM w0.203: PC828.1 67.39,89.98 PR826.1 66.34,88.94 v3(65.42,88.94) 65.41,88.93 PU801.17
N15442134: length 22.2
  TOP w0.254: PR823.3 76.41,79.71 76.29,79.84 76.29,82.13 74.42,84 71.79,84 69.42,86.38 68.3,86.38 v3(68.22,86.47) 68.13,86.38 67.7,86.38 66.51,87.56 65.82,87.56 65.49,87.23 65.49,86.85 v2(65.95,86.39)
  BOTTOM w0.203: PU801.20 64.19,87.73
  BOTTOM w0.254: PC829.2 PC830.1 66.51,86.06 66.31,86.26 66.08,86.26 v2(65.95,86.39) 65.81,86.53 65.4,86.53 64.45,87.47 64.45,87.48 64.24,87.68 64.24,87.68 64.19,87.73
N15442185: length 19.5
  TOP w0.254: v2(65.99,87.04) 66.5,87.04 67.54,86 69.16,86 71.54,83.62 74.24,83.62 75.91,81.95 75.91,79.91 75.7,79.71 PR823.2
  BOTTOM w0.203: PU801.19 64.44,88.13 v3(65.36,87.21)
  BOTTOM w0.254: PC831.1 66.66,86.95 PC830.2 66.05,86.97 v2(65.99,87.04) 65.53,87.04 v3(65.36,87.21)
N15443707:
  vias: v3(61.75,85.32)
N17156946: length 15.3
  TOP w0.254: v2(35.01,91.21) 35.21,91.01 PR15.1 PR14.1 35.21,89.21 35.3,89.13 PR1.2 34.94,88.34 PC5.1 35.09,87.23 PQ5.4 ; PQ1.4 v2(42.18,88.11)
  IN2 w0.254: v2(35.01,91.21) 35.01,91.04 36.77,89.28 38.72,89.28 39.9,88.11 v2(42.18,88.11)
N17252180: length 5.1
  TOP w0.508: v2(123.27,103.27) 122.67,102.67 122.67,101.25 PR906.1 121.87,101.17 PC902.2
  BOTTOM w0.508: v2(123.27,103.27) 122.67,102.67 PQ904.4
N17252838: length 3.8
  TOP w0.102: v3(67.04,13.91) 67.04,14.14 65.32,15.87 PQ911.5 64.21,15.87 PR919.2
N18339814: length 3.2
  TOP w0.254: RA25.2 282.03,23.52 v3(282.68,22.87)
  TOP w0.381: DA5.1 282.14,24.39 RA25.2
