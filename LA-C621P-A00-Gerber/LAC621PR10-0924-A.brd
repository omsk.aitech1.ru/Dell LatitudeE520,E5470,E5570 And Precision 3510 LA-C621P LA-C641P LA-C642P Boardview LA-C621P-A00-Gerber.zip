# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_ACT#: length 90.6
  IN4 w0.076: v2(142.8,59.86) 143.17,59.49 143.17,57.16 142.42,56.41 142.42,55.99 142.07,55.64
  IN4 w0.145: 142.07,55.64 140.9,54.47 140.9,53.6 138.81,51.51 138.81,46.29 138.4,45.89 138.4,36.53 142.65,32.28 142.65,31.47 152.17,21.95 154.24,21.95 157.56,18.62 167.55,18.62 168.07,18.1 168.98,18.1 169.23,17.84 169.23,16.46 170.24,15.45 173.75,15.45 173.8,15.4 175.45,15.4 175.88,15.83 177.4,15.83 178.3,14.94 179.13,14.94 179.67,15.48 179.67,15.6 180.07,16 183.53,16 184.78,14.75 185.49,14.75 186.24,14 v2(187.82,14)
  BOTTOM w0.076: UC1.AN53 v2(142.8,59.86)
  BOTTOM w0.168: JDIMM2.114 189.12,12.64 188.81,12.96 188.81,13.77 188.58,14 v2(187.82,14)
DDR_B_ALERT#: length 71.4
  IN1 w0.076: 150.8,55.55 149.69,56.65 149.69,59.36 v2(149.19,59.87)
  IN1 w0.089: 159.11,54.84 151.5,54.84 150.8,55.55
  IN1 w0.145: v2(189.62,13.01) 188.15,14.48 187.11,14.48 183.54,18.05 183.54,22.6 166.23,39.91 166.23,45.52 164.2,47.55 164.2,51.21 160.57,54.84 159.11,54.84
  BOTTOM w0.168: JDIMM2.116 v2(189.62,13.01)
  BOTTOM w0.254: v2(149.19,59.87) 148.81,60.25 UC1.AN43
DDR_B_BA0: length 90.6
  IN4 w0.076: v2(147.88,47.15) 148.45,46.59 148.45,44.73 148.38,44.66 148.38,43.64
  IN4 w0.145: 148.38,43.64 148.38,42.93 148.38,41.84 158.41,31.81 160.57,31.81 162.6,29.78 164.21,29.78 164.58,29.4 173.01,29.4 173.35,29.07 185.82,29.07 186.16,29.4 194.12,29.4 199.27,24.26 199.27,20.57 199.52,20.32 199.76,20.08 199.77,20.08 199.95,19.89 199.95,14.45 200.18,14.22 200.18,12.29 200.03,12.15 199.72,12.15 199.58,12.29 199.58,14.05 v2(199.07,14.56)
  BOTTOM w0.076: UC1.BB44 148.5,54.43 148.5,53.19 148.41,53.09 148.41,51.03 148.49,50.95 148.49,48.37 148.32,48.19 148.32,47.78
  BOTTOM w0.168: 148.32,47.78 148.32,47.58 v2(147.88,47.15) ; JDIMM2.150 200.12,13.48 199.07,14.53 v2(199.07,14.56)
DDR_B_BA1: length 91.3
  IN4 w0.076: v2(147.88,48.44) 147.88,48.32 147.52,47.95 147.52,43.96 147.53,43.95 147.53,43.64
  IN4 w0.145: v2(198.13,17.76) 198.13,16.23 198.28,16.08 198.89,16.08 199.07,16.26 199.07,16.92 198.77,17.22 198.77,18.03 198.12,18.67 198.12,21.52 197.07,22.57 197.07,23.8 197.28,24 197.48,24 197.55,23.94 197.76,23.94 197.97,24.15 197.97,24.35 197.13,25.2 196.94,25.2 196.61,24.87 196.41,24.87 196.2,25.08 196.2,25.28 196.53,25.61 196.53,25.79 196.31,26.02 196.12,26.02 195.79,25.69 195.59,25.69 195.39,25.9 195.39,26.1 195.58,26.3 195.58,26.51 195.38,26.71 195.17,26.71 194.98,26.51 194.77,26.51 194.57,26.72 194.57,26.92 194.89,27.25 194.89,27.43 194.67,27.66 194.48,27.66 194.16,27.33 193.95,27.33 193.75,27.54 193.75,27.74 194.07,28.07 194.07,28.25 193.85,28.47 193.66,28.48 193.34,28.15 193.13,28.15 192.73,28.56 186.51,28.56 186.18,28.22 160.8,28.22 147.53,41.49 147.53,43.13 147.53,43.64
  BOTTOM w0.076: UC1.BA44 148.34,54.92 148.34,53.26 148.27,53.19 148.27,53.19 148.24,53.16 148.24,50.96 148.27,50.93 148.27,48.83 v2(147.88,48.44)
  BOTTOM w0.168: v2(198.13,17.76) 198.13,18.55 198.87,19.29 JDIMM2.145
DDR_B_BG0: length 90.6
  IN4 w0.076: 142.63,54.94 144.1,56.41 144.1,58.84 v2(143.72,59.22)
  IN4 w0.145: 142.63,54.94 142.63,53.61 142.33,53.31 141.46,52.44 140.24,51.22 140.24,46.2 139.25,45.21 139.25,36.88 151.54,24.59 151.54,24.39 151.34,24.19 151.34,23.98 151.54,23.78 151.75,23.78 151.95,23.98 152.15,23.98 152.36,23.77 152.36,23.57 152.16,23.37 152.16,23.16 152.52,22.8 154.59,22.8 157.91,19.47 168.06,19.47 168.46,19.07 176.29,19.07 177.15,18.21 177.15,17.72 177.6,17.27 177.89,17.27 178.04,17.42 178.04,18.41 178.18,18.55 178.8,18.55 179.11,18.24 179.11,17.94 179.51,17.53 183.66,17.53 184.13,17.06 184.13,16.71 184.76,16.08 v2(186.3,16.08)
  BOTTOM w0.076: v2(143.72,59.22) 144.1,59.6 UC1.AP52
  BOTTOM w0.168: JDIMM2.115 189.37,17.59 188.83,17.04 188.36,17.04 188.05,16.73 186.95,16.73 v2(186.3,16.08)
DDR_B_BG1: length 91.6
  IN4 w0.076: v2(144.63,59.86) 145,59.49 145,57.8 144.66,57.46 144.66,56.21 143.37,54.92
  IN4 w0.145: v2(187.62,17.45) 187.84,17.45 188.31,16.98 188.31,16.78 188.14,16.6 187.8,16.6 187.41,16.99 187.08,16.99 186.93,17.14 186.93,17.97 186.79,18.11 186.54,18.11 186.4,17.97 186.4,17.14 186.25,17 186.01,17 185.86,17.14 185.86,17.92 185.72,18.06 185.4,18.06 185.25,17.92 185.25,17.75 185.11,17.61 184.79,17.61 184.62,17.78 184.62,17.99 184.47,18.13 184.26,18.13 184.02,18.38 184.02,18.58 183.88,18.72 183.54,18.72 183.4,18.58 183.4,18.49 183.29,18.38 182.95,18.38 182.84,18.49 182.84,18.58 182.7,18.72 182.3,18.72 182.15,18.58 182.15,18.52 182.01,18.38 181.72,18.38 181.58,18.52 181.58,18.58 181.43,18.72 181.14,18.72 181,18.58 181,18.52 180.85,18.38 180.56,18.38 180.42,18.52 180.42,18.58 180.27,18.72 179.87,18.72 179.19,19.4 177.16,19.4 176.64,19.92 168.81,19.92 168.41,20.32 158.27,20.32 154.94,23.65 153.68,23.65 140.25,37.08 140.25,37.37 140.39,37.52 140.56,37.52 140.7,37.66 140.7,37.89 140.49,38.1 140.24,38.1 140.1,38.25 140.1,44.86 141.09,45.85 141.09,50.87 143.37,53.15 143.37,54.92
  BOTTOM w0.076: v2(144.63,59.86) 144.57,59.86 UC1.AN52
  BOTTOM w0.168: JDIMM2.113 188.87,18.38 188.58,18.09 187.9,18.09 187.62,17.81 v2(187.62,17.45)
DDR_B_CKE0: length 92.9
  IN4 w0.076: v2(141.85,59.85) 142.12,59.57 142.12,59.57 142.26,59.43 142.26,56.26 141.65,55.65
  IN4 w0.145: v2(183.75,14.78) 181.8,12.83 160.91,12.83 157.39,16.35 152.66,16.35 150.3,18.71 150.3,22.31 142,30.61 142,32.01 138.66,35.34 137.75,36.26 137.75,46.22 138.15,46.63 138.15,51.43 140.5,53.77 140.5,54.5 141.65,55.65
  BOTTOM w0.076: UC1.AN56 141.44,60.25 141.85,59.85 v2(141.85,59.85)
  BOTTOM w0.168: JDIMM2.109 187.87,18.86 186.83,17.81 186.27,17.81 184.87,16.41 184.87,15.9 v2(183.75,14.78)
DDR_B_CKE1: length 92.3
  IN4 w0.076: 141.48,55.86 141.48,58.75 v2(141.89,59.16)
  IN4 w0.145: v2(185.3,13.8) 185.3,13.15 185.56,12.9 185.56,12.55 185.41,12.41 160.61,12.41 157.11,15.91 152.51,15.91 149.88,18.54 149.88,22.13 141.58,30.43 141.58,31.83 138.49,34.92 137.32,36.08 137.32,46.4 137.73,46.81 137.73,51.44 140.01,53.72 140.01,54.39 141.48,55.86
  BOTTOM w0.076: v2(141.89,59.16) 142.35,59.54 UC1.AP55
  BOTTOM w0.168: JDIMM2.110 188.12,12.6 186.77,13.96 185.47,13.96 v2(185.3,13.8)
DDR_B_CKE2: length 1.1
  TOP w0.168: v2(142.74,60.54) 143.02,60.83 T5.1
  BOTTOM w0.076: v2(142.74,60.54) 142.44,60.25 UC1.AN55
DDR_B_CKE3: length 1.2
  TOP w0.168: v2(142.8,59.22) 142.9,59.22 T6.1
  BOTTOM w0.076: UC1.AP53 v2(142.8,59.22)
DDR_B_CLK0: length 96.2
  IN4 w0.076: 147.74,55.83 147.74,55.85 147.7,55.89 147.7,56.55 147.92,56.77 147.92,59.39 148.06,59.53 148.06,59.62 v2(148.29,59.86)
  IN4 w0.112: v2(195.83,16.39) 196.04,16.6 196.81,16.6 197.06,16.84 197.06,17.3 196.45,17.91 196.45,19.29 196.2,19.53 195.96,19.53 195.85,19.65 195.85,19.98 195.96,20.09 196.13,20.09 196.39,20.35 196.39,20.93 196.13,21.19 195.67,21.19 195.56,21.3 195.56,21.94 195.54,21.96 191.04,26.47 189.7,26.47 189.44,26.21 189.44,25.15 189.33,25.04 188.99,25.04 188.88,25.15 188.88,26.21 188.63,26.47 188.09,26.47 187.83,26.21 187.83,25.67 187.72,25.56 187.38,25.56 187.27,25.67 187.27,26.21 187.02,26.47 184.76,26.47 184.5,26.21 184.5,25.44 184.39,25.33 184.06,25.33 183.95,25.44 183.95,26.21 183.69,26.47 183.22,26.47 182.89,26.13 182.66,26.13 182.26,26.53 182.12,26.67 182.01,26.67 160.25,26.67 146.01,40.91 146.01,43.95 146.82,44.76 146.82,48.33 146.95,48.45 146.95,52.65 147.74,53.45 147.74,55.83
  BOTTOM w0.076: v2(148.29,59.86) 148.09,59.86 UC1.AP45
  BOTTOM w0.094: v2(195.83,16.39) 195.72,16.49 195.23,16.49 194.97,16.75 194.97,17.75 194.87,17.84 JDIMM2.137
DDR_B_CLK1: length 95.4
  IN4 w0.076: v2(146.47,59.21) 146.47,59.41 146.54,59.49 146.61,59.49 146.68,59.55 146.84,59.55 146.94,59.45 146.94,59.08 146.84,58.97 146.84,56.99 146.29,56.45 146.29,55.89 146.25,55.85 146.25,55.83
  IN4 w0.112: v2(195.31,14.66) 195.34,14.66 195.6,14.92 195.6,15.36 194.94,16.02 194.94,18.96 194.53,19.37 194.53,21.54 193.45,22.62 193.29,22.62 192.82,22.15 192.46,22.15 192.08,22.53 192.08,22.89 192.55,23.37 192.55,23.52 192.31,23.76 192.16,23.76 191.54,23.14 191.17,23.14 190.79,23.52 190.79,23.89 191.41,24.51 191.41,24.66 191.1,24.97 190.75,24.97 189.77,24 187.99,24 187.81,24.17 187.44,24.54 186.56,24.54 186.42,24.54 186.17,24.79 186.17,25.34 186.06,25.45 185.67,25.45 185.55,25.34 185.55,24.67 185.19,24.3 182.96,24.3 181.6,25.66 178.61,25.66 178.61,25.66 159.83,25.66 144.99,40.49 144.99,44.4 145.81,45.22 145.81,48.75 145.93,48.87 145.93,55.11 146.25,55.43 146.25,55.83
  BOTTOM w0.076: UC1.AP46 146.86,59.6 v2(146.47,59.21)
  BOTTOM w0.094: v2(195.31,14.66) 195.55,14.42 195.55,13.55 195.28,13.28 195.28,12.93 195.12,12.77 JDIMM2.138
DDR_B_CLK#0: length 96.1
  IN4 w0.076: v2(147.38,59.86) 147.81,59.86 147.89,59.77 147.89,59.6 147.75,59.46 147.75,56.84 147.53,56.62 147.53,55.89 147.49,55.85 147.49,55.83
  IN4 w0.112: 147.49,55.83 147.49,53.55 146.84,52.9 146.7,52.76 146.7,48.56 146.57,48.43 146.57,44.87 145.76,44.05 145.76,40.81 160.14,26.43 178.29,26.43 178.29,26.43 181.91,26.43 182.01,26.43 182.55,25.89 182.99,25.89 183.33,26.22 183.59,26.22 183.7,26.11 183.7,25.34 183.95,25.08 184.49,25.08 184.75,25.34 184.75,26.11 184.86,26.22 186.91,26.22 187.03,26.11 187.03,25.57 187.28,25.31 187.82,25.31 188.08,25.57 188.08,26.11 188.19,26.22 188.52,26.22 188.64,26.11 188.64,25.05 188.89,24.79 189.43,24.79 189.69,25.05 189.69,26.11 189.8,26.22 190.94,26.22 195.31,21.84 195.31,21.2 195.57,20.94 196.03,20.94 196.14,20.83 196.14,20.45 196.03,20.34 195.86,20.34 195.61,20.08 195.61,19.54 195.86,19.29 196.1,19.29 196.2,19.19 196.2,17.81 196.81,17.2 196.81,16.95 196.71,16.84 195.92,16.84 195.79,16.97 v2(195.8,16.97)
  BOTTOM w0.076: v2(147.38,59.86) 147.62,59.86 147.83,60.07 UC1.AN45
  BOTTOM w0.094: v2(195.8,16.97) 195.8,16.95 195.53,16.68 195.31,16.68 195.16,16.83 195.16,17.83 195.07,17.92 195.07,18.89 195.37,19.19 JDIMM2.139
DDR_B_CLK#1: length 95.3
  IN4 w0.076: v2(146.46,59.86) 146.6,59.72 146.9,59.72 147.1,59.52 147.1,59.01 147,58.91 147,56.93 146.45,56.38 146.45,55.89 146.49,55.85 146.49,55.83
  IN4 w0.112: 146.49,55.83 146.49,55.33 146.18,55.01 146.18,48.77 146.05,48.64 146.05,45.11 145.24,44.3 145.24,40.6 159.93,25.91 178.51,25.91 181.7,25.91 183.06,24.55 185.08,24.55 185.31,24.77 185.31,25.44 185.56,25.7 186.16,25.7 186.41,25.44 186.41,24.9 186.52,24.79 187.54,24.79 188.09,24.25 189.67,24.25 190.64,25.22 191.2,25.22 191.66,24.77 191.66,24.4 191.04,23.79 191.04,23.63 191.28,23.39 191.43,23.39 192.05,24.01 192.42,24.01 192.8,23.63 192.8,23.26 192.32,22.79 192.32,22.63 192.56,22.4 192.72,22.4 193.19,22.87 193.55,22.87 194.78,21.65 194.78,19.47 195.19,19.06 195.19,16.13 195.85,15.47 195.85,14.79 v2(195.97,14.66)
  BOTTOM w0.076: UC1.AN46 v2(146.46,59.86)
  BOTTOM w0.094: v2(195.97,14.66) 195.74,14.43 195.74,13.47 195.47,13.2 195.47,12.93 195.62,12.77 JDIMM2.140
DDR_B_CS#0: length 93.6
  IN4 w0.145: v2(149.41,51.36) 149.8,51.36 150.23,50.93 150.23,46.05 150.73,45.56 150.73,42.85 150.89,42.68 151.6,41.97 159.03,34.54 159.41,34.16 160.2,34.16 160.34,34.3 160.34,34.42 160.49,34.56 160.78,34.56 160.92,34.42 160.92,34.3 161.07,34.16 161.19,34.16 161.19,34.16 161.54,34.16 162.06,33.63 162.6,33.63 162.75,33.49 162.75,32.95 162.93,32.77 163.23,32.77 163.38,32.91 163.38,33.49 163.52,33.64 163.81,33.64 163.96,33.49 163.96,33.3 164.1,33.15 164.39,33.15 164.54,33.3 164.54,33.49 164.68,33.64 164.97,33.64 165.11,33.49 165.11,33.3 165.26,33.15 165.55,33.15 165.69,33.3 165.69,33.49 165.84,33.64 166.13,33.64 166.27,33.49 166.27,33.3 166.42,33.15 166.71,33.15 166.85,33.3 166.85,33.49 167,33.64 167.29,33.64 167.43,33.49 167.43,33.3 167.58,33.15 167.87,33.15 168.01,33.3 168.01,33.49 168.16,33.64 168.45,33.64 168.59,33.49 168.59,33.3 168.73,33.15 169.02,33.15 169.17,33.3 169.17,33.49 169.31,33.64 169.6,33.64 169.75,33.49 169.75,33.14 170.19,32.71 171.38,32.71 172.33,31.75 173.99,31.75 174.32,31.42 184.65,31.42 184.99,31.75 195.09,31.75 195.73,31.12 201.62,25.23 201.62,24.48 201.73,24.36 202.15,24.36 202.3,24.21 202.3,17.32 202.46,17.17 202.64,17.17 202.86,16.95 202.86,16.57 202.7,16.41 202.4,16.41 202.32,16.49 v2(202.09,16.49)
  BOTTOM w0.076: UC1.BB42 149.97,54.49 149.97,53.51 149.74,53.29 149.74,52.18
  BOTTOM w0.168: v2(149.41,51.36) 149.44,51.36 149.75,51.68 149.75,52.15 149.74,52.16 149.74,52.18 ; JDIMM2.149 199.87,19.18 198.93,18.23 198.93,17.16 199.83,16.26 201.86,16.26 v2(202.09,16.49)
DDR_B_CS#1: length 94.4
  IN4 w0.145: v2(201.87,18.5) 201.87,20.69 201.19,21.37 201.19,25.05 195.3,30.95 194.92,31.33 185.28,31.33 184.94,31 174.14,31 173.81,31.33 171.58,31.33 171.43,31.47 171.43,31.99 171.29,32.13 171,32.13 170.85,31.99 170.85,31.47 170.71,31.33 170.42,31.33 170.27,31.47 170.27,32.12 170.1,32.29 169.81,32.29 169.69,32.17 169.69,31.47 169.55,31.33 169.26,31.33 169.11,31.47 169.11,32.57 168.97,32.72 168.68,32.72 168.54,32.57 168.54,31.47 168.39,31.33 168.1,31.33 167.96,31.47 167.96,32.52 167.81,32.67 167.52,32.67 167.38,32.52 167.38,31.47 167.23,31.33 166.94,31.33 166.8,31.47 166.8,32.57 166.65,32.72 166.36,32.72 166.22,32.57 166.22,31.47 166.07,31.33 165.74,31.33 165.59,31.47 165.59,32.55 165.45,32.69 165.15,32.69 165.01,32.55 165.01,31.85 164.87,31.7 164.57,31.7 164.43,31.85 164.43,32.55 164.28,32.69 164.01,32.69 163.87,32.55 163.87,31.85 163.72,31.7 163.4,31.7 161.89,33.21 161.36,33.73 159.21,33.73 150.3,42.64 150.3,45.5 149.87,45.93 149.87,50.26 v2(149.46,50.67)
  BOTTOM w0.076: UC1.AY42 150.21,55.56 150.21,53.43 150.07,53.29 150.07,52.97 150.08,52.96
  BOTTOM w0.102: 149.49,50.7 v2(149.46,50.67)
  BOTTOM w0.168: 150.08,52.96 150.08,52.58 150.23,52.43 150.23,51.44 149.49,50.7 ; JDIMM2.157 v2(201.87,18.5)
DDR_B_D0: length 50.4
  IN1 w0.084: v2(152.04,47.32) 151.99,47.32 151.99,47.32 151.64,46.97 151.64,46.01
  IN1 w0.089: v2(163.11,13.49) 162.7,13.49 162.01,14.18 162.01,19.43 151.64,29.81 151.64,29.81 151.64,46.01
  BOTTOM w0.076: 150.74,51.04 150.74,52.62 150.85,52.73 150.85,53.39 150.82,53.42 150.82,54.14 150.77,54.19 150.77,54.67 150.84,54.8 150.84,55.11 150.94,55.36 151.21,55.63 UC1.AY39
  BOTTOM w0.102: JDIMM2.8 162.62,13.01 v2(163.11,13.49) ; 150.74,51.04 150.56,50.86 150.56,48.8 v2(152.04,47.32)
DDR_B_D1: length 48.2
  IN1 w0.084: 150.73,43.24 150.73,51.97 v2(151.97,53.21)
  IN1 w0.089: 150.73,43.24 150.73,30.77 150.72,30.77 150.72,29.43 150.73,29.43 155.24,24.91 155.24,23.9 159.78,19.36 159.78,19.02 159.87,18.93 160.3,18.93 160.39,18.84 160.39,18.66 160.3,18.57 159.87,18.57 159.78,18.48 v2(159.78,17.61)
  BOTTOM w0.076: UC1.AW39 151.86,56.48 152.12,56.22 152.12,55.65 152.14,55.61 152.14,55.42 152.08,55.27 152.08,55.12 152.15,54.9 152.15,54.79 152.1,54.67 152.1,54.3 152.3,54.1 152.3,53.54 v2(151.97,53.21)
  BOTTOM w0.102: JDIMM2.3 161.37,19.18 159.8,17.61 v2(159.78,17.61)
DDR_B_D2: length 50.5
  IN1 w0.084: 152.77,45.64 152.77,51.72 v2(151.97,52.53)
  IN1 w0.089: 152.77,45.64 152.84,45.58 152.84,30.31 163.62,19.53 163.78,19.36 163.78,15.69 v2(163.18,15.09)
  BOTTOM w0.076: UC1.AY37 152.33,55.73 152.33,55.47 152.26,55.26 152.26,55.13 152.32,54.9 152.32,54.76 152.27,54.64 152.27,54.37 152.47,54.17 152.47,53.03 v2(151.97,52.53)
  BOTTOM w0.102: JDIMM2.16 164.62,14.18 163.71,15.09 v2(163.18,15.09)
DDR_B_D3: length 51.2
  IN1 w0.084: 153.14,43.26 153.14,45.65 152.99,45.8 152.99,48.16 v2(153.38,48.54)
  IN1 w0.089: v2(165.06,14.56) 164.09,15.53 164.09,19.49 163.64,19.94 163.64,20.07 163.76,20.19 163.76,20.31 163.64,20.44 163.51,20.44 163.39,20.32 163.26,20.32 153.14,30.44 153.14,43.26
  BOTTOM w0.076: v2(153.38,48.54) 152.96,48.96 152.96,49.33 152.78,49.51 152.78,52.47 152.96,52.66 152.96,54.17 152.96,55.19 152.74,55.41 152.74,55.95 152.43,56.26 UC1.AW37
  BOTTOM w0.102: v2(165.06,14.56) 165.62,14 JDIMM2.20
DDR_B_D4: length 48.7
  IN1 w0.084: v2(152.06,49.23) 151.83,49.23 151.05,48.45 151.05,47.92 151.03,47.9 151.03,43.24
  IN1 w0.089: v2(161.31,17.5) 161.31,19.28 157.58,23.01 157.45,23.01 157.09,22.65 156.97,22.65 156.84,22.78 156.84,22.9 157.2,23.26 157.2,23.39 157.07,23.51 156.95,23.51 156.56,23.13 156.44,23.13 156.31,23.26 156.31,23.38 156.7,23.76 156.7,23.89 156.57,24.01 156.44,24.01 156.09,23.66 155.96,23.66 155.84,23.78 155.84,23.91 156.19,24.27 156.19,24.39 151.03,29.55 151.03,43.24
  BOTTOM w0.076: 151.21,50.45 151.21,50.56 151.16,50.6 151.16,52.56 151.18,52.58 151.18,53.53 151.16,53.55 151.16,53.59 151.15,53.6 151.15,54.2 151.21,54.29 UC1.BB39
  BOTTOM w0.102: v2(152.06,49.23) 151.21,50.08 151.21,50.45 ; v2(161.31,17.5) 162.37,18.57 JDIMM2.7
DDR_B_D5: length 49.2
  IN1 w0.089: v2(161.2,14.05) 161.38,14.05 161.71,14.38 161.71,19.31 151.33,29.68 151.33,29.69 151.33,47.92 v2(152.04,48.63)
  BOTTOM w0.076: 150.88,50.45 150.88,50.84 150.99,50.96 150.99,52.62 151.01,52.65 151.01,53.46 150.99,53.49 150.99,54.21 150.94,54.25 150.94,54.64 151.06,54.89 151.06,54.89 151.07,54.89 151.07,55.04 UC1.BA39
  BOTTOM w0.102: 150.88,50.45 150.88,49.72 151.97,48.63 v2(152.04,48.63) ; JDIMM2.4 161.62,13.63 v2(161.2,14.05)
DDR_B_D6: length 49.9
  IN1 w0.084: 153.83,44.02 153.83,46.85 v2(153.36,47.32)
  IN1 w0.089: v2(165.85,18.16) 164.81,19.21 164.81,20.93 162.9,22.84 162.78,22.84 162.27,22.33 162.14,22.33 162.02,22.45 162.02,22.58 162.53,23.09 162.53,23.21 162.4,23.34 162.28,23.34 161.77,22.83 161.61,22.83 161.46,22.98 161.46,23.11 161.97,23.62 161.97,23.75 161.85,23.87 161.72,23.87 161.21,23.36 161.08,23.36 160.96,23.49 160.96,23.61 161.25,23.91 161.25,24.03 161.13,24.16 161,24.16 160.7,23.86 160.58,23.86 153.75,30.69 153.75,43.94 153.83,44.02
  BOTTOM w0.076: v2(153.36,47.32) 153.35,47.32 152.8,47.88 152.8,49.23 152.61,49.41 152.61,52.54 152.8,52.72 152.8,54.24 152.8,54.24 152.8,54.7 152.53,54.97 UC1.BA37
  BOTTOM w0.102: v2(165.85,18.16) 165.87,18.19 JDIMM2.21
DDR_B_D7: length 49.3
  IN1 w0.084: v2(153.38,46.1) 153.45,46.03 153.45,43.24
  IN1 w0.089: 153.45,43.24 153.45,30.56 162.19,21.82 162.32,21.82 162.66,22.16 162.79,22.16 162.92,22.04 162.92,21.91 162.6,21.59 162.6,21.42 162.7,21.32 163.63,21.32 164.5,20.44 164.5,17.68 165.54,16.64 v2(165.85,16.64)
  BOTTOM w0.076: UC1.BB37 152.53,54.34 152.63,54.24 152.63,52.79 152.45,52.61 152.45,49.52 152.45,49.05 152.49,49.01 152.49,47.98
  BOTTOM w0.102: v2(153.38,46.1) 153.3,46.1 152.49,46.92 152.49,47.98 ; JDIMM2.17 164.87,17.31 165.54,16.64 v2(165.85,16.64)
DDR_B_D8: length 53.1
  IN1 w0.076: v2(153.41,50.45) 154.28,49.58 154.28,44.06 154.55,43.79 154.55,43.25
  IN1 w0.084: 154.55,43.25 154.55,43.24
  IN1 w0.089: 154.55,43.24 154.55,34.13 158.87,29.81 158.87,29.64 158.57,29.33 158.57,29.2 158.69,29.08 158.82,29.08 159.13,29.38 159.25,29.38 159.38,29.26 159.38,29.13 159.07,28.83 159.07,28.7 159.2,28.58 159.32,28.58 159.63,28.88 159.75,28.88 159.88,28.76 159.88,28.63 159.65,28.4 159.65,28.27 161.71,26.22 162.47,26.22 163.21,25.48 163.21,24.12 165.67,21.65 165.67,19.54 166.58,18.62 166.58,15.27 v2(167.47,14.38)
  BOTTOM w0.076: UC1.AY35 153.76,55.73 153.76,55.47 153.8,55.37 153.8,55.37 153.83,55.28 153.83,55.08 153.79,54.99 153.79,54.72 153.83,54.63 153.83,54.06 153.65,53.89 153.65,52.86 153.94,52.57 153.94,50.97 v2(153.41,50.45)
  BOTTOM w0.102: JDIMM2.28 167.65,11.78 167.65,14.2 v2(167.47,14.38)
DDR_B_D9: length 53.8
  IN1 w0.089: v2(153.39,49.19) 154.06,48.52 154.06,43.92 154.25,43.73 154.25,34.01 157.38,30.88 157.38,30.75 157.1,30.47 157.1,30.35 157.22,30.22 157.35,30.22 157.63,30.5 157.75,30.5 157.88,30.37 157.88,30.25 157.57,29.94 157.57,29.82 157.7,29.69 157.83,29.69 158.13,30 158.26,30 158.38,29.87 158.38,29.75 158.03,29.39 158.03,29.26 161.38,25.91 162.34,25.91 162.9,25.35 162.9,23.92 162.9,23.66 165.3,21.26 165.3,19.42 166.28,18.44 166.28,15.68 165.82,15.22 165.82,13.77 v2(166.28,13.31)
  BOTTOM w0.076: UC1.AW35 153.66,56.29 153.34,55.97 153.34,55.42 153.13,55.21 153.13,54.1 153.13,54.1 153.13,52.59 153.02,52.48 153.02,49.56 v2(153.39,49.19)
  BOTTOM w0.102: JDIMM2.24 166.62,12.97 v2(166.28,13.31)
DDR_B_D10: length 54.1
  IN1 w0.089: v2(155.84,46.18) 155.84,46.17 156.22,45.79 156.22,44.33 156.67,43.88 156.67,35.01 161.49,30.18 165.73,25.94 165.73,25.82 165.45,25.53 165.45,25.4 165.57,25.28 165.7,25.28 165.89,25.47 166.01,25.47 166.14,25.34 166.14,25.22 165.73,24.81 165.73,24.58 168.21,22.1 169,22.1 169.68,21.42 169.68,16.92 169.77,16.83 169.95,16.83 170.04,16.74 170.04,16.57 169.95,16.48 169.77,16.48 169.68,16.39 169.68,16.16 169.77,16.07 169.9,16.07 169.99,15.98 169.99,15.81 169.9,15.72 169.77,15.72 169.68,15.63 169.68,15.37 170.14,14.91 v2(170.45,14.91)
  BOTTOM w0.076: 156.45,47.32 156.45,47.49 156.2,47.75 156.2,50.78 155.36,51.61 155.36,53.62 155.17,53.81 155.17,54.15 155.32,54.31 155.32,54.67 155.21,54.91 155.21,55.26 155.16,55.36 154.89,55.63 UC1.AY33
  BOTTOM w0.102: 156.45,47.32 156.45,46.79 v2(155.84,46.18) ; JDIMM2.42 171.12,14.23 v2(170.45,14.91)
DDR_B_D11: length 52.7
  IN1 w0.084: 156.36,43.28 156.36,43.83 155.99,44.2 155.99,44.73 v2(155.84,44.89)
  IN1 w0.089: 156.36,43.28 156.36,34.88 161.37,29.88 161.37,29.88 162.47,28.77 165.02,26.23 165.02,24.87 169.2,20.68 169.2,15.22 169.86,14.56 169.86,13.92 v2(170.52,13.26)
  BOTTOM w0.076: UC1.AW33 154.23,56.48 154.03,56.28 153.96,56.18 153.96,55.41 153.99,55.31 153.99,55.04 153.96,54.96 153.96,54.76 153.99,54.66 153.99,54 153.81,53.82 153.81,52.96 154.14,52.63
  BOTTOM w0.102: v2(155.84,44.89) 154.14,46.58 154.14,52.63 ; JDIMM2.38 170.12,12.87 v2(170.52,13.26)
DDR_B_D12: length 51.8
  IN1 w0.076: v2(153.41,51.03) 154.44,50 154.44,44.24 154.86,43.83 154.86,43.25
  IN1 w0.084: 154.86,43.24 154.86,43.25
  IN1 w0.089: v2(167.37,17.43) 167.14,17.2 167.02,17.2 166.89,17.33 166.89,18.5 166.89,18.63 166.98,18.72 167.05,18.72 167.14,18.81 167.14,19.07 167.08,19.13 166.51,19.13 166.38,19.26 166.38,19.42 166.47,19.51 166.8,19.51 166.89,19.6 166.89,19.79 166.8,19.88 166.09,19.88 166,19.97 166,20.14 166.09,20.23 166.8,20.23 166.89,20.32 166.89,20.49 166.8,20.58 166.19,20.58 166.1,20.67 166.1,20.87 166.19,20.96 166.47,20.96 166.56,21.05 166.56,21.19 166.46,21.29 166.19,21.29 166.1,21.38 166.1,21.65 163.51,24.24 163.51,25.61 162.26,26.85 162.14,26.85 161.88,26.6 161.76,26.6 161.63,26.72 161.63,26.85 161.89,27.11 161.89,27.23 161.76,27.36 161.64,27.36 161.38,27.11 161.25,27.11 160.31,28.04 160.31,28.81 154.86,34.26 154.86,43.24
  BOTTOM w0.076: UC1.BB35 153.46,54.43 153.46,52.8 153.77,52.48 153.77,51.4 153.41,51.04 v2(153.41,51.03)
  BOTTOM w0.102: v2(167.37,17.43) 167.87,17.93 JDIMM2.29
DDR_B_D13: length 52.5
  IN1 w0.076: 155.16,43.25 155.16,44.17 154.61,44.72 154.61,51.02 153.52,52.12 153.52,52.14 v2(153.39,52.27)
  IN1 w0.084: 155.16,43.25 155.16,43.24
  IN1 w0.089: 155.16,43.24 155.16,34.39 160.62,28.93 160.62,28.34 160.74,28.22 160.93,28.22 161.07,28.36 161.19,28.36 161.32,28.23 161.32,28.11 161.13,27.92 161.13,27.79 161.25,27.66 161.38,27.66 161.57,27.85 161.69,27.85 163.82,25.73 163.82,24.37 167.45,20.74 167.45,20.52 167.36,20.43 167.28,20.43 167.19,20.34 167.19,20.16 167.28,20.08 167.36,20.08 167.45,19.99 167.45,19.81 167.36,19.72 167.28,19.72 167.19,19.63 167.19,19.45 167.28,19.36 167.36,19.36 167.45,19.28 167.45,18.71 167.54,18.62 167.91,18.62 168,18.53 168,17.13 167.75,16.88 167.75,16.53 168,16.28 168,16.09 167.73,15.83 167.4,15.83 v2(167.32,15.9)
  BOTTOM w0.076: UC1.BA35 153.56,54.96 153.29,54.69 153.29,54.03 153.29,54.03 153.29,52.36 v2(153.39,52.27)
  BOTTOM w0.102: JDIMM2.25 166.87,16.35 v2(167.32,15.9)
DDR_B_D14: length 52.6
  IN1 w0.089: v2(170.45,15.88) 170.85,16.29 170.85,18.44 170.34,18.95 170.34,22.25 169.67,22.93 169.55,22.93 169.47,22.85 169.34,22.85 169.22,22.98 169.22,23.1 169.29,23.18 169.29,23.3 169.17,23.43 169.04,23.43 168.66,23.05 168.53,23.05 168.41,23.17 168.41,23.3 168.79,23.68 168.79,23.81 168.66,23.93 168.54,23.93 168.4,23.79 168.3,23.79 168.15,23.94 168.15,24.04 168.29,24.18 168.29,24.31 157.28,35.32 157.28,43.86 156.58,44.56 156.58,49.21 v2(155.78,50.01)
  BOTTOM w0.076: UC1.BA33 154.89,55.03 155.04,54.88 155.15,54.64 155.15,54.38 155,54.22 155,53.73 155.15,53.59 155.15,50.64 v2(155.78,50.01)
  BOTTOM w0.102: v2(170.45,15.88) 169.87,16.45 JDIMM2.37
DDR_B_D15: length 51.8
  IN1 w0.089: v2(170.39,17.43) 170.29,17.33 170.08,17.33 169.99,17.42 169.99,21.54 169.07,22.46 168.36,22.46 167.76,23.06 167.76,23.18 168.06,23.48 168.06,23.6 167.93,23.73 167.8,23.73 167.51,23.44 167.38,23.44 167.26,23.56 167.26,23.69 167.79,24.22 167.79,24.35 167.67,24.47 167.54,24.47 167.01,23.94 166.88,23.94 166.76,24.06 166.76,24.19 167.29,24.72 167.29,24.85 167.17,24.98 167.04,24.98 166.5,24.44 166.38,24.44 166.25,24.57 166.25,24.69 166.8,25.24 166.8,25.37 156.97,35.2 156.97,43.83 156.4,44.4 156.4,48.74 v2(155.78,49.36)
  BOTTOM w0.076: UC1.BB33 154.89,54.4 154.86,54.37 154.86,54.31 154.81,54.26 154.81,53.7 154.98,53.52 154.98,50.5 155.33,50.15 155.33,49.81 v2(155.78,49.36)
  BOTTOM w0.102: JDIMM2.41 170.87,17.91 v2(170.39,17.43)
DDR_B_D16: length 90.4
  IN4 w0.076: 151.69,54.86 152.75,53.79 152.75,48.83
  IN4 w0.084: 151.69,54.86 151.43,55.11 151.23,55.11 150.13,56.21 v2(150.13,57.24)
  IN4 w0.089: 152.75,48.83 152.75,47.22 152.98,46.99 152.98,45.94 153.28,45.63 153.28,44.08 153.28,43.67 160,36.95 162.12,36.95 162.64,36.43 163.05,36.02 166.21,36.02 170.67,36.02 171.6,35.09 172.37,35.09 173.32,34.14 197.8,34.14 205.65,26.29 205.65,18.47 205.42,18.24 205.42,16.34 205.98,15.78 205.98,14.1 v2(205.62,13.75)
  BOTTOM w0.076: v2(150.13,57.24) 150.54,57.65 UC1.AU40
  BOTTOM w0.102: JDIMM2.170 205.12,13.25 v2(205.62,13.75)
DDR_B_D17: length 91.1
  IN4 w0.076: 150.71,55.27 151.05,54.94 151.37,54.94 152.44,53.86 152.44,48.7
  IN4 w0.084: 150.71,55.27 149.76,56.22 149.76,57.41 150.12,57.77 v2(150.12,57.95)
  IN4 w0.089: v2(205.52,15.29) 205.12,15.7 205.12,18.36 205.35,18.59 205.35,26.17 197.67,33.84 173.19,33.84 172.24,34.79 171.48,34.79 170.54,35.72 166.08,35.72 162.92,35.72 162,36.65 159.87,36.65 152.98,43.54 152.98,43.79 152.98,44.21 152.98,45.51 152.67,45.81 152.67,46.86 152.44,47.09 152.44,48.7
  BOTTOM w0.076: UC1.AT40 v2(150.12,57.95)
  BOTTOM w0.102: JDIMM2.174 206.12,14.69 v2(205.52,15.29)
DDR_B_D18: length 92.1
  IN4 w0.076: 154.79,50.44 154.79,50.46 154.75,50.49 154.75,52.34 154.61,52.48 154.43,52.48 153.68,53.23 153.68,54.26 152.33,55.61 152.33,57.45 151.95,57.83 v2(151.95,57.95)
  IN4 w0.089: 154.79,50.44 154.79,44.35 160.68,38.45 162.75,38.45 163.67,37.53 166.83,37.53 171.29,37.53 172.23,36.6 172.99,36.6 173.94,35.65 198.42,35.65 199.01,35.06 207.15,26.92 207.15,26.25 207.15,18.79 207.61,18.34 207.61,14.3 207.83,14.08 208.06,14.08 v2(208.57,14.58)
  BOTTOM w0.076: UC1.AT37 v2(151.95,57.95)
  BOTTOM w0.102: JDIMM2.182 208.12,14.14 v2(208.57,14.58)
DDR_B_D19: length 91.2
  IN4 w0.089: v2(208.62,13.03) 208.32,13.03 207.48,13.87 206.98,13.87 206.89,13.96 206.89,14.95 206.98,15.04 207.21,15.04 207.3,15.13 207.3,18.21 206.85,18.66 206.85,26.37 206.85,26.37 206.85,26.79 198.71,34.93 198.3,35.34 173.82,35.34 172.86,36.29 172.1,36.29 171.17,37.22 166.71,37.22 163.55,37.22 162.62,38.15 160.49,38.15 154.48,44.16 154.48,52.17 153.5,53.15 153.5,54.02 151.95,55.58 v2(151.95,57.3)
  BOTTOM w0.076: UC1.AU37 v2(151.95,57.3)
  BOTTOM w0.102: v2(208.62,13.03) 209.12,12.53 JDIMM2.186
DDR_B_D20: length 91.9
  IN4 w0.076: 151.4,54.3 151.4,51.62 151.59,51.42 151.59,48.85
  IN4 w0.084: v2(150.12,58.59) 149.74,58.2 149.74,57.63 149.58,57.47 149.58,56.11
  IN4 w0.089: v2(204.37,16.11) 204.51,15.98 204.72,15.98 204.81,16.07 204.81,18.49 205.04,18.72 205.04,26.04 197.55,33.53 173.07,33.53 172.11,34.48 171.35,34.48 170.42,35.41 165.96,35.41 165.96,35.42 162.8,35.42 161.87,36.34 159.74,36.34 152.67,43.41 152.67,43.92 152.67,44.33 152.67,44.34 152.67,45.38 152.37,45.69 152.37,46.43 151.88,46.92 151.87,46.92 151.64,47.15 151.64,47.16 151.59,47.2 151.59,48.85 ; 151.4,54.3 149.58,56.11
  BOTTOM w0.076: UC1.AR40 v2(150.12,58.59)
  BOTTOM w0.102: v2(204.37,16.11) 205.87,17.61 JDIMM2.173
DDR_B_D21: length 92.6
  IN4 w0.084: v2(150.12,59.22) 149.56,58.67 149.56,57.7 149.41,57.55 149.41,56.77 149.41,56.77 149.41,54.85 151,53.25 151,51.79 151.07,51.72 151.07,51.47 151.23,51.31
  IN4 w0.089: v2(204.37,17.76) 204.37,17.62 204.29,17.53 204.01,17.53 203.92,17.62 203.92,18.14 203.97,18.19 203.97,18.81 204.11,18.95 204.66,18.95 204.74,19.03 204.74,19.24 204.65,19.33 204.16,19.33 204.08,19.42 204.08,19.6 204.16,19.69 204.65,19.69 204.74,19.78 204.74,19.96 204.65,20.04 204.27,20.04 204.18,20.13 204.18,20.3 204.27,20.4 204.65,20.4 204.74,20.49 204.74,20.67 204.65,20.76 204.48,20.76 204.4,20.84 204.4,21.02 204.48,21.11 204.65,21.11 204.74,21.2 204.74,21.38 204.65,21.47 204.48,21.47 204.4,21.56 204.4,21.73 204.48,21.82 204.65,21.82 204.74,21.91 204.74,25.91 197.42,33.23 172.94,33.23 171.99,34.18 171.22,34.18 170.29,35.11 165.83,35.11 162.67,35.11 161.74,36.04 159.62,36.04 152.37,43.29 152.37,44.05 152.37,44.46 152.37,44.46 152.37,45.24 152.06,45.54 152.06,46.2 151.29,46.98 151.29,48.83 151.29,48.83 151.29,51.25 151.23,51.31
  BOTTOM w0.076: UC1.AP40 v2(150.12,59.22)
  BOTTOM w0.102: JDIMM2.169 204.87,18.26 v2(204.37,17.76)
DDR_B_D22: length 93.4
  IN4 w0.076: v2(151.95,59.22) 152.49,58.68 152.49,57.8 152.67,57.63 152.67,56.16 154.4,54.42 154.4,53.87 155.09,53.18 155.09,50.83 155.39,50.52
  IN4 w0.089: v2(208.62,17.94) 208.32,17.94 208.22,18.04 208.22,18.85 208.13,18.94 207.87,18.94 207.76,19.04 207.76,19.28 207.85,19.37 208.56,19.37 208.65,19.46 208.65,19.64 208.56,19.73 207.85,19.73 207.76,19.82 207.76,20 207.85,20.08 208.53,20.08 208.62,20.17 208.62,20.35 208.53,20.44 207.85,20.44 207.76,20.53 207.76,20.71 207.85,20.8 208.48,20.8 208.57,20.88 208.57,21.06 208.48,21.15 207.85,21.15 207.76,21.24 207.76,21.45 207.85,21.54 208,21.54 208.09,21.63 208.09,21.81 208,21.9 207.85,21.9 207.76,21.99 207.76,25.99 207.76,27.17 199.62,35.31 198.68,36.25 174.19,36.25 173.24,37.21 172.48,37.21 171.55,38.14 167.09,38.14 163.93,38.14 163,39.06 160.94,39.06 155.39,44.61 155.39,50.52
  BOTTOM w0.076: UC1.AP37 v2(151.95,59.22)
  BOTTOM w0.102: v2(208.62,17.94) 209.37,18.69 JDIMM2.187
DDR_B_D23: length 93
  IN4 w0.076: 155.09,50.47 154.91,50.65 154.91,53.05 154.55,53.41 154.55,53.41 154.33,53.63 154.24,53.73 154.24,53.73 154.04,53.93 154.04,54.36 152.5,55.9 152.5,57.52 152.33,57.69 152.33,58.21 v2(151.95,58.59)
  IN4 w0.089: 155.09,50.47 155.09,44.48 160.81,38.76 162.87,38.76 163.8,37.83 166.96,37.83 166.96,37.83 171.42,37.83 172.35,36.9 173.12,36.9 174.07,35.95 198.55,35.95 199.32,35.19 207.46,27.04 207.46,26.12 207.46,18.92 207.91,18.46 207.91,15.49 208.06,15.35 208.45,15.35 208.6,15.49 v2(208.6,16.41)
  BOTTOM w0.076: UC1.AR37 v2(151.95,58.59)
  BOTTOM w0.102: v2(208.6,16.41) 208.52,16.41 208.04,16.89 208.04,18.77 208.37,19.11 JDIMM2.183
DDR_B_D24: length 94.8
  IN4 w0.076: 156.86,51.11 156.86,51.16 156.68,51.34 156.63,51.34 155.82,52.15 155.82,53.16 155.08,53.9 155.08,54.69 154.03,55.74 154.03,56.41 153.41,57.04 153.41,57.47 153.78,57.85 v2(153.78,57.95)
  IN4 w0.089: 156.86,51.11 156.86,45.09 156.86,44.84 161.49,40.2 163.43,40.2 164.39,39.24 167.55,39.24 173.12,39.24 175,37.36 199.14,37.36 200.73,35.77 208.87,27.63 208.87,25.54 208.87,22.87 209.78,21.96 209.78,17.64 209.87,17.56 210.16,17.56 210.25,17.47 210.25,17.29 210.16,17.2 209.87,17.2 209.78,17.11 209.78,16.95 210.18,16.55 210.18,14.62 210.27,14.53 210.5,14.53 210.63,14.66 210.63,15.96 v2(210.83,16.16)
  BOTTOM w0.076: v2(153.78,57.95) 153.96,58.09 UC1.AT33
  BOTTOM w0.102: v2(210.83,16.16) 210.37,16.62 JDIMM2.191
DDR_B_D25: length 94.6
  IN4 w0.076: 156.83,51.72 155.99,52.56 155.99,54.31 154.31,55.99 154.31,56.78 v2(153.78,57.32)
  IN4 w0.089: 156.83,51.72 157.16,51.39 157.16,44.96 161.62,40.51 163.55,40.51 164.51,39.55 167.67,39.55 173.24,39.55 175.13,37.66 199.26,37.66 201.03,35.9 209.17,27.75 209.17,27.04 209.31,26.9 209.5,26.9 209.59,26.81 209.59,26.62 209.5,26.53 209.29,26.53 209.21,26.44 209.21,26.27 209.29,26.18 209.73,26.18 209.83,26.07 209.83,25.93 209.73,25.82 209.29,25.82 209.21,25.73 209.21,25.56 209.29,25.47 209.99,25.47 210.08,25.38 210.08,25.2 209.99,25.11 209.29,25.11 209.21,25.02 209.21,24.84 209.29,24.76 209.99,24.76 210.08,24.67 210.08,24.49 209.99,24.4 209.29,24.4 209.21,24.31 209.21,24.13 209.29,24.04 209.99,24.04 210.08,23.95 210.08,23.78 209.99,23.69 209.29,23.69 209.21,23.6 209.21,23.42 209.29,23.33 209.99,23.33 210.08,23.24 210.08,23.07 209.99,22.98 209.55,22.98 209.46,22.89 209.46,22.71 209.55,22.62 209.99,22.62 210.08,22.53 210.08,18.09 210.46,17.72 v2(210.83,17.72)
  BOTTOM w0.076: UC1.AU33 153.96,57.45 v2(153.78,57.32)
  BOTTOM w0.102: v2(210.83,17.72) 210.99,17.72 211.37,18.1 JDIMM2.195
DDR_B_D26: length 93.3
  IN4 w0.076: 159.3,48.7 159.3,51.59 159.1,51.78
  IN4 w0.084: v2(155.61,57.32) 155.92,57 155.92,55.5 157.39,54.03 157.39,53.5 159.1,51.78
  IN4 w0.089: 159.3,48.7 159.3,44.52 160.84,42.98 160.97,42.98 161.34,43.35 161.47,43.35 161.59,43.22 161.59,43.1 161.22,42.73 161.22,42.6 161.37,42.45 161.5,42.45 162.38,43.32 162.51,43.32 162.65,43.18 162.65,43.05 161.76,42.16 161.76,42.06 161.91,41.91 162.01,41.91 162.94,42.84 163.07,42.84 163.19,42.71 163.19,42.59 162.54,41.94 162.54,41.81 162.65,41.7 162.81,41.7 163.45,42.34 163.57,42.34 165.16,40.75 168.17,40.75 173.74,40.75 175.62,38.86 199.96,38.86 211.28,27.54 211.28,27.12 211.28,19.64 212.03,18.89 212.03,18.09 212.18,17.94 v2(212.41,17.94)
  BOTTOM w0.076: UC1.AU30 v2(155.61,57.32)
  BOTTOM w0.102: v2(212.41,17.94) 212.76,17.94 213.37,18.55 JDIMM2.203
DDR_B_D27: length 94.5
  IN4 w0.076: 159.6,48.88 159.6,51.62 159.46,51.76 ; v2(155.61,57.95) 155.61,57.85 156.12,57.33 156.12,56.68
  IN4 w0.084: 159.46,51.76 157.69,53.52 157.69,54.08 156.12,55.66 156.12,56.68
  IN4 w0.089: v2(212.43,16.41) 212.83,16.81 212.83,19.26 212.68,19.42 212.55,19.42 212.3,19.16 212.19,19.16 212.04,19.31 212.05,19.41 212.3,19.67 212.3,19.79 212.18,19.92 212.05,19.92 211.86,19.73 211.73,19.73 211.59,19.87 211.59,20.13 211.68,20.22 211.82,20.22 211.91,20.31 211.91,20.49 211.82,20.58 211.68,20.58 211.59,20.67 211.59,20.85 211.68,20.93 211.82,20.93 211.91,21.02 211.91,21.2 211.82,21.29 211.68,21.29 211.59,21.38 211.59,21.56 211.68,21.65 211.82,21.65 211.91,21.73 211.91,21.91 211.82,22 211.68,22 211.59,22.09 211.59,22.27 211.68,22.36 211.82,22.36 211.91,22.45 211.91,22.62 211.82,22.71 211.68,22.71 211.59,22.8 211.59,22.98 211.68,23.07 211.82,23.07 211.91,23.16 211.91,23.33 211.82,23.42 211.68,23.42 211.59,23.51 211.59,27.66 200.09,39.17 175.75,39.17 173.87,41.05 168.3,41.05 165.29,41.05 162.58,43.76 160.5,43.76 159.6,44.65 159.6,48.88
  BOTTOM w0.076: UC1.AT30 v2(155.61,57.95)
  BOTTOM w0.102: JDIMM2.207 214.37,18.44 214.24,18.31 214.24,17.91 212.74,16.41 v2(212.43,16.41)
DDR_B_D28: length 95.6
  IN4 w0.076: v2(153.78,58.59) 153.41,58.22 153.41,57.71 153.24,57.55 153.24,56.91 153.85,56.3 153.85,55.66 154.9,54.61 154.9,53.85 154.91,53.84 154.91,53.83 155.45,53.3 155.45,52.13 156.27,51.32 156.37,51.32 156.55,51.14 156.55,51.03
  IN4 w0.089: v2(211.03,14.81) 211.03,14.63 210.63,14.23 210.63,13.43 210.54,13.34 210.16,13.34 210.07,13.43 210.07,13.76 209.87,13.95 209.87,16.42 209.47,16.82 209.47,21.83 208.56,22.74 208.56,25.66 208.56,27.5 200.42,35.64 199.01,37.05 174.87,37.05 172.99,38.94 167.42,38.94 164.26,38.94 163.3,39.9 161.37,39.9 156.55,44.71 156.55,44.96 156.55,45.21 156.55,45.22 156.55,51.03
  BOTTOM w0.076: v2(153.78,58.59) 153.96,58.73 UC1.AR33
  BOTTOM w0.102: JDIMM2.190 210.12,13.9 v2(211.03,14.81)
DDR_B_D29: length 96
  IN4 w0.076: v2(153.78,59.22) 153.24,58.69 153.24,57.78 153.08,57.62 153.08,56.82 153.62,56.27 153.62,55.56 154.58,54.61 154.58,53.93 155.27,53.24 155.27,51.99 156.25,51.01
  IN4 w0.089: v2(211.16,13.26) 211.16,13.02 211.07,12.93 209.22,12.93 209.13,13.02 209.13,13.22 209.22,13.31 209.68,13.31 209.76,13.4 209.76,13.63 209.68,13.72 209.22,13.72 209.13,13.81 209.13,14.39 209.57,14.83 209.57,16.29 209.17,16.69 209.17,21.63 208.26,22.54 208.26,25.79 208.26,27.37 200.12,35.52 200.12,35.52 198.88,36.75 174.4,36.75 173.45,37.7 172.68,37.7 171.75,38.63 167.29,38.63 164.13,38.63 163.17,39.59 161.24,39.59 156.25,44.58 156.25,45.09 156.25,45.34 156.25,45.34 156.25,51.01
  BOTTOM w0.076: UC1.AP33 153.96,59.37 v2(153.78,59.22)
  BOTTOM w0.102: JDIMM2.194 211.12,13.23 v2(211.16,13.26)
DDR_B_D30: length 94.4
  IN4 w0.076: 159.64,51.83 159.9,51.57 159.9,48.85 ; v2(155.61,59.22) 155.98,58.85 155.98,57.71 156.3,57.39 156.3,55.73
  IN4 w0.084: 156.3,55.73 157.93,54.1 157.93,53.54 159.64,51.83
  IN4 w0.089: v2(214.84,13.03) 214.82,13.01 214.34,13.01 214.08,13.26 214.08,15.27 213.16,16.2 213.16,19.37 212.22,20.31 212.22,23.64 212.05,23.81 211.99,23.81 211.9,23.9 211.9,24.07 211.99,24.16 212.13,24.16 212.22,24.25 212.22,24.43 212.13,24.52 211.99,24.52 211.9,24.61 211.9,24.79 211.99,24.87 212.13,24.87 212.22,24.96 212.22,25.14 212.13,25.23 211.99,25.23 211.9,25.32 211.9,27.53 211.9,27.79 200.21,39.47 175.88,39.47 173.99,41.36 168.42,41.36 165.41,41.36 162.71,44.06 162.31,44.06 160.62,44.06 159.9,44.78 159.9,48.85
  BOTTOM w0.076: UC1.AR30 v2(155.61,59.22)
  BOTTOM w0.102: v2(214.84,13.03) 214.62,12.81 JDIMM2.208
DDR_B_D31: length 95.4
  IN4 w0.076: v2(155.61,59.86) 156.15,59.31 156.15,57.77 156.48,57.44 156.48,55.8 158.1,54.18 158.1,53.65 160.21,51.54 160.21,49.06
  IN4 w0.089: 160.21,49.06 160.21,44.9 160.75,44.36 162.18,44.36 162.18,44.37 162.84,44.37 165.54,41.66 168.55,41.66 168.55,41.66 174.12,41.66 176,39.78 200.34,39.78 212.2,27.91 212.2,27.41 212.2,26.46 212.29,26.37 212.43,26.37 212.52,26.28 212.52,26.11 212.43,26.02 212.29,26.02 212.2,25.93 212.2,25.75 212.29,25.66 212.43,25.66 212.52,25.57 212.52,20.44 213.46,19.5 213.46,16.32 214.39,15.4 214.39,14.79 214.59,14.58 v2(214.84,14.58)
  BOTTOM w0.076: UC1.AP30 v2(155.61,59.86)
  BOTTOM w0.102: JDIMM2.204 213.62,13.4 213.91,13.68 213.91,14.38 214.29,14.76 214.67,14.76 v2(214.84,14.58)
DDR_B_D32: length 53.3
  IN1 w0.089: v2(157.57,46.05) 157.59,46.03 157.59,44.99 158.71,43.87 158.71,36.81 160.41,35.11 160.41,34.96 160.12,34.66 160.12,34.54 160.24,34.41 160.37,34.41 160.63,34.67 160.75,34.67 160.88,34.54 160.88,34.42 160.62,34.16 160.62,34.03 161.43,33.22 172.25,22.41 172.38,22.28 172.38,19 172.83,18.55 172.83,16.67 173.49,16.01 173.49,14.81 v2(174.08,14.23)
  BOTTOM w0.076: 157.07,47.32 156.36,48.04 156.36,50.85 155.9,51.31 155.9,53.81 155.9,54.16 155.76,54.31 155.76,54.67 155.77,54.7 155.92,55.08 155.92,55.36 156.19,55.63 UC1.AY31
  BOTTOM w0.102: v2(157.57,46.05) 157.07,46.55 157.07,47.32 ; JDIMM2.50 173.12,12.83 173.51,13.21 173.51,13.53 174.08,14.1 v2(174.08,14.23)
DDR_B_D33: length 53.3
  IN1 w0.084: 157.6,43.85 156.78,44.67 156.78,52.84 v2(156.98,53.04)
  IN1 w0.089: 157.6,43.85 157.77,43.68 157.77,35.53 170.84,22.46 170.84,19.16 171.35,18.65 171.35,15.71 171.44,15.62 172.01,15.62 172.1,15.71 v2(172.1,15.93)
  BOTTOM w0.076: UC1.AW31 156.84,56.48 157.1,56.22 157.1,55.65 157.12,55.61 157.12,55.42 157.06,55.27 157.06,55.12 157.13,54.9 157.13,54.79 157.09,54.7 157.08,54.68 157.08,54.15 157.38,53.85 157.38,53.8 157.38,53.43 v2(156.98,53.04)
  BOTTOM w0.102: JDIMM2.45 171.87,18.96 171.66,18.75 171.66,16.36 v2(172.1,15.93)
DDR_B_D34: length 52.2
  IN1 w0.084: v2(157.58,51.24) 158.37,50.45 158.37,45.02 159.7,43.69
  IN1 w0.089: v2(175.86,14.79) 174.59,16.06 174.59,18.37 174.09,18.86 174.09,20.95 173.57,21.46 173.57,22.78 171.08,25.27 163.6,32.75 163.6,33.62 159.92,37.29 159.92,43.47 159.7,43.69
  BOTTOM w0.076: v2(157.58,51.24) 157.58,52.32 157.54,52.36 157.54,52.62 157.54,52.62 157.54,53.73 157.54,53.73 157.54,53.92 157.25,54.22 157.25,54.64 157.3,54.76 157.3,54.9 157.24,55.13 157.24,55.26 157.31,55.47 157.31,55.73 UC1.AY29
  BOTTOM w0.102: v2(175.86,14.79) 175.12,14.06 JDIMM2.58
DDR_B_D35: length 53.1
  IN1 w0.089: v2(176.21,13.3) 176.27,13.3 176.69,13.72 176.69,15.1 176.83,15.24 176.83,18.46 175,20.29 175,21.33 174.49,21.84 174.49,23.16 171.46,26.19 167.55,30.1 167.55,31.02 160.84,37.72 160.84,43.41 159.65,44.61 159.65,46.94 v2(158.86,47.73)
  BOTTOM w0.076: v2(158.86,47.73) 158.84,47.73 158.29,48.28 158.29,52.32 158.04,52.58 158.04,52.83 158.04,54.15 157.95,54.24 157.95,55.19 157.72,55.41 157.72,55.95 157.41,56.26 UC1.AW29
  BOTTOM w0.102: v2(176.21,13.3) 176.12,13.21 JDIMM2.62
DDR_B_D36: length 51.6
  IN1 w0.089: v2(172.07,17.45) 172.07,17.3 171.94,17.17 171.74,17.17 171.65,17.26 171.65,19.27 171.56,19.36 171.25,19.36 171.16,19.45 171.16,19.63 171.25,19.72 171.63,19.72 171.72,19.8 171.72,19.98 171.63,20.07 171.25,20.07 171.16,20.16 171.16,20.34 171.25,20.43 171.63,20.43 171.72,20.52 171.72,20.69 171.63,20.78 171.25,20.78 171.16,20.87 171.16,21.05 171.25,21.14 171.6,21.14 171.69,21.23 171.69,21.4 171.6,21.49 171.25,21.49 171.16,21.58 171.16,21.78 171.25,21.87 171.6,21.87 171.69,21.96 171.69,22.1 171.56,22.23 171.3,22.23 171.21,22.32 171.21,22.58 158.08,35.72 158.08,43.81 156.96,44.93 156.96,47.36 v2(157.58,47.99)
  BOTTOM w0.076: UC1.BB31 156.19,54.35 156.23,54.31 156.23,53.56 156.23,53.56 156.23,51.44 156.69,50.98 156.69,48.87 v2(157.58,47.99)
  BOTTOM w0.102: JDIMM2.49 172.87,17.85 172.48,17.45 v2(172.07,17.45)
DDR_B_D37: length 52.2
  IN1 w0.089: v2(172.02,14.25) 172.63,14.86 172.63,16.01 172.53,16.11 172.53,18.42 172.07,18.88 172.07,22.15 159.07,35.16 159.07,35.41 159.29,35.63 159.29,35.75 159.16,35.88 159.03,35.88 158.75,35.6 158.63,35.6 158.38,35.84 158.38,43.93 157.14,45.18 157.14,46.89 v2(157.58,47.34)
  BOTTOM w0.076: UC1.BA31 156.19,55.03 156.04,54.88 155.92,54.64 155.92,54.38 156.07,54.23 156.07,53.67 156.07,51.37 156.53,50.92 156.53,48.39 v2(157.58,47.34)
  BOTTOM w0.102: JDIMM2.46 172.12,12.83 172.43,13.13 172.43,13.85 v2(172.02,14.25)
DDR_B_D38: length 52.1
  IN1 w0.089: v2(158.88,46.49) 159.28,46.09 159.28,44.72 160.53,43.47 160.53,37.58 166.43,31.68 166.43,31.19 166.29,31.05 166.29,30.92 166.42,30.8 166.54,30.8 166.87,31.12 166.99,31.12 167.12,30.99 167.12,30.87 166.8,30.55 166.8,30.42 167.75,29.47 174.18,23.03 174.18,21.71 174.7,21.2 174.7,20.16 176.52,18.34 176.52,16.69 v2(176.08,16.26)
  BOTTOM w0.076: 158.39,47.32 158.39,47.91 158.13,48.17 158.13,52.25 157.87,52.51 157.87,52.76 157.87,54.06 157.78,54.15 157.78,54.69 157.51,54.95 UC1.BA29
  BOTTOM w0.102: JDIMM2.63 176.37,18.94 176.52,18.8 176.52,16.69 v2(176.08,16.26) ; v2(158.88,46.49) 158.86,46.49 158.39,46.96 158.39,47.32
DDR_B_D39: length 51.1
  IN1 w0.089: v2(176.06,17.5) 175.83,17.28 175.03,17.28 174.89,17.42 174.89,18.52 174.39,19.02 174.39,21.07 173.88,21.59 173.88,22.9 171.2,25.58 165.71,31.07 165.71,31.2 165.89,31.38 165.89,31.51 165.76,31.63 165.64,31.63 165.46,31.45 165.33,31.45 165.21,31.58 165.21,31.7 165.39,31.89 165.39,32.01 165.26,32.14 165.14,32.14 164.95,31.95 164.83,31.95 164.7,32.08 164.7,32.21 165.01,32.51 165.01,32.64 164.88,32.76 164.76,32.76 164.45,32.46 164.33,32.46 164.2,32.58 164.2,32.71 164.51,33.02 164.51,33.14 164.33,33.31 160.23,37.42 160.23,43.47 158.85,44.85 v2(158.85,45.3)
  BOTTOM w0.076: 158,47.32 158,48.07 157.96,48.11 157.96,52.18 157.71,52.44 157.71,52.69 157.71,53.66 157.71,53.66 157.71,53.99 157.51,54.18 UC1.BB29
  BOTTOM w0.102: v2(158.85,45.3) 158,46.15 158,47.32 ; JDIMM2.59 175.37,17.93 175.8,17.5 v2(176.06,17.5)
DDR_B_D40: length 55.9
  IN1 w0.089: v2(177.76,14.84) 177.76,15.29 177.86,15.4 178.19,15.4 178.28,15.49 178.28,15.66 178.19,15.75 177.81,15.75 177.72,15.84 177.72,16.02 177.81,16.11 178.08,16.11 178.17,16.2 178.17,16.37 178.08,16.46 177.81,16.46 177.72,16.55 177.72,16.73 177.81,16.82 178.08,16.82 178.17,16.91 178.17,17.09 178.08,17.17 177.81,17.17 177.72,17.26 177.72,17.44 177.81,17.53 178.08,17.53 178.17,17.62 178.17,17.8 178.08,17.89 177.81,17.89 177.72,17.97 177.72,20.01 175.29,22.44 175.29,23.51 168.35,30.45 168.35,31.35 161.64,38.05 161.64,43.53 160.82,44.35 160.52,44.35 160.18,44.69 160.18,45.11 160.11,45.19 160.11,48.37 v2(158.88,49.61)
  BOTTOM w0.076: v2(158.88,49.61) 159.43,50.17 159.43,52.37 158.72,53.09 158.72,54.29 158.81,54.38 158.81,54.63 158.77,54.72 158.77,54.99 158.81,55.08 158.81,55.28 158.78,55.37 158.78,55.37 158.74,55.47 158.74,55.73 UC1.AY27
  BOTTOM w0.102: v2(177.76,14.84) 177.12,14.2 JDIMM2.66
DDR_B_D41: length 56.4
  IN1 w0.084: 159.93,45.02 159.93,47.3 v2(158.88,48.36)
  IN1 w0.089: v2(177.76,13.54) 177.32,13.98 177.32,19.22 177.23,19.31 176.71,19.31 176.62,19.4 176.62,19.58 176.71,19.67 177.23,19.67 177.32,19.76 177.32,19.93 177.23,20.02 175.97,20.02 175.88,20.11 175.88,20.29 175.97,20.38 176.35,20.38 176.44,20.47 176.44,20.67 176.35,20.76 175.59,20.76 175.5,20.84 175.5,21.53 174.98,22.05 174.98,23.38 168.05,30.32 168.05,31.22 161.34,37.93 161.34,43.37 160.95,43.77 160.79,43.77 159.93,44.63 159.93,45.02
  BOTTOM w0.076: UC1.AW27 158.64,56.29 158.32,55.97 158.32,55.42 158.11,55.21 158.11,54.31 158.2,54.22 158.2,53.46 158.2,52.9 158.46,52.64 158.46,48.78 v2(158.88,48.36)
  BOTTOM w0.102: v2(177.76,13.54) 178.12,13.18 JDIMM2.70
DDR_B_D42: length 56
  IN1 w0.076: v2(160.64,46.23) 161.2,45.67 161.2,44.71 162.39,43.51 162.39,43.24
  IN1 w0.089: 162.39,43.24 162.39,38.31 169,31.7 169,30.76 169.16,30.6 169.28,30.6 169.54,30.86 169.66,30.86 169.79,30.73 169.79,30.61 169.53,30.35 169.53,30.23 169.66,30.1 169.79,30.1 169.98,30.29 170.1,30.29 170.23,30.17 170.23,30.04 170.04,29.85 170.04,29.72 170.16,29.6 170.29,29.6 170.35,29.66 170.48,29.66 170.6,29.53 170.6,29.41 170.54,29.35 170.54,29.22 179.03,20.73 179.03,20.49 178.94,20.4 178.43,20.4 178.35,20.31 178.35,20.13 178.43,20.04 178.94,20.04 179.03,19.96 179.03,19.78 178.94,19.69 178.43,19.69 178.35,19.6 178.35,19.42 178.43,19.33 178.94,19.33 179.03,19.24 179.03,16.95 v2(178.6,16.51)
  BOTTOM w0.076: 161.16,48.89 161.16,50.99 160.57,51.59 160.57,52.87 160.31,53.13 160.31,54.65 160.19,54.91 160.14,55.01 160.14,55.36 159.87,55.63 UC1.AY25
  BOTTOM w0.102: v2(178.6,16.51) 177.37,17.74 JDIMM2.67 ; 161.16,48.89 161.17,48.87 161.17,46.77 v2(160.64,46.23)
DDR_B_D43: length 56.4
  IN1 w0.089: v2(160.62,45.65) 160.64,45.62 160.74,45.62 161,45.37 161,44.61 162.09,43.51 162.09,38.18 168.69,31.58 168.69,30.59 176.15,23.12 176.15,23 175.72,22.57 175.72,22.44 175.85,22.31 175.97,22.31 176.41,22.75 176.53,22.75 176.66,22.62 176.66,22.5 176.22,22.06 176.22,21.94 176.35,21.81 176.47,21.81 176.91,22.25 177.03,22.25 177.16,22.12 177.16,21.99 176.73,21.56 176.73,21.43 176.85,21.31 176.98,21.31 177.41,21.74 177.54,21.74 177.66,21.62 177.66,21.49 177.23,21.06 177.23,20.93 177.38,20.78 177.51,20.78 177.92,21.19 178.04,21.19 178.17,21.06 178.17,20.93 177.76,20.53 177.76,20.4 178.03,20.13 178.03,19.03 178.12,18.94 178.56,18.94 178.65,18.85 178.65,18.67 178.56,18.58 178.12,18.58 178.03,18.5 178.03,18.28 178.12,18.19 178.52,18.19 v2(178.6,18.11)
  BOTTOM w0.076: UC1.AW25 159.22,56.48 159.01,56.28 158.94,56.18 158.94,55.41 158.97,55.31 158.97,55.04 158.94,54.96 158.94,54.76 158.97,54.66 158.97,54.3 158.89,54.22 158.89,53.16 159.6,52.44
  BOTTOM w0.102: 159.6,52.44 159.61,52.43 159.61,46.63 160.62,45.62 v2(160.62,45.65) ; v2(178.6,18.11) 178.37,18.34 JDIMM2.71
DDR_B_D44: length 54.4
  IN1 w0.089: v2(158.88,50.21) 159.77,51.1 160.71,51.1 161.91,49.89 161.91,48.85 162.22,48.54 162.22,47.25 162.42,47.04 162.42,45.39 164.3,43.51 164.3,43.18 164.6,42.88 164.6,38.84 172.62,30.83 172.62,30.26 180.84,22.04 180.84,18.74 180.93,18.65 181.08,18.65 181.16,18.56 181.16,18.39 181.08,18.3 180.93,18.3 180.84,18.21 180.84,18.03 180.93,17.94 181.32,17.94 181.41,17.85 181.41,17.67 181.33,17.59 180.93,17.59 180.84,17.5 180.84,17.22 v2(181.16,16.89)
  BOTTOM w0.076: UC1.BB27 158.53,54.52 158.53,53.04 159.27,52.31 159.27,50.6 v2(158.88,50.21)
  BOTTOM w0.102: JDIMM2.79 180.37,17.68 v2(181.16,16.89)
DDR_B_D45: length 54.8
  IN1 w0.089: v2(182.49,17.1) 182.49,17.29 182.19,17.59 181.94,17.59 181.85,17.68 181.85,17.85 181.94,17.94 182.19,17.94 182.28,18.03 182.28,18.21 182.19,18.3 181.58,18.3 181.49,18.39 181.49,18.56 181.58,18.65 181.93,18.65 182.02,18.74 182.02,18.94 181.93,19.03 181.23,19.03 181.14,19.12 181.14,22.17 172.92,30.39 172.92,31.03 164.91,39.04 164.91,43.23 162.67,45.47 162.67,47.25 162.6,47.32 162.6,48.45 162.32,48.73 162.32,50.11 160.96,51.46 v2(158.9,51.46)
  BOTTOM w0.076: UC1.BA27 158.54,54.96 158.28,54.69 158.28,54.38 158.37,54.29 158.37,53.39 158.37,52.98 158.85,52.49 158.85,51.52 v2(158.9,51.46)
  BOTTOM w0.102: JDIMM2.83 181.37,18.36 182.49,17.25 v2(182.49,17.1)
DDR_B_D46: length 54.6
  IN1 w0.089: v2(160.65,50.62) 161.4,49.87 161.4,49.1 161.99,48.52 161.99,47.04 162.17,46.87 162.17,45.27 163.98,43.45 163.98,43.07 164.3,42.75 164.3,38.71 172.31,30.7 172.31,30.14 180.53,21.91 180.53,16.58 180.62,16.49 182.14,16.49 182.23,16.4 182.23,16.15 182.14,16.06 181.56,16.06 181.47,15.97 v2(181.47,15.57)
  BOTTOM w0.076: UC1.BA25 159.87,55.03 160.02,54.88 160.14,54.61 160.14,53.2 160.14,53.06 160.4,52.81 160.4,50.86 160.64,50.62 v2(160.65,50.62)
  BOTTOM w0.102: JDIMM2.80 180.62,13.47 180.89,13.73 180.89,14.99 v2(181.47,15.57)
DDR_B_D47: length 53.6
  IN1 w0.089: v2(181.47,14.02) 181.19,14.02 181.09,13.93 181.09,13.5 181.01,13.42 180.74,13.42 180.65,13.5 180.65,15.51 180.23,15.93 180.23,16.18 180.23,16.18 180.23,21.79 172.01,30.01 172.01,30.57 163.99,38.58 163.99,42.5 163.66,42.83 163.66,43.39 161.91,45.14 161.91,46.59 161.76,46.74 161.76,48.23 v2(160.65,49.34)
  BOTTOM w0.076: UC1.BB25 159.87,54.31 159.98,54.2 159.98,53.27 159.98,52.99 160.23,52.74 160.23,51.59 160.23,51.59 160.23,49.76 v2(160.65,49.34)
  BOTTOM w0.102: JDIMM2.84 181.62,12.61 181.9,12.88 181.9,13.59 v2(181.47,14.02)
DDR_B_D48: length 91.2
  IN4 w0.076: 157.44,56.24 159.63,54.05 159.63,53.19 161.99,50.83 161.99,49.97
  IN4 w0.084: 157.44,56.24 v2(157.44,57.3)
  IN4 w0.089: v2(216.37,13.11) 217.44,14.18 217.44,14.32 217.35,14.41 216.97,14.41 216.88,14.49 216.88,14.67 216.97,14.76 217.35,14.76 217.44,14.85 217.44,15.02 217.26,15.19 217.03,15.19 216.76,15.46 216.76,15.76 216.29,16.23 216.29,16.69 215.58,17.4 215.58,19.38 214.36,20.6 214.36,21.19 214.36,21.19 214.36,26.1 213.96,26.5 213.96,28.15 200.92,41.19 182.55,41.19 181.83,41.91 176.36,41.91 175.2,43.07 174.29,43.07 169.13,43.07 168.07,43.07 164.15,46.99 164.14,46.99 163.99,47.15 163.18,47.15 161.99,48.34 161.99,49.97
  BOTTOM w0.076: UC1.AU27 v2(157.44,57.3)
  BOTTOM w0.102: JDIMM2.216 216.62,12.85 v2(216.37,13.11)
DDR_B_D49: length 92.4
  IN4 w0.076: v2(157.44,57.95) 157.44,57.83 157.04,57.44 157.04,56.03 158.7,54.37 158.7,53.81 161.68,50.83 161.68,49.67
  IN4 w0.089: 161.68,49.67 161.68,48.21 161.95,47.95 161.95,47.82 161.8,47.67 161.8,47.54 161.92,47.41 162.05,47.41 162.2,47.57 162.33,47.57 162.45,47.44 162.45,47.32 162.27,47.14 162.27,47.01 162.4,46.89 162.52,46.89 162.7,47.07 162.83,47.07 163.21,46.69 164.02,46.69 164.02,46.69 167.94,42.77 169.01,42.77 169.01,42.77 173.43,42.77 175.07,42.77 176.28,41.56 181.75,41.56 182.42,40.88 200.8,40.88 213.31,28.37 213.31,28.01 213.4,27.92 213.54,27.92 213.63,27.83 213.63,27.55 213.54,27.46 213.4,27.46 213.31,27.37 213.31,27.12 213.4,27.03 213.54,27.03 213.63,26.94 213.63,26.4 214.03,26 214.03,25.49 214.03,20.49 214.03,20.49 215.27,19.25 215.27,17.71 215.27,17.71 215.27,17.28 215.27,17.14 215.36,17.05 215.51,17.05 215.66,16.9 215.66,16.73 215.57,16.64 215.36,16.64 215.27,16.55 215.27,16.19 215.53,15.93 215.75,15.93 215.84,16.02 v2(215.84,16.31)
  BOTTOM w0.076: UC1.AT27 v2(157.44,57.95)
  BOTTOM w0.102: JDIMM2.215 216.37,18.44 216.3,18.36 216.3,16.78 v2(215.84,16.31)
