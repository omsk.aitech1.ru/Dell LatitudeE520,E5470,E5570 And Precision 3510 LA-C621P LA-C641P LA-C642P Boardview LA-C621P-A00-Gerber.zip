# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_C_RD_DRX_N11: length 2.3
  TOP w0.094: UN5.2 241.37,31.61 241.52,31.76 241.52,32.29 241.83,32.61 241.83,32.78 CN31.2
PCIE_PTX_C_RD_DRX_N12: length 2.3
  TOP w0.094: UN4.2 230.04,32.8 230.2,32.95 230.2,33.28 230.27,33.36 230.27,33.93 CN22.2
PCIE_PTX_C_RD_DRX_P11: length 2.3
  TOP w0.094: CN32.2 242.03,32.78 242.03,32.53 241.71,32.21 241.71,31.78 241.87,31.63 UN5.1
PCIE_PTX_C_RD_DRX_P12: length 2.3
  TOP w0.094: UN4.1 230.54,32.8 230.39,32.95 230.39,33.2 230.47,33.28 230.47,33.92 CN21.2
PCIE_PTX_DRX_N3: length 114
  TOP w0.094: CZ58.1 234.83,65.77 235.15,65.77 235.88,65.04 237.01,65.04 237.68,65.71 238.37,65.71 v2(238.57,65.92)
  IN1 w0.112: v2(165.01,82.38) 165.17,82.22 167.19,82.22 167.85,81.56 167.85,81.25 168.35,80.75 170.04,80.75 170.32,81.03 170.32,84.63 173.55,87.86 181.77,87.86 183.44,86.19 189.15,86.19 189.31,86.03 197.65,86.03 197.85,85.83 203.32,85.83 203.47,85.98 205.21,85.98 205.51,85.68 210.08,85.68 211.47,84.3 213.3,84.3 213.75,83.84 221.88,83.84 222.29,84.25 222.29,86 223.96,87.67 228.58,87.67 230.01,86.24 230.89,86.24 233.25,83.87 233.25,82.49 236.12,79.62 236.12,78.24 238.08,76.28 238.08,65.8 238.2,65.68 238.33,65.68 v2(238.57,65.92)
  BOTTOM w0.076: UC1.D17 163.53,75.54 163.46,75.8 163.46,75.92 163.38,76.2 163.33,76.35 163.32,76.4 163.32,76.62 163.37,76.81 163.37,76.9 163.32,77.01 163.32,77.41 163.84,77.93 163.84,79.87 163.95,79.97 163.95,80.59
  BOTTOM w0.094: 163.95,80.59 163.95,81.74 164.38,82.16 164.8,82.16 v2(165.01,82.38)
PCIE_PTX_DRX_N5: length 151
  TOP w0.094: v2(253.1,16.34) 252.77,16.01 252.77,15.67 CZ14.1
  IN4 w0.112: v2(253.1,16.34) 253.1,17.25 250.99,19.36 248.24,19.36 247.13,20.47 247.13,20.9 245.36,22.67 243.74,22.67 242.65,23.76 242.65,23.93 242.24,24.34 241.68,24.34 236.89,29.13 236.89,33.82 236.29,34.41 236.29,36.08 229.55,42.82 229.55,46.19 230.08,46.72 230.08,51.82 228.71,53.19 228.71,55.42 230.34,57.05 231.8,57.05 233.04,58.3 233.04,60.75 232.23,61.55 232.23,63.58 231.4,64.42 231.4,72.7 228.58,75.53 222.09,75.53 221.61,76 209.99,76 209.23,75.24 204.96,75.24 194.74,75.24 193.09,76.88 186.53,76.88 185.26,75.61 181.99,75.61 179.34,78.25 174.78,78.25 174.57,78.45 169.26,78.45 167.97,77.16 165.27,77.16 163.82,78.61 v2(162.97,78.61)
  BOTTOM w0.076: v2(162.97,78.61) 162.61,78.25 162.61,77.87 162.66,77.81 162.66,77.05 162.61,76.94 162.61,76.79 162.66,76.59 162.66,76.42 162.58,76.17 UC1.C19
PCIE_PTX_DRX_N6: length 164.4
  TOP w0.094: v2(261.12,17.18) 261.3,17 261.3,16.44 CZ22.1
  IN4 w0.112: v2(163.01,79.81) 163.36,80.16 163.7,80.16 164.05,79.81 164.05,79.22 165.64,77.63 166.53,77.63 168.82,79.92 169.63,79.92 170.51,79.04 174.79,79.04 174.99,78.84 179.34,78.84 182.16,76.02 185.08,76.02 186.36,77.3 193.26,77.3 194.91,75.65 205.13,75.65 209.03,75.65 209.79,76.42 228.27,76.42 231.82,72.87 231.82,64.59 232.68,63.73 232.68,62.04 233.61,61.11 233.61,56.15 233.87,55.89 233.87,53.24 230.95,50.31 230.95,48.39 230.5,47.94 230.5,45.87 229.97,45.33 229.97,43 237.35,35.61 237.35,33.16 238.12,32.39 238.12,31.69 237.35,30.92 237.35,29.28 241.21,25.41 241.99,25.41 243.34,24.06 243.34,23.65 243.91,23.09 245.54,23.09 247.41,21.21 251.77,21.21 252.52,20.47 252.52,19.81 254.54,17.79 255.76,17.79 257.74,19.77 260.38,19.77 261.46,18.68 261.46,17.54 261.35,17.43 261.2,17.43 261.12,17.35 v2(261.12,17.18)
  BOTTOM w0.076: 162.42,79.3 162.42,78.99 162.23,78.8 162.23,78.25 162.23,78.25 162.23,77.53 162.1,77.41 162.1,76.33 162.13,76.31 162.13,76.04 161.83,75.75 UC1.D20
  BOTTOM w0.094: v2(163.01,79.81) 162.83,79.81 162.42,79.4 162.42,79.3
PCIE_PTX_DRX_N9: length 138.3
  TOP w0.094: CL6.1 262.02,95.69 262.02,95.96 261.77,96.2 259.13,96.2 258.51,95.58 258.51,94.72 258.05,94.26 257.01,94.26 256.73,94.54 256.73,94.92 v2(256.53,95.13)
  IN1 w0.112: v2(256.53,95.13) 256.84,94.81 256.84,94.67 256.75,94.59 255.31,94.59 254.49,95.41 254.1,95.41 253,96.51 250.13,96.51 249.02,97.62 241.53,97.62 240.98,97.06 232.26,97.06 231.02,95.82 230.05,95.82 229.05,96.82 225.78,96.82 224.48,95.51 219.94,95.51 219.76,95.69 210.59,95.69 210.47,95.8 206.46,95.8 202.32,91.66 192.24,91.66 188.95,94.95 185.8,94.95 174.29,94.95 173.67,94.33 171.67,94.33 170.09,95.91 157.21,95.91 156.09,94.8 156.09,94.19 v2(156.04,94.14)
  BOTTOM w0.076: 158.81,79.31 159.44,78.68 159.44,78.51 159.44,78.51 159.44,78.24 159.44,78.24 159.44,76.84 159.54,76.74 159.62,76.66 159.77,76.66 UC1.B23
  BOTTOM w0.094: 158.81,79.31 158.65,79.47 158.63,79.47 157.96,80.14 157.26,80.14 157.1,80.14 156.22,81.01 156.22,81.65 156.4,81.83 156.4,83.43 155.71,84.13 155.71,84.92 155.81,85.03 155.81,89.99 156.25,90.43 156.25,93.93 v2(156.04,94.14)
PCIE_PTX_DRX_N10: length 178
  TOP w0.094: v2(262.57,46.94) 262.62,46.94 262.84,46.73 262.84,46.62 CR25.1
  IN4 w0.112: v2(262.57,46.94) 262.75,46.76 262.75,46.57 263.11,46.21 269.72,46.21 273.71,50.21 273.71,53.87 275.24,55.4 275.24,55.81 275.32,55.89 275.32,55.89 275.47,56.03 275.47,62.51 275.47,62.72 272.81,65.38 272.81,65.96 272.4,66.37 272.4,67.49 267.84,72.05 266.32,72.05 264.49,73.88 261.38,73.88 259.69,75.58 258.19,75.58 257.36,76.4 255.97,76.4 255.27,77.1 255.27,77.6 254,78.87 254,85.76 251.39,88.37 246.85,88.37 246.22,89.01 244.49,89.01 242.85,87.37 242.4,87.37 242.11,87.08 239.71,87.08 239.28,87.51 233.77,87.51 233.51,87.25 230.23,87.25 229.63,87.85 224.5,87.85 222.67,86.03 222.67,83.94 222.05,83.32 216.87,83.32 216.72,83.32 213.07,83.32 212.71,83.67 210.45,83.67 209.93,83.16 202.27,83.16 202.03,83.39 190.78,83.39 190.22,83.95 188.81,83.95 186.37,86.39 181.4,86.39 180.63,85.62 179.5,85.62 179.35,85.77 175.48,85.77 174.43,86.81 164.77,86.81 164.2,87.37 163.39,87.37 161.34,85.32 161.34,84.91 159.02,82.6 159.02,81.54 v2(158.81,81.33)
  BOTTOM w0.076: 160.2,79.31 160.2,79.29 160.19,79.27 160.19,77.55 160.35,77.39 160.35,77.01 160.34,76.99 160.32,76.92 160.32,76.73 160.35,76.64 160.35,76.39 160.3,76.24 160.3,76.14 160.21,76.05 160.21,75.74 159.92,75.45 UC1.D23
  BOTTOM w0.094: v2(158.81,81.33) 159.12,81.03 159.68,81.03 160.2,80.5 160.2,79.31
PCIE_PTX_DRX_N11: length 149
  TOP w0.094: v2(239.5,43.63) 239.73,43.39 239.73,43.16 240.43,42.46 240.43,41.01 v4(240.09,40.67) 239.37,39.94 239.32,39.94 238.9,39.53 238.9,39.48 238.72,39.3 238.72,37.97 241.83,34.86 241.83,34.39 CN31.1
  IN4 w0.112: v2(239.5,43.63) 239.68,43.81 239.68,44.93 241.21,46.46 241.21,47.32 241.88,47.99 241.88,50.43 242.83,51.38 242.83,53.65 242.5,53.97 242.5,54.86 242.9,55.26 242.9,55.82 242.55,56.17 242.55,61.63 241.42,62.76 241.42,69.67 239.03,72.06 239.03,75.69 231.89,82.83 231.22,82.83 229.55,84.5 229.55,85.83 228.46,86.92 224.85,86.92 223.58,85.65 223.58,83.56 222.43,82.41 216.5,82.41 216.35,82.41 212.64,82.41 212.33,82.1 201.92,82.1 201.54,82.48 191.33,82.48 191.21,82.37 189.11,82.37 186,85.48 182.19,85.48 180.37,83.66 175.92,83.66 174.29,85.29 168.1,85.29 167.83,85.56 163.27,85.56 159.93,82.22 159.93,79.72 159.42,79.21 158.31,79.21 158.14,79.04 158.08,79.04 157.97,78.94 v2(157.97,78.72)
  BOTTOM w0.076: UC1.D24 159.36,75.77 159.06,76.06 159.06,76.31 159.11,76.35 159.11,78.37 158.63,78.85 158.1,78.85 v2(157.97,78.72)
PCIE_PTX_DRX_N12: length 108.9
  TOP w0.094: CN22.1 230.19,35.45 230.19,36.04 v2(230.03,36.2)
  IN4 w0.076: v2(155.33,78.74) 155.15,78.57 154.67,78.57 154.27,78.16 154.27,77.58 155.14,76.7 155.82,76.7 156.64,75.89 156.94,75.89 157.81,75.02 157.81,73.11 158.11,72.81 159.02,72.81 159.4,72.43 161.52,72.43 161.83,72.74 162.14,72.74 162.77,72.11 162.77,72.01 162.94,71.84 162.95,71.84
  IN4 w0.112: 162.95,71.84 166.46,71.84 166.95,71.34 170.65,71.34 171.47,72.17 171.48,72.17 171.49,72.17 173.58,72.17 174.04,71.71 176.66,71.71 177.33,72.38 180.47,72.38 181.19,71.65 183.89,71.65 184.3,71.25 186.6,71.25 187.84,70.01 191.12,70.01 193.15,67.97 193.36,67.97 194.37,66.97 197.54,66.97 198.34,66.17 198.34,62.76 199.91,61.18 203.58,61.18 206.47,58.3 206.47,57.89 208.73,55.63 208.73,53.35 208.95,53.13 208.95,51.46 209.07,51.34 209.07,50.88 209.51,50.44 209.51,48.85 210.6,47.76 213.32,47.76 216.39,44.69 217.43,44.69 218.9,43.22 221.75,43.22 227.25,37.72 228.88,37.72 230.11,36.48 230.11,36.28 v2(230.03,36.2)
  BOTTOM w0.076: v2(155.33,78.74) 155.75,78.32 157.28,78.32 158.57,77.04 158.67,77.04 UC1.A25
PCIE_PTX_DRX_P3: length 114
  TOP w0.094: CZ59.1 234.83,65.58 235.07,65.58 235.8,64.85 237.09,64.85 237.76,65.52 238.33,65.52 v2(238.57,65.28)
  IN1 w0.112: v2(238.57,65.28) 238.42,65.43 238.09,65.43 237.83,65.7 237.83,76.18 235.88,78.13 235.88,79.51 233.01,82.38 233.01,83.77 230.79,85.99 229.91,85.99 228.47,87.42 224.06,87.42 222.54,85.9 222.54,84.15 221.98,83.6 213.65,83.6 213.19,84.05 211.36,84.05 209.98,85.43 205.41,85.43 205.11,85.73 203.57,85.73 203.42,85.58 197.95,85.58 197.75,85.58 197.54,85.78 189.21,85.78 189.05,85.94 183.34,85.94 181.67,87.61 173.65,87.61 170.57,84.53 170.57,80.93 170.14,80.51 168.25,80.51 167.61,81.15 167.61,81.46 167.1,81.97 165.18,81.97 v2(164.98,81.76)
  BOTTOM w0.076: UC1.C17 163.75,75.68 163.84,75.59 163.96,75.59 164.04,75.68 164.04,76 163.89,76.15 163.64,76.15 163.53,76.26 163.53,76.26 163.48,76.42 163.48,76.59 163.54,76.79 163.54,76.94 163.48,77.05 163.48,77.34 164.01,77.86 164.01,79.8 164.11,79.91 164.11,80.51 164.12,80.52 164.12,80.58 164.13,80.58 164.13,80.59
  BOTTOM w0.094: v2(164.98,81.76) 164.76,81.98 164.45,81.98 164.13,81.66 164.13,80.59
PCIE_PTX_DRX_P5: length 151
  TOP w0.094: v2(252.46,16.34) 252.58,16.22 252.58,15.84 CZ13.1
  IN4 w0.112: v2(162.98,78.02) 163.32,78.36 163.72,78.36 165.17,76.92 168.08,76.92 169.37,78.21 174.47,78.21 174.68,78 179.24,78 181.88,75.36 185.36,75.36 186.64,76.64 192.99,76.64 194.63,74.99 204.86,74.99 209.33,74.99 210.1,75.75 221.51,75.75 221.98,75.28 228.47,75.28 231.15,72.6 231.15,64.31 231.98,63.48 231.98,61.45 232.79,60.64 232.79,58.4 231.69,57.3 230.24,57.3 228.46,55.52 228.46,53.09 229.83,51.72 229.83,46.82 229.3,46.29 229.3,42.72 236.05,35.98 236.05,34.31 236.64,33.72 236.64,29.03 241.58,24.09 242.14,24.09 242.4,23.83 242.4,23.65 243.63,22.42 245.26,22.42 246.88,20.8 246.88,20.37 248.14,19.11 250.89,19.11 252.85,17.15 252.85,16.67 252.69,16.51 252.69,16.46 252.56,16.34 v2(252.46,16.34)
  BOTTOM w0.076: UC1.D19 162.53,75.21 162.61,75.34 162.61,75.54 162.77,76.09 162.77,76.2 162.82,76.35 162.82,76.37 162.83,76.39 162.83,76.64 162.79,76.73 162.79,76.92 162.82,76.99 162.83,77.01 162.83,77.87 v2(162.98,78.02)
PCIE_PTX_DRX_P6: length 164.4
  TOP w0.094: CZ21.1 261.49,16.42 261.49,16.99 v2(261.71,17.2)
  IN4 w0.112: v2(163.01,80.41) 163.8,80.41 164.3,79.91 164.3,79.32 165.74,77.88 166.43,77.88 168.72,80.17 169.73,80.17 170.61,79.29 174.89,79.29 175.09,79.09 179.44,79.09 182.26,76.27 184.98,76.27 186.26,77.55 193.36,77.55 195.01,75.9 205.24,75.9 205.24,75.9 208.93,75.9 209.69,76.66 228.38,76.66 232.06,72.98 232.06,64.7 232.93,63.83 232.93,62.14 233.86,61.21 233.86,56.25 234.12,55.99 234.12,53.13 231.19,50.21 231.19,48.28 230.75,47.84 230.75,45.77 230.21,45.23 230.21,43.1 237.6,35.71 237.6,33.26 238.37,32.49 238.37,31.59 237.6,30.82 237.6,29.38 241.32,25.66 242.09,25.66 243.59,24.16 243.59,23.76 244.01,23.33 245.64,23.33 247.51,21.46 251.88,21.46 252.77,20.57 252.77,19.91 254.64,18.04 255.66,18.04 257.64,20.01 260.48,20.01 261.71,18.78 v2(261.71,17.2)
  BOTTOM w0.076: 162.24,79.38 162.24,79.04 162.06,78.87 162.06,77.6 161.94,77.48 161.94,76.29 UC1.C20
  BOTTOM w0.094: 162.24,79.38 162.24,79.48 162.63,79.87 162.63,80.27 162.77,80.41 v2(163.01,80.41)
PCIE_PTX_DRX_P9: length 138.3
  TOP w0.094: v2(257.14,95.13) 256.92,94.91 256.92,94.62 257.09,94.46 257.97,94.46 258.31,94.8 258.31,95.66 259.05,96.4 261.85,96.4 262.21,96.04 262.21,95.64 CL5.1
  IN1 w0.112: v2(257.14,95.13) 257.09,95.08 257.09,94.57 256.86,94.34 255.21,94.34 254.39,95.16 254,95.16 252.9,96.26 250.03,96.26 248.92,97.37 241.63,97.37 241.08,96.82 232.36,96.82 231.12,95.57 229.95,95.57 228.95,96.57 225.89,96.57 224.58,95.27 219.84,95.27 219.66,95.44 210.69,95.44 210.69,95.44 210.48,95.44 210.36,95.56 206.56,95.56 202.42,91.41 192.14,91.41 188.85,94.7 185.91,94.7 174.39,94.7 173.77,94.09 171.57,94.09 169.99,95.67 157.31,95.67 156.34,94.69 156.34,94.44 v2(156.65,94.13)
  BOTTOM w0.076: UC1.A23 159.96,77.12 159.96,76.89 159.89,76.82 159.69,76.82 159.6,76.91 159.6,78.17 159.6,78.75 158.98,79.37 158.98,79.38 158.94,79.42 158.94,79.43 158.94,79.44
  BOTTOM w0.094: v2(156.65,94.13) 156.44,93.91 156.44,90.35 156.01,89.91 156.01,84.95 155.9,84.84 155.9,84.21 156.59,83.51 156.59,81.75 156.42,81.57 156.42,81.09 157.18,80.33 158.04,80.33 158.94,79.44
PCIE_PTX_DRX_P10: length 178
  TOP w0.094: v2(263.18,46.94) 263.03,46.79 263.03,46.69 263.38,46.33 CR24.1
  IN4 w0.112: v2(158.84,80.45) 158.63,80.45 158.48,80.6 158.48,80.78 158.63,80.92 158.98,80.92 159.26,81.2 159.26,82.49 161.58,84.81 161.58,85.22 163.49,87.13 164.1,87.13 164.66,86.56 174.33,86.56 175.37,85.52 179.25,85.52 179.39,85.37 180.73,85.37 181.5,86.14 186.27,86.14 188.7,83.71 190.12,83.71 190.68,83.15 201.93,83.15 202.17,82.91 210.03,82.91 210.55,83.43 212.61,83.43 212.96,83.07 216.62,83.07 216.77,83.07 222.16,83.07 222.92,83.84 222.92,85.93 224.6,87.61 229.53,87.61 230.13,87.01 233.62,87.01 233.87,87.26 239.18,87.26 239.61,86.83 242.21,86.83 242.5,87.12 242.95,87.12 244.59,88.76 246.12,88.76 246.75,88.13 251.29,88.13 253.75,85.66 253.75,78.77 255.03,77.5 255.03,76.99 255.87,76.15 257.26,76.15 258.08,75.33 259.59,75.33 261.28,73.63 264.39,73.63 266.22,71.8 267.73,71.8 272.15,67.39 272.15,66.27 272.56,65.86 272.56,65.52 272.54,65.5 272.56,65.49 272.56,65.28 275.22,62.61 275.22,56.14 275,55.91 275,55.5 273.47,53.97 273.47,50.31 269.61,46.46 263.21,46.46 263,46.67 263,46.76 v2(263.18,46.94)
  BOTTOM w0.076: 160.01,79.31 160.01,79.29 160.02,79.27 160.02,77.48 160.19,77.32 160.19,77.05 160.15,76.95 160.15,76.7 160.17,76.67 160.19,76.61 160.19,76.42 160.14,76.27 160.14,76.21 160.08,76.15 159.75,76.15 159.6,76 159.6,75.7 159.68,75.62 159.8,75.62 159.92,75.74 UC1.C23
  BOTTOM w0.094: v2(158.84,80.45) 159.23,80.84 159.6,80.84 160.01,80.42 160.01,79.31
PCIE_PTX_DRX_P11: length 149
  TOP w0.094: CN32.1 242.16,34.26 242.08,34.34 242.03,34.39 242.03,34.94 238.92,38.05 238.92,39.22 v4(239.27,39.58) 240,40.3 240.04,40.3 240.46,40.72 240.46,40.76 240.63,40.93 240.63,42.54 239.93,43.24 239.93,43.53 v2(240.08,43.68)
  IN4 w0.112: v2(157.97,79.46) 159.32,79.46 159.68,79.82 159.68,82.33 163.16,85.81 167.93,85.81 168.2,85.53 174.39,85.53 176.02,83.9 180.27,83.9 182.09,85.72 186.1,85.72 189.21,82.61 191.11,82.61 191.23,82.73 201.65,82.73 202.03,82.35 212.23,82.35 212.53,82.66 216.45,82.66 216.6,82.66 222.33,82.66 223.34,83.66 223.34,85.75 224.75,87.17 228.56,87.17 229.8,85.93 229.8,84.6 231.33,83.07 232,83.07 239.28,75.79 239.28,72.17 241.67,69.78 241.67,62.86 242.8,61.73 242.8,56.27 243.14,55.92 243.14,55.15 242.75,54.76 242.75,54.07 243.07,53.75 243.07,51.28 242.13,50.33 242.13,47.89 241.46,47.22 241.46,46.36 239.93,44.83 239.93,43.83 v2(240.08,43.68)
  BOTTOM w0.076: v2(157.97,79.46) 157.85,79.33 157.85,79.19 157.95,79.09 158.14,79.09 158.22,79.01 158.7,79.01 159.27,78.44 159.27,76.27 UC1.C24
PCIE_PTX_DRX_P12: length 108.9
  TOP w0.094: v2(230.62,36.22) 230.38,35.99 230.38,35.48 230.68,35.19 CN21.1
  IN4 w0.076: v2(155.33,78.16) 155.09,78.4 154.74,78.4 154.43,78.1 154.43,77.65 155.21,76.86 155.89,76.86 156.7,76.05 157.01,76.05 157.97,75.09 157.97,73.18 158.18,72.98 159.09,72.98 159.47,72.6 161.45,72.6 161.76,72.9 162.21,72.9 163.03,72.08
  IN4 w0.112: 163.03,72.08 166.56,72.08 167.06,71.59 170.54,71.59 171.37,72.41 171.38,72.41 171.38,72.42 173.68,72.42 174.14,71.96 176.56,71.96 177.23,72.62 180.57,72.62 181.3,71.9 183.99,71.9 184.4,71.49 186.71,71.49 187.94,70.26 191.22,70.26 193.25,68.22 193.46,68.22 194.47,67.21 197.64,67.21 198.59,66.27 198.59,62.86 200.02,61.43 203.68,61.43 206.71,58.4 206.71,57.99 208.98,55.73 208.98,53.45 209.19,53.23 209.19,51.57 209.32,51.44 209.32,50.98 209.76,50.54 209.76,48.95 210.7,48.01 213.42,48.01 216.5,44.94 217.53,44.94 219,43.46 221.85,43.46 227.35,37.96 228.98,37.96 230.36,36.58 230.36,36.48 v2(230.62,36.22)
  BOTTOM w0.076: UC1.B25 158.79,76.58 157.21,78.16 v2(155.33,78.16)
PCIE_PTX_RD_DRX_N11: length 3.6
  TOP w0.094: CN36.2 243.1,25.38 243.1,25.67 242.96,25.81 242.75,25.81 242.72,25.78 242.13,25.78 242.1,25.81 241.84,25.81 241.52,26.13 241.52,26.49 241.37,26.64 UN5.17
PCIE_PTX_RD_DRX_N12: length 2.8
  TOP w0.094: CN26.2 230.91,26.39 230.91,26.58 230.85,26.65 230.42,26.65 230.21,26.85 230.21,27.46 230.04,27.63 UN4.17
PCIE_PTX_RD_DRX_P11: length 3.6
  TOP w0.094: UN5.18 241.87,26.62 241.71,26.47 241.71,26.21 241.92,26.01 v4(242.43,26.01) 243.04,26.01 243.3,25.75 243.3,25.38 CN35.2
PCIE_PTX_RD_DRX_P12: length 2.8
  TOP w0.094: UN4.18 230.54,27.64 230.4,27.5 230.4,26.93 230.5,26.84 230.93,26.84 231.1,26.66 231.1,26.39 CN25.2
PCIE_RCOMPN: length 13.3
  TOP w0.381: RC45.1 181.15,71.57 180.01,72.71 178.39,72.71 177.4,71.72 v3(174.92,71.72) 174.41,71.72 173.45,72.69 172.19,72.69 171.44,73.44 170.83,73.44 v2(170.24,74.03)
  BOTTOM w0.305: UC1.F5 v2(170.24,74.03)
PCIE_RCOMPP: length 17
  TOP w0.381: v2(170.24,74.64) 171.02,74.64 171.25,74.86 172.12,74.86 172.5,74.48 172.5,73.97 173.1,73.37 173.82,73.37 174.78,72.42 v3(176.85,72.42) 177.13,72.42 178.1,73.4 178.1,74.42 178.45,74.77 179.03,74.77 180.34,73.45 180.34,73.35 181.46,72.23 181.84,72.23 182.08,71.99 RC45.2
  BOTTOM w0.305: v2(170.24,74.64) 170.64,74.44 UC1.E5
PCIE_WAKE#: length 130.5
  IN1 w0.089: v2(264.68,16.82) 263.94,16.82 262.53,15.41 260.44,15.41 258.8,17.05 v2(257.57,17.05) 257.58,17.06 257.58,15.38 252.74,10.54 252.74,3.18 v2(253.12,2.8)
  IN2 w0.122: v2(249.39,89.03) 249.42,89 249.42,85.26 250.06,84.62 250.06,83.69 250.14,83.62 250.14,80.48 249.36,79.7 249.36,76.79 250.04,76.12 250.04,74.6 250.1,74.54 250.1,74.31 251.46,72.95 251.46,66.44 251.48,66.41 251.48,65.16 251.01,64.7 251.01,64.65 251.01,64.65 251.01,63.81 251.01,63.81 251.01,61.67 250.63,61.29 v2(249.88,61.29)
  IN4 w0.089: v2(264.68,16.82) 265.32,17.46 265.32,23.41 265.71,23.8 265.71,29.15 264.39,30.48 264.39,35.58 264.31,35.66 264.31,35.9 263.92,36.29 263.92,36.8 261.91,38.81 261.62,38.81 259.75,40.68 259.75,41.88 257.41,44.21 257.41,48.26 253.66,52.02 253.66,53.79 249.41,58.04 249.41,60.82 v2(249.88,61.29)
  BOTTOM w0.102: JNGFF1.62 260.95,21.75 260.59,21.39 260.59,20.13 261.14,19.57 261.14,18.83 260.9,18.58 259.41,18.58 258,17.17 257.69,17.17 v2(257.57,17.05) 257.2,16.68 JNGFF1.47 ; v2(249.39,89.03) 249.39,89.03 RE275.1 RE274.1 ; v2(249.88,61.29) 248.83,61.29 246.24,63.88 243.11,63.88 242.69,64.3 JNGFF2.46 ; v2(253.12,2.8) 253.3,2.62 JNGFF3.54
PCIE_WAKE#_R: length 6.5
  TOP w0.102: v2(248.55,86.54) 248.91,86.54 249.14,86.78 UE1.B10
  BOTTOM w0.102: RE35.2 249.39,87.28 RE275.2 249.39,86.72 249.24,86.57 248.58,86.57 v2(248.55,86.54) 249.06,86.03 249.06,85.49 248.48,84.9 v3(248.48,84.38)
PD_ACE_DET#: length 16
  TOP w0.102: v2(249.43,92.03) 249.21,92.03 RE310.2 ; UE1.A60 255.57,84.38 256.43,85.24 256.43,85.54 256.54,85.65 v1(256.54,85.77) 256.54,86.92 254.85,88.61 v2(254.26,88.61)
  IN3 w0.122: v2(254.26,88.61) 253.7,88.61 253.46,88.84 253.46,91.46 252.25,92.68 250.08,92.68 v2(249.43,92.03)
PECI_EC: length 176.8
  TOP w0.102: v2(203.11,87.15) 203.11,88.39 202.78,88.73 197.9,88.73 197.09,89.54 189.66,89.54 186.91,92.29 175.11,92.29 173.78,93.62 172.77,93.62 170.63,95.75 166.85,95.75 166.07,94.98 158.82,94.98 157.16,93.32 154.32,93.32 v2(153.89,92.89) ; RE60.2 253.94,56.18 253.94,58.54 v2(253.99,58.58)
  IN2 w0.122: v2(253.99,58.58) 255,59.6 255,63.36 255.01,63.37 255.01,65.47 255.62,66.08 255.62,69.43 255.36,69.69 255.36,72.22 255.73,72.6 255.73,74.66 256.59,75.52 256.59,77.34 254.79,79.14 254.79,86.75 253.64,87.9 253.64,90.69 251.88,92.45 247.66,92.45 246.77,91.57 244.41,91.57 244.06,91.91 242.13,91.91 241.47,91.26 240.61,90.39 240.61,88.6 239.43,87.42 234.86,87.42 234.28,86.84 229.05,86.84 228.47,87.42 224.38,87.42 222.84,85.88 222.84,85.08 221.25,83.49 211.47,83.49 210.26,84.69 205.33,84.69 203.11,86.91 v2(203.11,87.15)
  BOTTOM w0.076: 142.08,81.74 142.08,80.93 142.85,80.16 142.85,79.19 142.42,78.76 142.42,77.31 UC1.A54
  BOTTOM w0.102: v2(153.89,92.89) 153.89,91.74 149.52,87.36 v3(149.52,84.19) 149.52,82.5 148.5,81.49 146.85,81.49 145.68,82.66 142.97,82.66 142.4,82.1 142.29,82.1 142.08,81.88 142.08,81.74
PECI_EC_R: length 8.7
  TOP w0.102: UE2.A48 260.12,57.54 259.56,56.99 257.99,56.99 257.07,56.07 256.35,56.07 255.86,55.58 254.29,55.58 RE60.1 253.96,55.2 254.51,54.65 v3(254.51,54.17)
PGOOD_3V: length 23.2
  TOP w0.254: v2(223.35,69.17) 223.35,68.3 PR107.2 ; PU101.1 v2(228.59,64.23)
  IN1 w0.254: v2(230.13,58.74) 229.86,59.01 229.86,61.31 228.59,62.58 v2(228.59,64.23)
  IN4 w0.254: v2(228.59,64.23) 227.61,64.23 226.99,64.85 222.72,64.85 221.32,66.25 221.32,67.39 221.96,68.03 222.21,68.03 v2(223.35,69.17)
  BOTTOM w0.254: PR119.1 230.05,58.66 v2(230.13,58.74) ; v2(223.35,69.17) 223.43,69.24 223.43,70.63 223.14,70.93 PU100.9
PGOOD_5V: length 11.1
  TOP w0.254: v3(225.94,61.35) 226.19,61.1 227.31,61.1 227.95,61.75 v2(228.17,61.75) 228.17,61.24 228.39,61.03 228.97,61.03 229.24,61.3 229.24,62.79 229.02,63.01 PU101.2
  BOTTOM w0.254: v2(228.17,61.75) 227.96,61.75 227.4,61.18 PR120.1 226.75,60.93 PR113.2 225.28,61.29 224.95,61.63 PU102.9
PLTRST_5048#: length 88.1
  TOP w0.102: UE1.B22 246.22,84.63 246.37,84.78 v2(246.37,85.35)
  IN2 w0.122: v2(246.37,85.35) 246.17,85.54 245.33,85.54 243.75,87.12 241.52,87.12 239.41,85.01 238.91,85.01 237.83,83.93 234.19,83.93 233.84,83.93 232.5,82.58 231.21,82.58 v2(230.14,82.58)
  IN3 w0.122: v2(230.14,82.58) 230.14,80.31 229.83,80.01 229.58,79.76 229.58,79.74 228.81,78.97 228.81,75.47 232.14,72.15 232.14,70.92 v2(232.62,70.44)
  BOTTOM w0.102: RC64.1 188.72,72.65 188.03,73.34 188.03,73.67 191.12,76.76 195.06,76.76 195.15,76.67 200.78,76.67 200.99,76.88 v3(208.17,76.88) 220.36,76.88 220.68,77.19 228.12,77.19 228.67,76.65 228.67,75.04 231.81,71.9 231.81,70.84 232.21,70.44 v2(232.62,70.44)
PLTRST_LAN#: length 110.2
  TOP w0.102: UL1.36 266.63,89.13 266.45,88.95 v2(262.09,88.95) ; v2(232.62,71.66) 233.04,72.07 233.04,72.62 230.01,75.64 230.01,77.31 230.9,78.2 231.41,78.2 233.24,80.03 233.24,80.83 235.76,83.35 236.95,83.35 239.77,86.18 239.77,88.18 v2(239.1,88.85)
  IN1 w0.089: v2(239.1,88.85) 239.17,88.92 240.59,88.92 243.28,91.61 246.71,91.61 247.63,92.52 251.75,92.52 253.69,90.59 254.2,90.59 254.56,90.24 257.17,90.24 258.2,89.21 261.12,89.21 261.38,88.95 v2(262.09,88.95)
  BOTTOM w0.102: v2(232.62,71.66) 229.17,75.11 229.17,76.8 228.37,77.6 220.51,77.6 220.19,77.28 v3(210,77.28) 200.82,77.28 200.61,77.07 195.32,77.07 195.23,77.17 190.95,77.17 190.71,76.93 187.29,73.51 187.29,72.64 186.55,71.9 186.55,70.45 186.49,70.39 185.91,70.39 RC62.1
PLTRST_TPM#: length 16.5
  TOP w0.102: UZ12.17 191.4,70.23 191.56,70.39 191.81,70.39 191.98,70.21 v2(191.98,70.08)
  IN2 w0.122: v2(186.24,62.72) 186.68,62.72 187.7,63.74 187.7,64.2 187.76,64.27 187.76,64.27 188.01,64.52 188.01,64.52 191.98,68.49 v2(191.98,70.08)
  BOTTOM w0.102: RC60.1 188.91,69.55 189.28,69.19 189.64,69.19 190.54,70.08 v2(191.98,70.08) ; RC325.1 186.24,63.55 v2(186.24,62.72)
PLTRST_VMM2320#: length 48.8
  TOP w0.076: 211.99,94.8 213.75,93.04 UV8.A13
  TOP w0.102: 211.99,94.8 211.77,95.02 209.56,95.02 v2(209.46,95.13)
  IN3 w0.122: v2(188.17,72.6) 188.58,72.6 193.32,77.33 195.79,77.33 197.15,78.69 205.2,78.69 210.42,83.91 210.42,88.14 208.37,90.19 208.37,94.03 208.9,94.57 209.26,94.57 209.46,94.77 v2(209.46,95.13)
  BOTTOM w0.102: RC61.1 186.73,69.96 186.96,70.18 186.96,71.73 187.82,72.6 v2(188.17,72.6)
PM_LANPHY_ENABLE: length 180.5
  TOP w0.102: v2(226.48,37.57) 226.48,38.13 227.49,39.15 228.33,39.15 228.66,38.82 228.66,38.21 229.2,37.67 230.96,37.67 232.2,36.44 232.2,34.47 232.97,33.7 234.64,33.7 235.6,34.66 235.6,35.05 235.95,35.4 235.95,38.65 234.48,40.13 234.48,42.67 233.95,43.2 233.95,43.63 236.41,46.1 236.41,47.02 238.12,48.72 238.12,50.02 238.43,50.33 238.43,51.33 237.63,52.13 237.63,54.59 237.54,54.68 237.54,59.58 233.63,63.49 232.62,63.49 231.79,64.32 231.79,66.45 231.2,67.03 231.2,73.79 229.61,75.39 229.61,77.48 230.73,78.6 231.23,78.6 232.68,80.05 232.68,80.85 235.69,83.86 v3(236.08,83.86) 236.87,83.86 239.37,86.36 239.37,87.82 238.47,88.73 v2(238.47,88.85)
  IN1 w0.089: v2(257.62,90.63) 255.48,90.63 253.19,92.92 247.47,92.92 246.56,92.01 243.13,92.01 240.48,89.36 238.97,89.36 v2(238.47,88.85) ; v2(226.48,37.57) 225.66,37.57 224.47,36.38 220.68,36.38 219.84,37.23 217.87,37.23 215.48,39.62 214.02,39.62 213.33,40.3 v2(212.65,40.3)
  BOTTOM w0.076: UC1.AW17 163.61,56.38 163.44,56.21 163.22,55.51 163.22,55.42 163.18,55.31 163.18,55.06 163.22,54.94 163.22,54.76 163.18,54.67 163.18,54.31 163.38,54.11 163.38,52.86 165.01,51.23
  BOTTOM w0.102: 165.01,51.23 165.44,50.8 165.44,48.53 171.14,42.83 175.06,42.83 177.25,40.64 177.25,40.22 177.54,39.93 209.99,39.93 211.15,41.1 211.85,41.1 v2(212.65,40.3) ; v2(257.62,90.63) 257.79,90.63 258.02,90.39 RL7.1
PME#: length 3.6
  TOP w0.102: T115.1 167.98,59.22 167.69,58.93 167.39,58.93 167.1,58.64 167.1,57.82 v2(166.59,57.32)
  BOTTOM w0.076: v2(166.59,57.32) 166.92,57.65 UC1.AU11
POA_WAKE#: length 73.7
  TOP w0.102: v2(276.74,14.61) 276.11,13.98 v3(276.11,13.48) 276.11,13.36 276.39,13.08 276.39,10.12 273.36,7.09 271.41,7.09 270.96,7.54 JUSH1.23 ; UE2.B68 270.32,56.69 270.65,56.37 272.53,56.37 273.75,57.59 275.32,57.59 275.88,58.14 v2(275.88,58.45) 275.96,58.53 276.95,58.53 277.24,58.23 RPE5.3
  IN3 w0.122: v2(275.88,58.45) 275.61,58.18 275.61,54.75 272.28,51.41 272.28,49.99 269.09,46.81 269.09,43.48 268.24,42.63 268.24,40.71 267.89,40.36 267.89,34.31 268.54,33.65 268.54,29.13 268.86,28.8 268.86,26.73 270.65,24.95 270.65,23.65 271.74,22.56 271.74,20.48 272.58,19.64 272.58,18.24 273.67,17.15 275.25,17.15 276.09,16.31 276.09,15.26 v2(276.74,14.61)
POWER_SW#_MB: length 126.7
  TOP w0.102: JAPS1.11 299.94,30.95 300.55,31.57 v2(302.22,31.57) ; SW3.4 303.9,88.83 303.9,84.77 SW3.2 303.05,83.92 302.73,83.92 302.43,83.62 298.49,83.62 v2(297.96,84.15) ; RE33.2 CE10.1 279.36,50.88 v2(280.3,50.88)
  IN1 w0.089: v2(280.3,50.88) 280.61,50.88 283.01,48.47 290.5,48.47 291.13,47.84 294.6,47.84 301.6,40.84 301.6,39.82 303.01,38.41 303.01,32.36 v2(302.22,31.57)
  IN3 w0.122: v2(297.96,84.15) 291.65,84.15 290.23,82.73 290.23,79.54 287.63,76.93 287.63,73 285.88,71.24 285.88,68.25 284.78,67.15 284.78,66.48 284.42,66.13 284.42,65.35 285.31,64.46 285.31,59.39 282.07,56.16 282.07,52.33 292.97,41.43 297.21,41.43 302.86,35.78 302.86,35.27 303.15,34.98 303.15,31.94 302.77,31.57 v2(302.22,31.57)
POWER_SW_IN#: length 13.4
  TOP w0.102: v2(274.15,56.29) 273.93,56.06 273.93,55.63 274.26,55.3 275.2,55.3 277.46,53.04 CE12.1 277.46,52.4 277.55,52.3 RE31.2 RE33.1 ; UE2.B67 269.4,57.1 v2(269.84,57.53)
  BOTTOM w0.102: v2(269.84,57.53) 270.37,57.53 271.69,56.21 274.08,56.21 v2(274.15,56.29)
PROCHOT_GATE: length 14.9
  TOP w0.102: UE1.A61 255.75,84.88 256.2,85.34 256.2,86.94 255.11,88.03 v2(254.26,88.03) ; RE311.2 249.91,92.22 249.91,91.69 v2(249.82,91.59)
  IN3 w0.122: v2(254.26,88.03) 253.93,88.03 253.22,88.74 253.22,91.35 252.14,92.43 250.65,92.43 v2(249.82,91.59)
PS_ID: length 274.1
  TOP w0.102: PU1.4 52.48,98.97 52.68,99.16 53,99.16 53.22,98.94 53.22,97.87 52.62,97.26 50.98,97.26 v3(50.92,97.2) 50.92,95.61 51.5,95.03 51.95,95.03 52.41,95.48 54.32,95.48 v2(54.8,95) ; UE2.B24 266.9,65.37 v2(266.53,65)
  IN3 w0.122: v2(266.53,65) 266.02,65.52 264.71,65.52 263.79,66.44 261.16,66.44 260.07,67.53 254.57,67.53 247.87,74.23 246.81,74.23 246.77,74.26 245.82,74.26 245.58,74.51 245.58,74.77 245.39,74.96 245.39,75.73 245.39,75.73 245.39,76.14 245.39,76.14 244.93,76.59 244.93,76.6 244.64,76.89 244,77.52 244,78.31 244.3,78.61 244.3,81.9 244.78,82.38 244.78,86.91 245.79,87.92 245.79,91.69 244.67,92.81 244.67,96.27 243.17,97.76 232.13,97.76 231.98,97.91 229.89,97.91 229.58,98.22 228.71,99.09 228.37,99.09 227.1,100.35 225.05,100.35 224.45,100.95 217.49,100.95 216.62,100.08 211.72,100.08 210.62,98.99 210.32,98.99 205.48,94.15 205.48,92.31 204.74,91.57 203.03,91.57 202.3,90.83 189.1,90.83 185.15,94.78 179.07,94.78 177.65,93.36 177.65,92.42 176.74,91.51 174.28,91.51 173.39,92.4 173.39,94.83 170.63,97.59 158.74,97.59 158.11,98.22 144.12,98.22 142.21,96.3 123.56,96.3 120.44,93.18 119.16,93.18 116.49,90.51 108.04,90.51 107.14,91.4 105.42,91.4 105.06,91.76 101.48,91.76 99.83,90.12 90.89,90.12 90.44,90.57 89.75,90.57 88.69,91.63 88.69,92.32 87.06,93.95 74.68,93.95 72.61,91.88 69.03,91.88 68.14,92.78 59.71,92.78 57.49,95 v2(54.8,95)
PSID_DISABLE#: length 260.2
  TOP w0.102: UE1.A37 247.89,76.91 248.07,76.74 248.07,76.36 248.04,76.33 248.04,76.31 247.83,76.1 247.53,76.1 247.2,75.77 247.2,75.05 246.82,74.67 246.82,73.52 247.4,72.95 248.03,72.95 250.48,75.39 v2(250.48,75.85) ; v2(62.95,97.59) 62.95,97.24 61.96,96.24 PR11.2
  IN3 w0.122: v2(250.48,75.85) 250.49,75.85 250.9,76.26 250.9,77.31 250.67,77.53 250.67,79.07 250.97,79.37 250.97,80.68 252.64,82.36 253.89,82.36 254.52,82.99 254.52,84.39 255.26,85.13 255.26,90.09 255.52,90.34 255.52,90.96 253.01,93.47 251.15,93.47 249.22,95.4 249.22,96.72 246.25,99.69 246.1,99.84 245.36,100.58 243.99,101.94 243.23,101.94 237.64,101.94 237.34,102.24 232.5,102.24 231.95,102.78 230.21,102.78 230.06,102.63 229.05,102.63 227.74,103.94 214.11,103.94 213.24,103.07 209.02,103.07 207.04,101.09 207.04,99.94 201.5,94.39 199.93,94.39 199.86,94.32 192.18,94.32 188.86,97.64 181.86,97.64 181.02,98.48 178.75,100.75 178.75,107.78 178.22,108.31 178.22,108.62 178.22,109.04 176.83,110.42 158.82,110.42 156.6,108.2 149.28,108.2 148.52,107.44 145.81,107.44 145.24,108 136.2,108 134.64,109.56 133.75,109.56 132.9,110.41 128.95,110.41 127.05,108.51 127.05,104.64 119.41,97 118.12,97 117.4,97 116.3,95.9 116.3,94.35 115.35,93.39 111.12,93.39 110.64,93.88 110.49,94.03 107.03,94.03 106.5,94.03 106.09,94.44 104.33,94.44 101.34,97.43 92.85,97.43 92.12,98.16 80.43,98.16 79.22,96.95 63.59,96.95 v2(62.95,97.59)
PWM1_GT: length 15.1
  TOP w0.203: v2(86.07,64.29) 86.05,64.27 PU602.12
  TOP w0.254: v2(91.05,68.61) v3(91.96,68.61) 92.03,68.67 v2(95.11,68.67) 95.19,68.67 95.41,68.44 PR680.1
  IN1 w0.254: v2(86.07,64.29) 86.52,64.29 87.58,65.35 87.58,66.84 88.68,67.95 89.57,67.95 90.23,68.61 v2(91.05,68.61)
  BOTTOM w0.203: PU605.8 95.31,67.69 95.15,67.86 95.15,68.55 95.11,68.58 v2(95.11,68.67)
PWM_IA: length 21.2
  TOP w0.203: PU602.22 83.83,69.04 v2(84.16,69.37)
  IN1 w0.254: v2(90.65,78.05) 89.69,77.09 89.69,74.12 89.9,73.91 89.9,73.1 90.46,72.54 90.46,70.47 89.24,69.24 85.64,69.24 84.97,69.9 84.44,69.9 84.16,69.63 v2(84.16,69.37)
  BOTTOM w0.203: v2(90.65,78.05) 90.26,77.65 89.39,77.65 PR662.1 88.66,77.93 88.66,77.12 88.91,76.86 PU603.8
PWM_VSA: length 30.6
  TOP w0.203: v2(79.26,69.32) 79.92,68.66 80.5,68.66 80.63,68.53 PU602.30
  IN1 w0.089: v2(99.87,79.12) 99.41,79.58 95.92,79.58 95.36,79.02 93.64,79.02 93.2,78.59 92.25,78.59 91.97,78.87 90.82,78.87 89.39,77.45 89.39,76.11 88.02,74.74 86.68,74.74 80.91,68.97 79.61,68.97 v2(79.26,69.32)
  BOTTOM w0.102: v2(99.87,79.12) 100.55,79.8 PU606.3
RD1_A_DE0: length 8.2
  TOP w0.102: UN4.6 228.04,32.69 v3(227.41,33.33) 227.16,33.57 RN38.1 227.06,34.29 226.38,34.98 226.38,36.35 226.73,36.71 227.24,36.71 227.54,37.01 227.54,38.13 RN25.2
RD1_A_DE1: length 3
  TOP w0.102: UN4.8 226.88,30.91 226.68,31.11 225.78,31.11 225.65,30.97 RN39.1 225.31,31.39 225.34,31.42 RN26.2
RD1_A_EQ0: length 4.2
  TOP w0.102: RN42.2 234.45,31.32 233.56,31.32 RN45.1 232.45,30.81 232.35,30.91 UN4.23
RD1_A_EQ1: length 2.8
  TOP w0.102: RN43.2 RN46.1 232.6,29.93 232.12,30.41 UN4.22
RD1_A_EQ2: length 4.7
  TOP w0.102: UN4.19 231.91,28.91 232.08,28.74 232.08,27.2 v3(231.92,27.04) 231.92,26.6 RN47.1 RN44.2
RD1_B_DE0: length 4.2
  TOP w0.102: UN4.13 228.04,27.63 227.9,27.49 227.11,27.49 v3(226.68,27.05) 226.12,26.49 RN40.1 RN27.2
RD1_B_DE1: length 4.2
  TOP w0.102: UN4.9 226.63,30.41 226.25,30.03 RN41.1 224.83,30.51 224.01,30.51 RN28.2
RD1_B_EQ0: length 4.5
  TOP w0.102: RN49.2 224.04,27.56 224.17,27.69 224.8,27.69 225.31,28.19 RN52.1 225.43,28.2 226.64,29.41 UN4.11
RD1_B_EQ1: length 4
  TOP w0.102: UN4.21 232.13,29.91 232.62,29.42 232.62,28.25 232.73,28.15 RN53.1 RN50.2
RD1_B_EQ2: length 3
  TOP w0.102: RN51.2 RN54.1 229.67,26.39 229.54,26.53 v3(229.54,27.02) UN4.16
RD1_REXT: length 2.3
  TOP w0.102: UN4.10 226.49,29.91 v1(226.19,29.61) 225.72,29.14 RN30.1
RD2_A_DE0: length 3.2
  TOP w0.102: UN5.6 239.37,31.6 v3(238.74,32.23) 238.59,32.38 RN59.1 RN55.2
RD2_A_DE1: length 5.3
  TOP w0.102: v3(235.84,33.15) RN60.1 236.86,33.1 RN56.2 237.04,31.68 237.61,31.11 237.61,30.37 238.11,29.87 UN5.8
RD2_A_EQ0: length 4.5
  TOP w0.102: UN5.23 243.13,29.87 243.88,30.62 v3(243.88,31.28) 244.03,31.43 RN66.1 244.86,31.43 RN63.2
RD2_A_EQ1: length 3.2
  TOP w0.102: RN67.1 RN64.2 243.6,29.65 243.32,29.37 UN5.22
RD2_A_EQ2: length 3.9
  TOP w0.102: UN5.19 243.05,27.87 v3(243.89,27.03) 244.07,26.86 RN68.1 244.86,26.86 RN65.2
RD2_B_DE0: length 3.6
  TOP w0.102: RN57.2 RN61.1 238.31,25.53 v3(238.75,25.97) 239.37,26.58 UN5.13
RD2_B_DE1: length 2.6
  TOP w0.102: UN5.9 238.08,29.37 237.55,29.9 RN62.1 RN58.2
RD2_B_EQ0: length 2.4
  TOP w0.102: UN5.11 237.75,28.37 237.51,28.13 RN72.1 RN69.2
RD2_B_EQ1: length 3.1
  TOP w0.102: UN5.21 v3(243.88,28.87) 244.32,28.87 244.44,28.76 RN70.2 RN73.1
RD2_B_EQ2: length 3
  TOP w0.102: RN71.2 RN74.1 240.98,25.56 240.87,25.67 v3(240.87,25.97) UN5.16
RD2_REXT: length 1.5
  TOP w0.102: RN31.1 237.47,29.02 237.61,28.87 UN5.10
REM_DIODE1_N: length 203.5
  TOP w0.127: v2(269.76,63.5) 269.83,63.5 270.04,63.29 UE2.B13 ; CE24.1 273.21,64.72 v2(272.86,64.37) ; v2(143.6,63.4) 143.78,63.22 143.78,63.05 143.64,62.92 143.04,62.92 CE35.1 142.3,63.66 141.09,63.66 QE3.3
  IN1 w0.127: v2(248.35,67.57) 248.55,67.77 249.49,67.77 250.71,68.99 253.21,68.99 253.64,68.57 257.42,68.57 257.82,68.96 259.73,68.96 260.21,69.45 264.71,69.45 265.57,68.58 270.8,68.58 272.13,67.25 274.12,67.25 274.62,66.75 274.62,66.12 274.83,65.92 274.83,65.48 273.72,64.37 v2(272.86,64.37) 272.71,64.52 271.86,64.52 270.84,63.5 v2(269.76,63.5)
  IN2 w0.127: v2(248.35,67.57) 248.07,67.29 248.07,63.81 247.89,63.64 247.89,63.11 248.01,62.99 248.01,59.52 248.28,59.26 248.28,57.7 247.85,57.27 247.85,54.88 244.5,51.53 243.56,51.53 241.81,49.79 241.81,45.82 241.45,45.46 241.45,43.19 240.79,42.54 240.79,41.79 239.95,40.95 236.7,40.95 236.12,41.53 230.21,41.53 229.76,41.98 222.62,41.98 222.11,42.49 218.73,42.49 218.2,41.96 217.31,41.96 213.19,37.83 196.65,37.83 189.15,45.34 186.4,45.34 185.5,46.24 174.11,46.24 170.87,49.49 170.87,51.26 172.49,52.88 172.49,53.15 173.03,53.69 175.41,53.69 176.12,52.98 176.85,52.98 178.83,54.95 178.83,56.46 v2(178.95,56.58)
  IN4 w0.127: v2(143.6,63.4) 143.75,63.25 143.75,62.97 144.06,62.67 145.22,62.67 146.01,61.88 150.86,61.88 151.47,61.27 162.38,61.27 162.71,61.6 163.94,61.6 164.21,61.33 165.17,61.33 165.34,61.51 167.4,61.51 169.08,59.83 169.56,59.83 170.09,60.37 170.5,60.37 173.25,57.61 178.87,57.61 179.46,57.02 179.46,56.87 179.17,56.58 v2(178.95,56.58)
REM_DIODE1_P: length 203.2
  TOP w0.127: v2(144.18,63.38) 144.03,63.22 144.03,62.95 143.75,62.67 143.24,62.67 CE35.2 142.03,63.01 QE3.2 141.49,62.76 141.49,61.51 QE3.1 ; UE2.A13 272.64,63.54 272.91,63.81 CE24.2 273.82,63.81 274.1,63.53 v2(274.1,63.15)
  IN1 w0.127: v2(248.37,68.23) 248.58,68.03 249.39,68.03 250.61,69.24 253.32,69.24 253.74,68.82 257.31,68.82 257.71,69.22 259.63,69.22 260.11,69.7 264.81,69.7 265.67,68.84 270.91,68.84 272.24,67.5 274.23,67.5 274.88,66.85 274.88,66.23 275.08,66.02 275.08,65.37 274.1,64.39 v2(274.1,63.15)
  IN2 w0.127: v2(179.4,56.17) 179.08,55.85 179.08,54.84 176.96,52.72 176.01,52.72 175.3,53.43 173.13,53.43 172.74,53.04 172.74,52.78 171.12,51.16 171.12,49.59 174.22,46.5 185.6,46.5 186.51,45.59 189.25,45.59 196.75,38.09 213.08,38.09 217.21,42.21 218.1,42.21 218.63,42.75 222.21,42.75 222.72,42.24 229.86,42.24 230.32,41.78 236.23,41.78 236.8,41.21 239.85,41.21 240.54,41.9 240.54,42.64 241.2,43.3 241.2,45.56 241.56,45.92 241.56,49.89 243.45,51.79 244.39,51.79 247.6,54.99 247.6,57.38 248.02,57.8 248.02,59.16 247.76,59.42 247.76,62.89 247.64,63.01 247.64,63.74 247.81,63.92 247.81,67.67 v2(248.37,68.23)
  IN4 w0.127: v2(179.4,56.17) 179.4,56.45 179.71,56.76 179.71,57.13 178.98,57.87 173.36,57.87 170.61,60.62 169.99,60.62 169.46,60.09 169.18,60.09 167.51,61.76 165.24,61.76 165.06,61.58 164.31,61.58 164.05,61.85 162.6,61.85 162.27,61.52 151.57,61.52 150.96,62.13 146.11,62.13 145.33,62.92 144.16,62.92 144,63.08 144,63.2 v2(144.18,63.38)
REM_DIODE2_N: length 210
  TOP w0.127: QE5.3 254.95,14.2 254.95,13.82 CE37.2 254.95,13.31 254.95,12.45 252.75,10.25 252.25,10.25 v2(252.01,10.01) ; UE2.B14 270.26,63.79 269.94,64.11 v2(269.76,64.11) ; CE26.1 272.5,66.3 272.15,65.94 v2(272.15,65.69)
  IN2 w0.127: v2(272.15,65.69) 272.3,65.54 273.8,65.54 275.45,63.88 275.45,55.63 274.22,54.4 274.22,52.61 272.99,51.39 272.99,47.92 270.43,45.35 270.43,43.54 270.71,43.27 270.71,39.61 269.56,38.47 269.56,34.21 268.74,33.38 268.74,30.56 267.43,29.25 267.43,23.08 266.91,22.55 266.91,14.58 269.07,12.42 269.07,10.29 267.66,8.87 263.29,8.87 261.36,6.94 255.62,6.94 254.47,5.8 253.63,5.8 252.34,7.09 252.34,8.59 253.02,9.28 253.02,9.65 253.02,9.83 252.59,10.27 252.26,10.27 v2(252.01,10.01) 251.65,10.37 245.15,10.37 239.52,16 232.91,16 232.75,16.16 232.17,16.16 232.04,16.03 232.04,15.85 v2(232.2,15.69)
  BOTTOM w0.127: CE46.2 151.89,24.3 QE7.2 153.84,25.34 154.29,25.34 QE7.1 155.09,25.34 156.17,25.34 157.77,23.75 193.5,23.75 194.23,24.48 223.65,24.48 224.73,23.4 227.54,23.4 230.06,20.88 230.06,15.7 230.77,14.99 231.74,14.99 231.99,15.24 231.99,15.49 v2(232.2,15.69) ; v2(272.15,65.69) 271.82,65.69 270.24,64.11 v2(269.76,64.11)
REM_DIODE2_P: length 207.2
  TOP w0.127: UE2.A14 271.67,64.04 272.05,64.42 272.05,64.98 v2(272.15,65.08) 272.48,65.08 CE26.2 ; QE5.1 254.75,15.3 QE5.2 254.47,14.28 254.47,13.75 CE37.1 254.55,13.31 254.55,12.4 252.66,10.52 252.26,10.52 v2(252.06,10.72)
  IN2 w0.127: v2(272.15,65.08) 272.35,65.28 273.69,65.28 275.2,63.78 275.2,55.74 273.96,54.5 273.96,52.72 272.74,51.5 272.74,48.02 270.18,45.46 270.18,43.44 270.45,43.16 270.45,39.72 269.31,38.57 269.31,34.31 268.48,33.49 268.48,30.66 267.17,29.35 267.17,23.18 266.65,22.66 266.65,14.48 268.82,12.31 268.82,10.39 267.55,9.12 263.18,9.12 261.25,7.19 255.51,7.19 254.37,6.05 253.74,6.05 252.59,7.2 252.59,8.49 253.28,9.17 253.28,9.55 253.28,9.94 252.69,10.52 252.31,10.52 252.1,10.72 v2(252.06,10.72) 251.95,10.62 245.25,10.62 239.62,16.25 233.02,16.25 232.85,16.41 232.06,16.41 231.79,16.14 231.79,16 v2(231.53,15.74)
  BOTTOM w0.127: CE46.1 151.78,25.6 QE7.3 156.28,25.6 157.87,24.01 193.4,24.01 194.12,24.73 223.76,24.73 224.83,23.65 227.64,23.65 230.31,20.98 230.31,15.8 230.87,15.24 231.63,15.24 231.74,15.35 231.74,15.54 v2(231.53,15.74)
REM_DIODE4_N: length 309.1
  TOP w0.127: UE2.A16 271.16,65.24 271.16,66.33 271,66.48 271,67.72 270.66,68.06 v2(270.39,68.06) 270.39,68.63 CE27.1 ; v2(104.05,68.7) 102.35,70.4 101.73,70.4 QE6.3 101.34,70.02 100.45,70.02 100.14,70.32 99.28,70.32 99.11,70.16 CE39.1
  IN2 w0.127: v2(270.39,68.06) 270.56,67.9 270.75,67.9 270.9,68.05 270.9,68.55 270.63,68.83 267.87,68.83 267.55,68.51 267.55,66.83 267.28,66.57 267.28,63.73 266.77,63.22 266.77,63.11 266.76,63.11 266.76,56.95 266.34,56.53 265.22,56.53 264.7,56.02 264.34,55.66 262.29,55.66 258.93,52.29 258.93,46.8 259.13,46.6 259.13,44.49 258.44,43.8 258.44,42.61 258.2,42.37 258.2,37.66 257.84,37.29 257.84,35.18 256.83,34.17 256.83,31.02 255.61,29.8 252.29,29.8 251.94,29.45 250.73,29.45 250.73,29.45 250.21,29.45 246.54,25.78 239.94,25.78 239.33,25.17 237.84,25.17 237.64,24.97 235.31,24.97 232.87,27.4 226.13,27.4 223.97,29.56 222.45,29.56 222.16,29.27 221.01,29.27 219.87,28.14 206.49,28.14 203.12,31.51 192.42,31.51 187.83,36.1 105.2,36.1 99.98,30.88 86.86,30.88 86.14,31.6 86.14,39.13 86.65,39.63 86.65,41.58 95.25,50.18 95.25,58.45 93.33,60.37 88.58,60.37 86.3,62.65 85.53,62.65 84.66,63.53 84.66,64.28 84.66,64.28 84.66,64.74 85.13,65.21 85.13,68.3 85.89,69.05 89.31,69.05 89.83,69.58 103.18,69.58 v2(104.05,68.7)
REM_DIODE4_P: length 308.8
  TOP w0.127: CE39.2 98.71,69.26 99.2,69.75 QE6.1 101.07,69.75 QE6.2 103.19,69.1 103.47,68.82 v2(103.47,68.67) ; UE2.B17 270.74,65.29 270.9,65.46 270.9,66.22 270.75,66.37 270.75,67.26 270.55,67.47 v2(270.45,67.47) 270.27,67.47 269.96,67.77 269.96,68.25 270.12,68.41 270.12,69.4 270.47,69.75 CE27.2
  IN2 w0.127: v2(270.45,67.47) 270.62,67.64 270.85,67.64 271.16,67.95 271.16,68.66 270.73,69.08 267.76,69.08 267.3,68.61 267.3,66.94 267.03,66.67 267.03,63.84 266.51,63.32 266.51,63.22 266.51,63.22 266.51,57.06 266.24,56.79 265.11,56.79 264.45,56.12 264.23,55.91 262.19,55.91 258.67,52.4 258.67,46.7 258.88,46.49 258.88,44.6 258.19,43.91 258.19,42.72 257.95,42.48 257.95,37.76 257.59,37.4 257.59,35.29 256.58,34.28 256.58,31.12 255.51,30.05 252.19,30.05 251.84,29.7 250.84,29.7 250.1,29.7 246.43,26.04 239.84,26.04 239.23,25.43 237.74,25.43 237.54,25.23 235.41,25.23 232.98,27.66 226.24,27.66 224.08,29.82 222.34,29.82 222.06,29.53 220.91,29.53 219.77,28.39 206.6,28.39 203.22,31.77 192.52,31.77 187.94,36.35 105.1,36.35 99.88,31.13 86.97,31.13 86.4,31.7 86.4,39.02 86.9,39.53 86.9,41.47 95.5,50.08 95.5,58.56 93.44,60.62 88.69,60.62 86.4,62.91 85.64,62.91 84.91,63.63 84.91,64.17 84.91,64.17 84.91,64.64 85.38,65.1 85.38,65.31 85.38,65.32 85.38,68.19 85.99,68.8 89.41,68.8 89.93,69.32 103.05,69.32 103.47,68.9 v2(103.47,68.67)
RES_BIAS: length 2.8
  TOP w0.102: RL13.1 260.49,82.78 260.49,84.56 260.66,84.73 UL1.12
RESET_OUT#: length 329.5
  TOP w0.102: RE56.2 258.02,62.96 v2(258.59,62.96) ; v2(91.96,35.99) 92.12,35.83 v3(92.95,35.83) 94.04,35.83 94.94,36.73 94.94,37.41 94.04,38.3 94.04,38.41 RC129.1 ; UE2.B39 262.38,63.29 262.62,63.53 v2(262.62,63.68)
  IN1 w0.089: v2(262.62,63.68) 262.62,63.78 262.23,64.18 261.64,64.18 261.62,64.15 261.56,64.15 260.76,63.35 258.98,63.35 v2(258.59,62.96) 257.58,62.96 257.11,63.43 255.35,63.43 254.93,63.85 250.62,63.85 250.33,64.13 250.16,64.13 250.15,64.15 248.97,64.15 248.72,63.9 240.18,63.9 239.21,62.93 237.92,62.93 237.51,62.53 234.85,62.53 234.11,63.27 234.11,68.94 233.93,69.12 233.93,69.68 233.93,72.42 233.93,73.01 232.47,74.47 232.47,74.66 228.27,78.86 223.25,78.86 223.25,78.86 222.86,78.86 222.05,79.67 209,79.67 207.39,81.28 205.55,81.28 205.53,81.27 205.2,81.27 205.08,81.15 203.92,81.15 203.86,81.15 202.12,81.15 201.03,80.06 198.63,80.06 197.72,79.15 192.01,79.15 191.53,78.67 189.29,78.67 186.09,75.47 180.8,75.47 178.58,77.69 174.95,77.69 v2(174.64,77.37)
  IN3 w0.122: v2(91.96,35.99) 93.88,34.08 103.03,34.08 105.68,36.73 125.56,36.73 128.09,34.2 209.05,34.2 209.31,33.94 213.91,33.94 214.62,33.23 217.12,33.23 217.58,33.69 219.43,33.69 222.44,36.7 227.32,36.7 227.89,37.27 230.47,37.27 231.58,38.38 237.3,38.38 237.63,38.05 237.66,38.05 237.99,37.72 240.05,37.72 241.26,38.93 246.99,38.93 248.17,37.75 253.28,37.75 255.31,39.78 256.09,39.78 257.8,41.48 257.8,45.72 257.97,45.9 260.82,45.9 261.63,46.71 261.63,48.49 260.79,49.34 260.79,51.97 260.91,52.09 260.91,53.43 260.9,53.43 260.9,54.07 260.9,55.09 257.82,58.17 257.82,61.73 257.34,62.2 257.34,64.89 257.69,65.23 258.13,65.23 258.52,64.84 260.19,64.84 261.78,63.25 262.29,63.25 262.62,63.59 v2(262.62,63.68)
  BOTTOM w0.076: UC1.B6 170.78,76.45 170.78,76.61 171.03,76.87 171.21,76.87 171.43,77.09 171.43,77.29 171.77,77.63 174.38,77.63 v2(174.64,77.37)
RESET_OUT#_R: length 5.9
  TOP w0.102: JXDP1.47 91.11,41.42 90.89,41.2 90.89,40.59 91.06,40.43 91.63,40.43 92.23,39.83 CC33.1 92.54,38.99 RC129.2 RC128.2
RING2:
  vias: v2(283.35,32.36) v2(283.88,32.08) v2(287.9,32.44) v2(288.5,32.41) v3(287.98,33.01)
RING2_R: length 17.4
  IN2 w1.27: 294.2,30.22 294.2,24.19 292.82,22.82 292.82,20.65 293.37,20.11 299.88,20.11
  vias: v2(294.02,31.86) v2(294.65,31.86) v3(293.01,34.34)
RJ45_MDIN0: length 8.8
  BOTTOM w0.229: JLOM1.2 272.25,100.17 271.67,100.17 271.12,99.62 269.93,99.62 266.83,96.52 266.83,96.31 267.29,95.84 TL1.14
RJ45_MDIN1: length 8.9
  TOP w0.229: JLOM1.6 275.59,99.03 274.54,99.03 274.32,98.81 274.32,98.32 274.42,98.22 v2(274.71,98.22)
  BOTTOM w0.229: TL1.18 272.37,95.96 271.91,96.42 271.91,96.6 272.46,97.15 273.69,97.15 274.23,97.7 274.23,97.99 274.46,98.22 v2(274.71,98.22)
RJ45_MDIN2: length 7.1
  BOTTOM w0.229: TL1.20 274.91,95.75 274.47,96.2 274.47,96.37 274.77,96.68 275.26,96.68 275.94,97.36 275.94,98.87 275.62,99.19 275.62,100.1 275.51,100.21 JLOM1.5
RJ45_MDIN3: length 6.7
  BOTTOM w0.229: JLOM1.8 278.32,100.22 278.02,100.22 277.77,99.97 277.77,98.71 279.44,97.03 279.44,96.61 279.99,96.06 TL1.24
RJ45_MDIP0: length 8.8
  BOTTOM w0.229: JLOM1.1 271.43,100.42 270.98,99.97 269.79,99.97 266.49,96.67 266.49,96.32 266.02,95.86 TL1.13
RJ45_MDIP1: length 8.9
  TOP w0.229: v2(273.36,98.29) 273.82,98.29 273.98,98.45 273.98,98.97 273.47,99.48 JLOM1.3
  BOTTOM w0.229: v2(273.36,98.29) 273.59,98.29 273.89,97.99 273.89,97.84 273.54,97.49 272.32,97.49 271.57,96.74 271.57,96.54 271.1,96.07 TL1.17
RJ45_MDIP2: length 7.1
  BOTTOM w0.229: TL1.19 273.64,95.82 274.13,96.3 274.13,96.52 274.63,97.02 275.11,97.02 275.59,97.5 275.59,98.73 275.28,99.05 275.28,99.96 274.97,100.27 274.8,100.27 JLOM1.4
RJ45_MDIP3: length 6.8
  BOTTOM w0.229: JLOM1.7 277.55,100.24 277.42,100.11 277.42,98.56 279.1,96.89 279.1,96.7 278.72,96.33 TL1.23
RUN_ON: length 159.1
  TOP w0.102: UZ4.3 244.56,46.04 v2(244.66,45.93) ; RE280.2 257.19,64.17 257.19,65.72 v2(256.93,65.98) 256.3,65.98 256.02,66.26 UE5.4 256.25,67.12 257.34,67.12 258.04,67.82 259.29,67.82 259.58,68.11 259.58,68.34 259.48,68.44 259.48,72.38 260.81,73.71 v1(265.41,73.71) 266,73.71 267.52,72.19 269.47,72.19 271.55,70.11 274.72,70.11 275.71,69.13 275.71,67.77 277.66,65.82 277.66,63.43 278.17,62.92 278.17,61.88 277.94,61.65 RPE10.2 276.7,61.65 276.39,61.34 275.83,61.34 RE292.1 275.4,60.41 v2(275.88,60.41) ; PR402.1 206.65,50.46 v2(206.74,50.37) ; UZ3.3 250.42,39.72 v2(250.79,40.09) ; QE2.2 253.17,67.9 253.5,67.57 253.5,67 v2(253.96,66.54)
  IN1 w0.089: v2(206.74,50.37) 207.14,49.97 207.14,48.38 207.61,47.91 208.8,47.91 209.35,47.35 213.98,47.35 214.7,46.64 215.17,46.64 216.03,45.78 220.85,45.78 221.35,45.28 223.29,45.28 224.34,44.23 236.97,44.23 237.4,44.66 238.52,44.66 239.62,45.76 243.25,45.76 243.42,45.93 v2(244.66,45.93) ; v2(256.93,65.98) 254.63,65.98 254.08,66.54 v2(253.96,66.54)
  IN3 w0.122: v2(275.88,60.41) 274.93,61.36 273.55,61.36 272.93,61.97 270.92,61.97 270.63,62.27 270.32,62.57 268.14,62.57 268.03,62.46 264.02,62.46 263.52,62.96 263.52,63.5 262.83,64.19 261.78,64.19 260.55,65.43 260.34,65.43 260.09,65.67 258.75,65.67 258.28,66.14 257.51,66.14 257.34,65.98 v2(256.93,65.98) 256.43,65.98 255.23,64.78 255.23,56.57 256.83,54.97 256.83,53.78 257.29,53.31 257.29,50.32 257.54,50.07 257.54,46.18 257.29,45.93 257.29,41.71 255.87,40.29 255.06,40.29 253.41,38.64 251.82,38.64 250.95,39.51 250.95,39.92 v2(250.79,40.09)
  IN4 w0.089: v2(250.79,40.09) 250.79,41.06 250.22,41.62 249.24,41.62 248.07,42.8 247.66,42.8 245.73,44.72 245.73,44.89 244.69,45.93 v2(244.66,45.93)
RUN_ON#: length 3.4
  TOP w0.102: RE68.2 253.37,70.67 253.17,70.46 QE2.5 QE2.6 252.26,69.97 252.13,69.84 v3(251.02,69.84)
RUN_ON_EC: length 25.6
  TOP w0.102: v2(256.35,63.99) 255.51,63.99 255.37,64.13 UE5.2 ; v2(273.29,60.13) 273.82,60.66 RE292.2 ; UE2.B9 269.34,61.29 268.9,61.73 268.9,62 v2(268.77,62.13)
  IN4 w0.089: v2(268.77,62.13) 268.26,62.64 265.08,62.64 264.94,62.78 261.1,62.78 260.85,62.53 259.46,62.53 259.3,62.36 259.3,61.78 259.1,61.57 258.51,61.57 257.22,62.86 257.22,63.22 256.46,63.99 v2(256.35,63.99)
  BOTTOM w0.102: v2(268.77,62.13) 268.77,61.83 269.4,61.19 270.37,61.19 270.98,60.58 272.83,60.58 v2(273.29,60.13)
RUNPWROK: length 271.4
  TOP w0.102: UC8.1 98.79,42.57 98.69,42.47 98.69,42.17 v2(98.89,41.96) ; v2(95.47,34.56) 96.78,35.87 v1(96.78,39.5) 96.78,42.29 97.12,42.63 v2(97.65,42.63) 97.75,42.63 98.51,43.38 99.44,43.38 99.67,43.61 UC8.13 ; UE2.B26 265.9,65.46 265.72,65.28 v2(265.72,65.03) ; v2(102.2,44.38) 101.83,44.75 101.8,44.75 101.8,44.75 101.52,44.75 101.17,44.4 UC8.10 ; v2(252.06,88.9) 251.89,88.74 UE1.A4 ; QE2.3 253.82,68.56 253.59,68.79 RE67.2 251.17,67.89 252.51,66.56 v2(253.27,66.56) ; v2(100.85,40.64) 100.67,40.82 UC8.4
  IN1 w0.089: v2(97.65,42.63) 98.23,42.63 v2(98.89,41.96) 99.27,41.96 100.6,40.64 v2(100.85,40.64) 102.17,41.96 102.17,44.35 v2(102.2,44.38)
  IN2 w0.122: 253.27,66.56 v2(253.27,66.56) ; 253.27,66.56 253.27,66.78 253.61,67.11 253.61,67.67 253.31,67.97 253.31,68.8 253.17,68.94 253.17,72.28 254.15,73.26 254.15,75.28 253.19,76.23 253.19,76.64 252.38,77.46 252.38,80.12 252.73,80.47 252.73,86.56 252.06,87.23 v2(252.06,88.9) ; 253.27,66.56 253.19,66.47 253.19,65.69 253.2,65.68 253.35,65.54 253.35,62.47 252.85,61.98 252.85,61.66 251.62,60.43 v2(251.62,59.82) ; v2(247.03,39.86) 246.8,39.86 240.35,33.41 236.45,33.41 234.8,35.06 234.8,35.49 233.86,36.42 232.45,36.42 230.77,34.75 227.18,34.75 226.79,34.36 225.3,34.36 223.41,32.46 221.24,32.46 220.32,31.55 220.32,30.81 219.65,30.14 207.04,30.14 204.19,33 193.86,33 188,38.86 164.67,38.86 164.47,38.66 162.47,38.66 162.27,38.86 105.99,38.86 101.69,34.56 v2(95.47,34.56)
  IN3 w0.122: v2(265.72,65.03) 265.67,64.98 265.64,64.98 265.31,64.65 265.31,64.19 265.09,63.96 264.68,63.96 264.43,64.22 264.43,65.46 263.69,66.19 261.06,66.19 259.97,67.29 254,67.29 v2(253.27,66.56)
  BOTTOM w0.102: v2(251.62,59.82) 251.49,59.82 249.42,57.75 248.07,57.75 247.46,57.14 247.46,54.67 246.14,53.36 246.14,51.55 247.46,50.24 247.46,47.37 247.46,47.18 246.74,46.46 246.74,45.75 246.9,45.59 246.9,43.74 244.95,41.79 244.74,41.58 244.74,40.53 245.41,39.86 v2(247.03,39.86)
S5_1.2V: length 2.4
  BOTTOM w0.203: PU201.8 95.03,54.31 PR208.2 PC214.1
SA_LGATE: length 5.5
  IN2 w0.762: 105.78,83.11 105.73,83.06 100.29,83.06
  vias: v2(99.43,83.1) v2(99.91,84.04) v2(106.84,83.16) v2(107.43,83.16)
SA_SNUB:
  vias: v3(112.77,83.19)
SA_SW: length 5
  BOTTOM w0.254: PR624.1 110.79,85.52 110.79,82.81 110.48,82.5 PL601.1
  vias: v2(107.63,82) v2(107.63,81.36) v3(112.75,81.01)
SA_UGATE: length 3.5
  IN2 w0.762: 106.01,80.34 105.42,80.93 102.73,80.93 102.73,80.92
  vias: v2(102.03,81.26) v2(102.03,80.67) v2(106.87,80.57) v2(107.48,80.57)
SATA_LED: length 98
  TOP w0.094: v3(275.53,3.72) 277.34,3.72 279.65,6.03 v2(279.65,7.96) JLED1.3
  IN2 w0.122: v2(279.65,7.96) 279.12,8.5 279.12,10.31 277.03,12.4 276.39,12.4 273.65,15.14 273.65,16.08 272.63,17.1 272.63,20.78 271.53,21.88 271.53,25.15 270.85,25.83 270.85,31.32 271.31,31.78 271.54,31.78 272.16,32.41 272.16,34.23 274.81,36.88 274.81,37.22 274.88,37.3 274.88,40.05 274.81,40.13 274.81,44.04 277.69,46.92 277.69,46.96 277.76,47.02 277.76,50.85 278.72,51.82 278.87,51.96 279.38,52.47 280.28,52.47 281.4,53.58 281.4,58.59 281.24,58.74 281.24,63.33 284.65,66.73 v2(285.34,66.73)
  BOTTOM w0.094: v2(285.34,66.73) 285.34,66.61 285.77,66.18 289.87,66.18 290.39,66.69 290.39,68.69 291.38,69.69 291.38,71.66 290.03,73.02 288.9,73.02 288.04,73.88 284.15,73.88 283.9,73.63 QZ4.3
