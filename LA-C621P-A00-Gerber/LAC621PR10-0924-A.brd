# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D50: length 90.6
  IN4 w0.076: 160.31,54.48 160.32,54.48 161.17,53.63 161.17,52.79 163.49,50.47 163.49,49.82 163.67,49.64 ; 159.04,55.75 158.96,55.83 158.96,56.59 158.88,56.68 158.88,57.3 158.35,57.84 v2(158.35,57.95)
  IN4 w0.084: 160.31,54.48 159.04,55.75
  IN4 w0.089: 163.67,49.64 163.84,49.47 163.85,49.47 168.75,44.57 175.84,44.57 176.91,43.51 185.26,43.51 186.08,42.69 201.55,42.69 215.47,28.77 215.47,27.12 215.86,26.73 215.86,25.48 215.86,21.23 217.77,19.33 217.77,16.36 218.12,16.01 218.38,16.01 218.81,15.57 218.81,14.41 v2(218.15,13.75)
  BOTTOM w0.076: UC1.AT25 v2(158.35,57.95)
  BOTTOM w0.102: v2(218.15,13.75) 218.62,13.27 JDIMM2.224
DDR_B_D51: length 89.9
  IN4 w0.084: 162.53,51.15 160.29,53.4 160.29,54.27 158.76,55.79 158.76,56.56 158.71,56.61 158.71,56.95 v2(158.35,57.32)
  IN4 w0.089: v2(218.25,15.42) 217.72,15.42 217.39,15.75 217.39,18.33 217.38,18.33 217.38,19.28 215.55,21.11 215.55,25.61 215.56,25.61 215.56,26.6 215.16,26.99 215.16,28.64 201.42,42.39 185.95,42.39 185.14,43.2 176.78,43.2 175.72,44.27 168.62,44.27 163.72,49.17 163.72,49.17 162.93,49.96 162.93,50.76 162.53,51.15
  BOTTOM w0.076: UC1.AU25 v2(158.35,57.32)
  BOTTOM w0.102: JDIMM2.228 219.62,12.98 219.14,13.47 219.14,14.53 v2(218.25,15.42)
DDR_B_D52: length 92.4
  IN4 w0.076: v2(157.44,59.22) 157.07,58.85 157.07,57.71 156.86,57.51 156.86,55.96 158.52,54.3 158.52,53.71 161.38,50.85 161.38,49.23
  IN4 w0.089: v2(214.84,17.86) 214.84,17.69 214.76,17.61 214.35,17.61 214.26,17.69 214.26,18 214.35,18.09 214.45,18.09 214.54,18.18 214.54,18.41 214.45,18.5 214.35,18.5 214.26,18.58 214.26,18.94 214.35,19.03 214.68,19.03 214.77,19.12 214.77,19.3 214.68,19.38 214.35,19.38 214.26,19.47 214.26,19.83 213.91,20.18 213.91,20.18 213.73,20.36 213.73,21.87 213.64,21.96 213.44,21.96 213.35,22.05 213.35,22.23 213.44,22.32 213.64,22.32 213.73,22.41 213.73,22.58 213.64,22.67 213.41,22.67 213.32,22.76 213.32,22.94 213.41,23.03 213.64,23.03 213.73,23.12 213.73,23.3 213.64,23.38 213.44,23.38 213.35,23.47 213.35,23.65 213.44,23.74 213.64,23.74 213.73,23.83 213.73,24.04 213.64,24.13 213.41,24.13 213.32,24.22 213.32,24.48 213.41,24.57 213.64,24.57 213.73,24.65 213.73,24.88 213.64,24.97 213.44,24.97 213.35,25.06 213.35,25.34 213.44,25.43 213.57,25.43 213.73,25.58 213.73,25.76 213.32,26.17 213.32,26.62 213,26.93 213,27.07 213,27.08 213,28.24 200.67,40.58 182.3,40.58 181.65,41.23 176.18,41.23 174.94,42.46 174.01,42.46 174.01,42.46 173.56,42.46 173.56,42.46 168.88,42.46 168.88,42.46 167.82,42.46 163.89,46.38 162.37,46.38 161.38,47.37 161.38,47.73 161.38,49.23
  BOTTOM w0.076: UC1.AP27 v2(157.44,59.22)
  BOTTOM w0.102: v2(214.84,17.86) 215.05,17.86 215.37,18.19 JDIMM2.211
DDR_B_D53: length 93.1
  IN4 w0.076: 161.07,49.06 161.07,50.92 158.35,53.65 158.35,54.22 156.68,55.89 156.68,57.58 156.9,57.8 156.9,59.32 v2(157.44,59.86)
  IN4 w0.089: v2(216.37,14.66) 213.96,17.07 213.96,19.7 213.78,19.88 213.42,20.24 213.42,21.37 213.02,21.77 213.02,26.49 212.7,26.81 212.7,27.2 212.7,28.12 200.54,40.27 182.17,40.27 181.52,40.92 176.05,40.92 174.82,42.16 173.89,42.16 168.75,42.16 167.69,42.16 163.77,46.08 162.24,46.08 161.07,47.25 161.07,47.44 161.07,49.06
  BOTTOM w0.076: UC1.AN27 v2(157.44,59.86)
  BOTTOM w0.102: JDIMM2.212 215.62,13.92 v2(216.37,14.66)
DDR_B_D54: length 92.5
  IN4 w0.076: 162.57,52.71 162.04,53.24 ; v2(158.35,59.86) 158.89,59.32 158.89,57.8 159.22,57.48 159.22,56.81 ; 164.95,49.23 164.91,49.28
  IN4 w0.084: 162.04,53.24 161.74,53.54 161.74,53.63 159.32,56.05 159.32,56.71 159.22,56.81 ; 162.57,52.71 164.65,50.63 164.65,49.81
  IN4 w0.089: v2(219.87,18.57) 219.87,18.44 219.62,18.19 219.3,18.19 219.21,18.28 219.21,18.89 219.12,18.98 218.87,18.98 218.78,18.89 218.78,17.77 218.69,17.68 218.46,17.68 218.38,17.77 218.38,19.58 217.68,20.28 217.68,20.4 217.95,20.67 217.95,20.8 217.83,20.92 217.7,20.92 217.43,20.65 217.3,20.65 217.18,20.78 217.18,20.9 217.45,21.17 217.45,21.3 217.32,21.43 217.2,21.43 216.93,21.16 216.8,21.16 216.47,21.49 216.47,25.23 216.47,25.23 216.47,26.47 216.47,26.73 216.47,26.98 216.08,27.37 216.08,29.02 201.8,43.3 199.29,43.3 186.33,43.3 185.51,44.12 178.03,44.12 176.31,45.84 168.35,45.84 164.95,49.23 ; 164.65,49.81 164.65,49.53 164.86,49.32 164.91,49.28
  BOTTOM w0.076: v2(158.35,59.86) 158.77,60.22 UC1.AN25
  BOTTOM w0.102: JDIMM2.229 v2(219.87,18.57)
DDR_B_D55: length 92.2
  IN4 w0.076: 163.98,51.04 162.16,52.86 162.01,52.86 ; v2(158.35,59.22) 158.72,58.85 158.72,57.7 159.05,57.37 159.05,56.74 159.13,56.66 159.13,55.99 159.22,55.91
  IN4 w0.084: 162.01,52.86 161.87,53 161.57,53.3 161.57,53.55 159.22,55.91
  IN4 w0.089: 163.98,51.04 164.15,50.87 164.15,49.61 168.25,45.51 176.21,45.51 177.9,43.81 185.39,43.81 186.21,43 199.41,43 201.67,43 215.77,28.9 215.77,27.25 216.16,26.85 216.16,26.6 216.16,25.35 216.16,21.36 218.07,19.45 218.07,16.63 218.16,16.54 218.41,16.54 218.5,16.63 218.5,17.28 218.59,17.36 218.96,17.36 219.28,17.05 v2(219.87,17.05)
  BOTTOM w0.076: UC1.AP25 v2(158.35,59.22)
  BOTTOM w0.102: JDIMM2.225 218.87,17.84 219.67,17.05 v2(219.87,17.05)
DDR_B_D56: length 95.6
  IN4 w0.076: v2(160.18,57.95) 160.18,57.83 159.81,57.46 159.81,57.1
  IN4 w0.084: 159.81,57.1 160.13,56.77 160.13,56.02 164.51,51.64
  IN4 w0.089: v2(222.16,16.39) 222.16,16.26 221.93,16.03 221.59,16.03 221.5,16.12 221.5,16.45 221.59,16.54 221.69,16.54 221.78,16.63 221.78,16.83 221.69,16.92 221.59,16.92 221.5,17.01 221.5,17.19 221.59,17.28 221.79,17.28 221.88,17.36 221.88,17.54 221.79,17.63 221.59,17.63 221.13,18.09 221.13,18.99 219.91,20.22 219.91,21.85 219.65,22.11 219.65,22.32 219.97,22.64 219.97,22.77 219.84,22.89 219.72,22.89 219.46,22.64 219.34,22.64 219.21,22.77 219.21,22.89 219.48,23.16 219.48,23.28 219.35,23.41 219.23,23.41 218.95,23.13 218.82,23.13 218.7,23.26 218.7,23.38 218.98,23.66 218.98,23.79 218.85,23.91 218.72,23.91 218.49,23.68 218.37,23.68 218.16,23.9 218.03,23.9 217.84,23.71 217.71,23.71 217.59,23.83 217.59,23.96 217.78,24.15 217.78,24.27 217.57,24.48 217.57,24.77 217.57,26.02 217.57,26.27 217.57,26.52 217.58,26.52 217.58,27.44 217.18,27.83 217.18,29.48 217.07,29.59 217.07,29.59 216.43,30.24 215.28,31.39 202.26,44.41 198.83,44.41 186.79,44.41 185.45,45.74 178.6,45.74 177.4,46.95 168.8,46.95 165.64,50.11 165.64,50.63 164.63,51.64 164.51,51.64
  BOTTOM w0.076: UC1.AT22 v2(160.18,57.95)
  BOTTOM w0.102: v2(222.16,16.39) 220.87,17.67 JDIMM2.233
DDR_B_D57: length 94.9
  IN4 w0.076: 162.43,53.97 162.43,53.96 162.89,53.51 162.94,53.51
  IN4 w0.084: v2(160.18,57.3) 160.18,57.16 161,56.34 161,55.4 162.43,53.97
  IN4 w0.089: v2(222.34,17.92) 222.2,18.06 221.61,18.06 221.53,18.15 221.53,18.41 221.61,18.5 221.75,18.5 221.84,18.58 221.84,19.15 221.71,19.27 221.59,19.27 221.5,19.18 221.37,19.18 221.24,19.31 221.24,19.43 221.33,19.53 221.33,19.65 221.21,19.78 221.08,19.78 220.99,19.69 220.87,19.69 220.74,19.81 220.74,19.94 220.91,20.11 220.91,20.33 220.83,20.41 220.71,20.41 220.49,20.19 220.36,20.19 220.21,20.34 220.21,20.85 220.3,20.94 220.78,20.94 220.87,21.03 220.87,21.21 220.78,21.3 220.3,21.3 220.21,21.39 220.21,21.56 220.3,21.65 220.78,21.65 220.87,21.74 220.87,21.92 220.78,22.01 220.3,22.01 220.21,22.1 220.21,22.28 220.3,22.36 220.78,22.36 220.87,22.45 220.87,22.79 220.64,23.01 220.51,23.01 220.44,22.94 220.31,22.94 220.18,23.06 220.18,23.19 220.26,23.27 220.26,23.39 220.14,23.52 220.01,23.52 219.93,23.44 219.81,23.44 219.68,23.56 219.68,23.69 219.76,23.77 219.76,23.89 219.63,24.02 219.51,24.02 219.43,23.94 219.3,23.94 219.18,24.07 219.18,24.19 219.26,24.27 219.26,24.4 219.13,24.52 218.9,24.52 218.51,24.13 218.38,24.13 218.23,24.28 218.23,24.4 218.7,24.88 218.7,24.95 218.58,25.08 218.4,25.08 218.11,24.78 217.98,24.78 217.88,24.88 217.88,25.06 218.15,25.33 218.15,25.51 217.88,25.77 217.88,25.89 217.88,26.39 217.88,27.56 217.49,27.96 217.49,29.61 217.38,29.72 202.38,44.71 198.7,44.71 186.92,44.71 185.58,46.05 178.73,46.05 177.52,47.25 168.94,47.25 165.95,50.25 165.95,50.78 164.71,52.02 164.43,52.02 162.94,53.51
  BOTTOM w0.076: UC1.AU22 v2(160.18,57.3)
  BOTTOM w0.102: v2(222.34,17.92) 222.34,17.92 222.34,17.94 221.87,18.4 JDIMM2.237
DDR_B_D58: length 94.2
  IN4 w0.084: 161.91,56.49 v2(161.09,57.3)
  IN4 w0.089: 161.91,56.49 161.91,56.39 162.94,55.35 163.21,55.35 164.04,54.51 164.04,53.67 164.8,52.92 165.9,52.92 165.9,52.91 166.08,52.74 166.15,52.74 167.73,51.16 167.73,50.6 169.87,48.45 178.02,48.45 179.23,47.25 186.08,47.25 187.41,45.91 198.21,45.91 201.13,45.91 201.63,45.91 202.88,45.91 215.9,32.89 218.78,30.01 218.78,28.36 219.08,28.06 219.08,26.27 219.63,25.72 219.76,25.72 220.32,26.28 220.45,26.28 220.57,26.15 220.57,26.03 220.01,25.46 220.01,25.34 220.14,25.21 220.26,25.21 220.99,25.94 221.12,25.94 221.24,25.81 221.24,25.69 220.78,25.23 220.51,24.96 220.51,24.84 220.64,24.71 220.77,24.71 221.28,25.23 221.51,25.45 221.63,25.45 221.76,25.32 221.76,25.2 221.02,24.46 221.02,24.33 221.14,24.21 221.27,24.21 221.92,24.86 222.05,24.86 222.17,24.73 222.17,24.61 221.52,23.96 221.52,23.83 221.65,23.7 221.77,23.7 222,23.94 222.13,23.94 222.25,23.81 222.25,23.68 222.02,23.45 222.02,23.33 222.21,23.14 222.21,20.98 223.87,19.32 v2(223.87,18.63)
  BOTTOM w0.076: UC1.AU21 v2(161.09,57.3)
  BOTTOM w0.102: JDIMM2.245 v2(223.87,18.63)
DDR_B_D59: length 95.3
  IN4 w0.084: v2(161.09,57.95) 161.09,57.83 162.1,56.82 162.1,56.81 162.1,56.44 162.94,55.6 163.56,55.6
  IN4 w0.089: 163.56,55.6 164.43,54.74 164.43,53.67 164.93,53.17 165.95,53.17 166.08,53.04 166.27,53.04 168.18,51.14 168.18,50.68 170.1,48.76 178.15,48.76 179.35,47.55 186.2,47.55 187.54,46.21 198.08,46.21 201,46.21 201.51,46.21 203.01,46.21 216.03,33.19 219.08,30.14 219.08,28.49 219.38,28.19 219.64,27.93 219.64,27.8 219.38,27.54 219.38,27.34 219.47,27.25 219.6,27.25 219.9,27.55 220.02,27.55 220.18,27.4 220.18,27.27 219.48,26.58 219.48,26.45 219.61,26.33 219.74,26.33 220.43,27.02 220.55,27.02 222.95,24.62 222.95,24.43 222.86,24.34 222.63,24.34 222.54,24.25 222.54,24.02 222.63,23.93 222.93,23.93 223.02,23.84 223.02,23.61 222.93,23.52 222.75,23.52 222.66,23.44 222.66,23.21 222.75,23.12 222.93,23.12 223.02,23.03 223.02,22.85 222.93,22.76 222.75,22.76 222.66,22.67 222.66,22.5 222.75,22.41 222.93,22.41 223.02,22.32 223.02,22.11 222.93,22.03 222.75,22.03 222.66,21.94 222.66,21.73 222.75,21.64 222.93,21.64 223.02,21.56 223.02,20.61 224.27,19.35 224.27,17.49 v2(223.89,17.1)
  BOTTOM w0.076: UC1.AT21 v2(161.09,57.95)
  BOTTOM w0.102: v2(223.89,17.1) 224.17,17.1 224.87,17.81 JDIMM2.249
DDR_B_D60: length 96.4
  IN4 w0.076: 164.88,50.73 164.95,50.66 164.95,49.93 165.36,49.53 ; 159.39,56.89 159.39,57.55 159.63,57.79 159.63,59.31 159.66,59.33 v2(160.18,59.86)
  IN4 w0.084: 159.39,56.89 159.5,56.78 159.5,56.11 162.65,52.96
  IN4 w0.089: 164.88,50.73 162.65,52.96 ; 165.36,49.53 168.55,46.34 176.61,46.34 178.34,44.61 180.42,44.61 185.72,44.61 186.54,43.8 199.08,43.8 202,43.8 215.02,30.78 215.44,30.36 216.17,29.63 216.17,29.63 216.46,29.34 216.57,29.23 216.57,27.58 216.97,27.18 216.97,26.77 216.97,26.52 216.97,26.27 216.96,26.27 216.96,25.02 216.96,22.5 217.05,22.41 217.28,22.41 217.41,22.54 217.54,22.54 217.66,22.41 217.66,22.28 217.49,22.12 217.49,21.99 217.62,21.87 217.75,21.87 217.91,22.03 218.04,22.03 218.16,21.91 218.16,21.78 217.98,21.6 217.98,21.48 218.11,21.35 218.24,21.35 218.42,21.53 218.54,21.53 218.67,21.4 218.67,21.28 218.45,21.06 218.45,20.94 218.58,20.81 218.7,20.81 218.92,21.03 219.04,21.03 219.17,20.9 219.17,20.09 220.52,18.74 220.52,17.62 220.89,17.25 220.89,16.62 220.18,15.9 220.18,13.29 220.43,13.03 v2(221.14,13.03)
  BOTTOM w0.076: v2(160.18,59.86) UC1.AN22
  BOTTOM w0.102: JDIMM2.236 221.62,12.55 v2(221.14,13.03)
DDR_B_D61: length 96.3
  IN4 w0.076: 159.94,55.92 159.94,56.58 159.64,56.88 159.64,57.55 159.81,57.71 159.81,58.85 v2(160.18,59.22)
  IN4 w0.084: 159.94,55.92 159.95,55.92 162.55,53.32
  IN4 w0.089: v2(221.07,14.56) 221.4,14.89 221.4,15.47 221.19,15.68 221.19,17.38 220.83,17.74 220.83,18.86 219.6,20.09 219.6,20.93 219.36,21.17 219.36,21.3 219.55,21.49 219.55,21.62 219.42,21.74 219.3,21.74 219.1,21.55 218.98,21.55 218.85,21.68 218.85,21.8 219.22,22.17 219.22,22.3 219.1,22.42 218.97,22.42 218.6,22.05 218.48,22.05 218.35,22.18 218.35,22.3 218.72,22.67 218.72,22.8 218.59,22.93 218.47,22.93 218.1,22.56 217.97,22.56 217.85,22.68 217.85,22.81 218.13,23.09 218.13,23.21 218,23.34 217.88,23.34 217.66,23.12 217.41,23.12 217.27,23.26 217.27,24.89 217.27,24.9 217.27,26.14 217.27,26.39 217.27,26.65 217.27,27.31 216.88,27.7 216.88,29.36 216.77,29.46 216.04,30.19 216.04,30.2 215.15,31.08 202.13,44.1 198.96,44.1 198.96,44.1 186.66,44.1 185.85,44.92 182.91,44.92 182.9,44.92 181.99,44.92 181.99,44.92 180.29,44.92 178.59,44.92 176.87,46.64 168.67,46.64 168.55,46.77 165.57,49.75 165.28,50.03 165.28,50.58 162.55,53.32
  BOTTOM w0.076: UC1.AP22 v2(160.18,59.22)
  BOTTOM w0.102: v2(221.07,14.56) 220.62,14.11 JDIMM2.232
DDR_B_D62: length 95.5
  IN4 w0.076: v2(161.94,59.27) 161.94,59.24 162.44,58.73 162.44,56.95 ; 166.2,53.65 165.55,53.65 165.51,53.61 165.21,53.61 164.93,53.88 164.93,55.07
  IN4 w0.089: 166.2,53.65 166.69,53.65 169.19,51.15 171.42,51.15 171.87,51.6 176.16,51.6 179.61,48.16 186.46,48.16 187.79,46.82 197.83,46.82 200.75,46.82 201.25,46.82 203.26,46.82 216.28,33.8 219.69,30.39 219.69,28.74 219.99,28.44 225.12,23.31 225.12,22.42 225.03,22.33 224.64,22.33 224.55,22.24 224.55,22.01 224.64,21.92 224.98,21.92 225.12,21.78 225.12,21.07 225.03,20.98 224.67,20.98 224.59,20.89 224.59,20.71 224.67,20.62 225.03,20.62 225.12,20.53 225.12,14.04 224.14,13.06 v2(224.12,13.06) ; 162.44,56.95 162.72,56.67 163.33,56.67 164.93,55.07
  BOTTOM w0.076: UC1.AP21 161.6,59.6 161.94,59.26 v2(161.94,59.27)
  BOTTOM w0.102: JDIMM2.246 v2(224.12,13.06)
DDR_B_D63: length 96.8
  IN4 w0.076: v2(161.09,59.86) 161.48,59.47 161.48,57.89 162.27,57.1 162.27,56.88 162.55,56.61 162.55,56.6 162.65,56.49 162.89,56.49 ; 164.68,54.94 164.68,53.8 165.06,53.42 166,53.42 166.08,53.35 166.2,53.35
  IN4 w0.089: 162.89,56.49 163.13,56.49 164.68,54.94 ; v2(224.09,14.61) 224.7,15.22 224.7,19.54 223.32,20.92 223.32,21.82 223.41,21.91 223.89,21.91 223.98,22 223.98,22.18 223.89,22.26 223.41,22.26 223.32,22.35 223.32,22.53 223.41,22.62 223.8,22.62 223.89,22.71 223.89,22.89 223.8,22.98 223.41,22.98 223.32,23.06 223.32,24.68 219.69,28.31 219.39,28.61 219.39,30.26 216.15,33.5 203.13,46.52 201.38,46.52 200.88,46.52 200.87,46.52 197.95,46.52 197.95,46.52 187.67,46.52 186.33,47.86 179.48,47.86 178.27,49.06 170.23,49.06 168.48,50.81 168.48,51.38 166.52,53.35 166.2,53.35
  BOTTOM w0.076: UC1.AN21 v2(161.09,59.86)
  BOTTOM w0.102: v2(224.09,14.61) 224.42,14.61 225.12,13.9 JDIMM2.250
DDR_B_DQS0: length 49.7
  IN1 w0.076: v2(152.04,50.45) 152.27,50.68 152.4,50.68 152.44,50.63 152.44,46.14 152.16,45.85 152.16,43.28 152.14,43.26 152.14,43.24
  IN1 w0.102: v2(163.28,16.62) 162.97,16.93 162.76,16.93 162.52,17.17 162.52,19.64 162.12,20.04 152.14,30.02 152.14,30.18 152.14,30.18 152.14,43.24
  BOTTOM w0.076: v2(152.04,50.45) 152.04,50.46 151.9,50.6 151.6,50.6 151.35,50.85 151.35,54.21 151.45,54.36 151.47,54.4 151.47,54.63 151.43,54.77 151.43,54.97 151.48,55.09 151.48,55.27 151.41,55.43 151.41,55.6 151.52,55.83 151.57,55.88 151.63,55.93 151.72,55.93 151.77,55.98 UC1.AY38
  BOTTOM w0.102: v2(163.28,16.62) 163.46,16.8 163.65,16.8 164.12,17.27 164.12,18.76 163.87,19 JDIMM2.13
DDR_B_DQS1: length 53.1
  IN1 w0.076: 155.86,43.24 155.86,44.08 155.23,44.71 155.23,47.59 155.46,47.82 155.6,47.82 155.83,47.59 v2(155.83,47.46)
  IN1 w0.102: v2(169.23,14.25) 169.12,14.25 168.9,14.48 168.9,14.8 168.7,14.99 168.7,19.06 168.48,19.28 168.28,19.28 168.18,19.38 168.18,19.69 168.28,19.79 168.48,19.79 168.7,20 168.7,20.47 164.51,24.66 164.51,26.02 161.97,28.56 161.16,29.38 161.16,29.38 155.86,34.68 155.86,43.24
  BOTTOM w0.076: UC1.BA34 154.22,55.71 154.28,55.77 154.4,55.77 154.44,55.73 154.51,55.56 154.51,55.47 154.45,55.3 154.45,55.05 154.5,54.93 154.5,54.79 154.46,54.65 154.46,53.52 154.52,53.45 154.6,53.37 154.6,53.37 154.65,53.32 154.65,49.74 154.74,49.65 154.74,49.08 154.73,49.06 154.73,49.05
  BOTTOM w0.102: v2(169.23,14.25) 169,14.02 169,12.76 169.12,12.63 JDIMM2.34 ; 154.73,49.05 154.73,47.95 155.07,47.61 155.68,47.61 v2(155.83,47.46)
DDR_B_DQS2: length 92
  IN4 w0.076: 153.78,48.7 153.78,48.72 153.8,48.74 153.8,52.38 153.03,53.14 153.03,53.95 151.27,55.71 151.27,56.32 150.55,57.04 150.55,57.05 150.52,57.08 150.52,58.23 150.68,58.4 150.91,58.4 151.09,58.57 v2(151.09,58.57)
  IN4 w0.102: 153.78,48.7 153.78,43.87 160.2,37.45 162.33,37.45 163.14,36.64 163.14,36.64 163.26,36.53 166.42,36.53 166.42,36.53 170.88,36.53 171.81,35.6 172.57,35.6 173.53,34.64 198.01,34.64 206.15,26.5 206.15,18.26 205.92,18.03 205.92,16.6 206.13,16.39 206.6,16.39 v2(206.72,16.27)
  BOTTOM w0.076: UC1.AR38 151.49,58.72 151.34,58.57 v2(151.09,58.57)
  BOTTOM w0.102: v2(206.72,16.27) 206.95,16.49 207.33,16.49 207.56,16.72 207.56,18.75 207.37,18.93 JDIMM2.179
DDR_B_DQS3: length 94.7
  IN4 w0.076: v2(154.69,58.59) 154.69,58.58 154.91,58.36 154.91,58.16 155.05,58.03 155.05,57 155.04,56.99 155.04,56.98
  IN4 w0.102: v2(213.32,13.92) 212.91,14.34 212.3,14.34 211.6,15.04 211.6,16.08 211.33,16.35 211.33,18.6 210.59,19.35 210.59,27.25 199.67,38.17 175.33,38.17 173.45,40.05 167.88,40.05 164.72,40.05 163.76,41.01 163.35,41.01 161.83,41.01 158.03,44.8 158.03,51.56 157.54,52.06 157.08,52.06 156.31,52.83 156.31,54.41 154.88,55.84 154.88,56.57 155.04,56.73 155.04,56.98
  BOTTOM w0.076: v2(154.69,58.59) 154.83,58.59 155.15,58.9 UC1.AR32
  BOTTOM w0.102: JDIMM2.200 212.62,12.59 212.43,12.78 212.43,14.05 212.82,14.43 213.12,14.43 213.32,14.23 v2(213.32,13.92)
DDR_B_DQS4: length 52.5
  IN1 w0.076: 159.22,43.24 159.22,43.69 158,44.91 158,49.45 157.92,49.53 157.77,49.53 157.58,49.34 v2(157.58,49.29)
  IN1 w0.102: 159.22,43.24 159.22,37.01 160.82,35.4 161.05,35.18 161.27,34.95 161.28,34.95 161.45,34.78 161.45,33.91 161.93,33.43 161.93,33.43 170.73,24.63 170.73,24.63 170.79,24.58 172.75,22.61 172.88,22.49 172.88,20.82 173.09,20.6 173.28,20.6 173.39,20.49 173.39,20.21 173.28,20.1 173.09,20.1 172.88,19.88 172.88,19.26 173.35,18.79 173.35,17.14 173.59,16.9 173.77,16.9 173.82,16.85 173.98,16.7 v2(173.98,16.62)
  BOTTOM w0.076: UC1.AY30 156.75,55.98 156.7,55.93 156.61,55.93 156.5,55.83 156.4,55.6 156.4,55.43 156.46,55.27 156.46,55.09 156.41,54.97 156.41,54.77 156.45,54.63 156.45,54.4 156.4,54.31 156.4,52.97 156.4,52.97 156.4,52.83 156.45,52.78 156.86,52.37 156.86,49.71 157.13,49.43 157.43,49.43 v2(157.58,49.29)
  BOTTOM w0.102: v2(173.98,16.62) 174.16,16.8 174.47,16.8 174.71,17.04 174.71,18.7 174.37,19.04 JDIMM2.55
DDR_B_DQS5: length 55.4
  IN1 w0.076: v2(160.67,47.43) 160.84,47.6 160.99,47.6 161.22,47.38 161.22,46.34 161.48,46.08 161.48,44.94 162.95,43.47 162.95,43.27 162.93,43.25 162.93,43.24
  IN1 w0.102: 162.93,43.24 162.93,38.66 171.31,30.28 171.31,29.72 179.53,21.5 179.53,16.47 179.53,16.08 179.03,15.57 179.03,14.71 179.53,14.21 179.96,14.21 v2(180.15,14.02)
  BOTTOM w0.076: UC1.BA26 159.2,55.71 159.26,55.77 159.38,55.77 159.42,55.73 159.49,55.56 159.49,55.47 159.43,55.3 159.43,55.05 159.48,54.93 159.48,54.79 159.44,54.65 159.44,54.29 159.44,54.29 159.53,54.14 159.62,54.05 159.62,52.75 159.84,52.53 159.84,47.94 160.12,47.66 160.43,47.66 v2(160.67,47.43)
  BOTTOM w0.102: v2(180.15,14.02) 179.95,14.23 179.59,14.23 179.33,13.96 179.33,12.95 179.62,12.65 JDIMM2.76
DDR_B_DQS6: length 91.3
  IN4 w0.076: 162.49,49.23 162.49,49.31 162.5,49.33 162.5,50.64 159.92,53.22 159.92,54.09 158.4,55.61 158.4,56.45 157.82,57.03 157.82,58.2 157.44,58.58 v2(157.44,58.59)
  IN4 w0.102: v2(216.85,17.12) 216.67,17.3 216.39,17.3 216.08,17.61 216.08,18.79 216.38,19.08 216.38,19.3 214.86,20.82 214.86,25.9 214.86,26.31 214.47,26.7 214.47,28.35 201.13,41.69 185.3,41.69 185.09,41.91 185.09,42.27 184.85,42.51 184.65,42.51 184.55,42.41 184.55,41.91 184.33,41.69 183.87,41.69 183.65,41.91 183.65,42.34 183.54,42.45 183.3,42.45 183.19,42.34 183.19,42.05 182.96,41.82 182.63,41.82 182.33,42.12 182.33,42.32 182.15,42.51 176.47,42.51 175.4,43.57 168.33,43.57 164.12,47.78 163.28,47.78 162.71,48.35 162.71,48.86 162.49,49.09 162.49,49.23
  BOTTOM w0.076: UC1.AR27 v2(157.44,58.59)
  BOTTOM w0.102: v2(216.85,17.12) 216.85,17.17 217.03,17.35 217.31,17.35 217.87,17.91 JDIMM2.221
DDR_B_DQS7: length 95.2
  IN4 w0.076: 165.65,51.95 165.63,51.96 165.63,51.96 165.23,52.37 164.61,52.37 163.6,53.38 163.6,54.04 160.56,57.08 160.56,58.09 160.46,58.19 160.46,58.86 160.69,59.08 160.96,59.08 v2(161.09,59.22)
  IN4 w0.102: v2(223.08,13.8) 222.91,13.97 222.46,13.97 221.99,14.44 221.99,15 222.42,15.43 222.42,15.73 222.85,16.16 222.85,18.85 222.29,19.41 221.41,20.29 221.41,22.95 218.38,25.98 218.38,26.19 218.38,27.77 218.08,28.07 218.08,29.72 215.61,32.19 202.59,45.21 198.49,45.21 187.13,45.21 185.79,46.55 178.94,46.55 177.73,47.76 169.58,47.76 166.92,50.42 166.92,50.68 165.73,51.86 165.65,51.95
  BOTTOM w0.076: v2(161.09,59.22) 161.36,58.95 UC1.AR21
  BOTTOM w0.102: v2(223.08,13.8) 223.08,14.09 222.92,14.26 222.75,14.26 222.39,13.9 222.39,13.54 222.83,13.11 222.83,12.75 223.12,12.45 JDIMM2.242
DDR_B_DQS#0: length 49.7
  IN1 w0.076: v2(152.04,51.1) 152.31,50.84 152.47,50.84 152.61,50.7 152.61,46.07 152.32,45.78 152.32,43.28 152.34,43.26 152.34,43.24
  IN1 w0.102: v2(163.28,17.43) 162.98,17.12 162.84,17.12 162.72,17.25 162.72,19.72 162.26,20.18 152.34,30.1 152.34,43.24
  BOTTOM w0.076: v2(152.04,51.1) 152.04,50.97 151.84,50.77 151.67,50.77 151.52,50.91 151.52,53.38 151.52,54.16 151.59,54.27 151.6,54.29 151.64,54.35 151.64,54.65 151.59,54.79 151.59,54.93 151.64,55.05 151.64,55.3 151.58,55.47 151.58,55.56 151.66,55.73 151.69,55.77 151.82,55.77 151.87,55.71 UC1.BA38
  BOTTOM w0.102: v2(163.28,17.43) 163.28,17.1 163.38,17 163.56,17 163.92,17.35 163.92,18.67 163.79,18.8 163.5,18.8 163.37,18.93 JDIMM2.11
DDR_B_DQS#1: length 53.1
  IN1 w0.076: v2(155.83,48.11) 155.7,47.98 155.4,47.98 155.07,47.65 155.07,44.64 155.69,44.02 155.69,43.33 155.68,43.32 155.68,43.27 155.66,43.25 155.66,43.24
  IN1 w0.102: v2(168.49,14.25) 168.7,14.46 168.7,14.72 168.5,14.91 168.5,18.98 168.4,19.08 168.2,19.08 167.98,19.3 167.98,19.77 168.2,19.98 168.4,19.98 168.5,20.08 168.5,20.39 164.32,24.58 164.32,25.94 161.78,28.48 155.66,34.59 155.66,43.24
  BOTTOM w0.076: UC1.AY34 154.32,55.98 154.37,55.93 154.47,55.93 154.57,55.83 154.68,55.6 154.68,55.43 154.61,55.27 154.61,55.09 154.67,54.97 154.67,54.77 154.62,54.63 154.62,53.59 154.76,53.45 154.82,53.39 154.82,49.81 154.91,49.72 154.91,49.08 154.93,49.06 154.93,49.05
  BOTTOM w0.102: v2(168.49,14.25) 168.62,14.25 168.79,14.08 168.79,12.68 168.62,12.51 JDIMM2.32 ; v2(155.83,48.11) 155.52,47.81 155.15,47.81 154.93,48.03 154.93,49.05
DDR_B_DQS#2: length 91.9
  IN4 w0.076: v2(151.09,57.94) 151.09,58.05 150.9,58.23 150.75,58.23 150.68,58.16 150.68,57.15 151.44,56.4 151.44,55.78 153.2,54.02 153.2,53.21 153.96,52.45 153.96,48.74 153.98,48.72 153.98,48.7
  IN4 w0.102: v2(206.72,17.17) 206.72,16.85 206.46,16.58 206.21,16.58 206.12,16.68 206.12,17.95 206.35,18.18 206.35,26.58 198.09,34.84 173.61,34.84 172.66,35.79 171.89,35.79 170.96,36.72 166.5,36.72 163.34,36.72 162.41,37.65 160.29,37.65 153.98,43.96 153.98,48.7
  BOTTOM w0.076: v2(151.09,57.94) 151.45,58.3 UC1.AT38
  BOTTOM w0.102: v2(206.72,17.17) 206.72,16.87 206.9,16.69 207.25,16.69 207.35,16.8 207.35,18.67 207.22,18.8 207.02,18.8 206.87,18.95 JDIMM2.177
DDR_B_DQS#3: length 94.7
  IN4 w0.076: 155.23,56.98 155.23,56.99 155.22,57 155.22,58.09 155.08,58.23 155.08,58.4 155.27,58.59 v2(155.61,58.59)
  IN4 w0.102: v2(213.3,14.94) 212.89,14.53 212.38,14.53 211.8,15.12 211.8,16.16 211.53,16.43 211.53,18.68 210.78,19.43 210.78,27.33 199.75,38.36 175.41,38.36 173.53,40.24 167.96,40.24 167.96,40.25 164.8,40.25 163.84,41.2 163.27,41.2 161.91,41.2 158.23,44.88 158.23,51.64 157.62,52.25 157.16,52.25 156.5,52.91 156.5,54.49 155.07,55.92 155.07,56.49 155.23,56.65 155.23,56.98
  BOTTOM w0.076: v2(155.61,58.59) 155.44,58.59 UC1.AT32
  BOTTOM w0.102: v2(213.3,14.94) 213.3,14.81 213.12,14.63 212.73,14.63 212.23,14.13 212.23,12.73 212.12,12.63 JDIMM2.198
DDR_B_DQS#4: length 52.5
  IN1 w0.076: v2(157.58,49.94) 157.82,49.7 157.99,49.7 158.17,49.52 158.17,44.98 159.39,43.76 159.39,43.33 159.4,43.32 159.4,43.27 159.42,43.25 159.42,43.24
  IN1 w0.102: 159.42,43.24 159.42,37.09 160.91,35.6 161.19,35.31 161.65,34.86 161.65,33.99 162.13,33.51 170.87,24.77 172.95,22.7 173.07,22.57 173.07,20.9 173.17,20.8 173.36,20.8 173.59,20.57 173.59,20.13 173.36,19.9 173.17,19.9 173.07,19.8 173.07,19.34 173.54,18.87 173.54,17.23 173.67,17.1 173.82,17.1 174,17.28 v2(174,17.4)
  BOTTOM w0.076: UC1.BA30 156.85,55.71 156.8,55.77 156.68,55.77 156.64,55.73 156.56,55.56 156.56,55.47 156.63,55.3 156.63,55.05 156.57,54.93 156.57,54.79 156.62,54.65 156.62,54.35 156.61,54.33 156.56,54.26 156.56,52.9 157.02,52.44 157.02,49.77 157.2,49.6 157.38,49.6 157.58,49.8 v2(157.58,49.94)
  BOTTOM w0.102: v2(174,17.4) 173.93,17.33 173.93,17.12 174.05,17 174.39,17 174.51,17.12 174.51,18.61 174.25,18.88 174.05,18.88 173.87,19.05 JDIMM2.53
DDR_B_DQS#5: length 55.5
  IN1 w0.076: v2(160.65,48.04) 160.92,47.77 161.06,47.77 161.38,47.44 161.38,46.41 161.64,46.14 161.64,45 163.12,43.53 163.12,43.27 163.13,43.25 163.13,43.24
  IN1 w0.102: v2(180.15,14.66) 179.89,14.41 179.62,14.41 179.23,14.79 179.23,15.49 179.73,15.99 179.73,16.39 179.73,16.39 179.73,21.58 171.5,29.8 171.5,30.36 163.13,38.74 163.13,43.24
  BOTTOM w0.076: v2(160.65,48.04) 160.45,47.83 160.18,47.83 160.01,48.01 160.01,52.6 159.79,52.82 159.79,54.12 159.66,54.25 159.6,54.34 159.6,54.63 159.65,54.77 159.65,54.97 159.6,55.09 159.6,55.27 159.66,55.43 159.66,55.6 159.55,55.83 159.45,55.93 159.4,55.93 159.3,56.03 UC1.AY26
  BOTTOM w0.102: v2(180.15,14.66) 179.92,14.43 179.51,14.43 179.12,14.05 JDIMM2.74
DDR_B_DQS#6: length 91.3
  IN4 w0.076: v2(158.35,58.59) 158.29,58.59 157.98,58.28 157.98,57.1 158.56,56.52 158.56,55.68 160.08,54.16 160.08,53.29 162.67,50.71 162.67,49.33 162.68,49.31 162.68,49.23
  IN4 w0.102: 162.68,49.23 162.68,49.17 162.91,48.94 162.91,48.43 163.36,47.98 164.21,47.98 168.41,43.77 175.49,43.77 176.55,42.7 182.23,42.7 182.53,42.4 182.53,42.2 182.71,42.02 182.88,42.02 182.99,42.13 182.99,42.42 183.22,42.64 183.62,42.64 183.85,42.42 183.85,41.99 183.95,41.88 184.25,41.88 184.35,41.99 184.35,42.49 184.57,42.7 184.93,42.7 185.28,42.35 185.28,41.99 185.38,41.88 201.21,41.88 214.66,28.44 214.66,26.78 215.05,26.39 215.05,25.81 215.05,20.9 216.57,19.38 216.57,19 216.28,18.71 216.28,17.69 216.47,17.5 216.67,17.5 216.89,17.71 v2(216.89,17.94)
  BOTTOM w0.076: UC1.AR25 v2(158.35,58.59)
  BOTTOM w0.102: v2(216.89,17.94) 216.89,17.7 217.03,17.55 217.23,17.55 217.67,18 217.67,18.67 217.57,18.78 217.52,18.78 217.37,18.93 JDIMM2.219
DDR_B_DQS#7: length 95.2
  IN4 w0.076: v2(161.09,58.59) 161.09,58.7 160.87,58.92 160.76,58.92 160.63,58.79 160.63,58.25 160.72,58.16 160.72,57.15 163.77,54.11 163.77,53.45 164.68,52.53 165.3,52.53 165.69,52.13 165.73,52.13 165.78,52.08
  IN4 w0.102: v2(223.08,14.71) 223.15,14.64 223.15,14.43 222.89,14.17 222.54,14.17 222.19,14.53 222.19,14.92 222.62,15.35 222.62,15.65 223.05,16.08 223.05,18.93 221.61,20.37 221.61,22.87 221.61,23.03 218.58,26.06 218.58,26.11 218.58,26.11 218.58,27.85 218.28,28.15 218.28,29.8 215.69,32.39 215.69,32.39 202.67,45.41 198.41,45.41 187.21,45.41 185.87,46.75 179.02,46.75 177.81,47.95 169.66,47.95 167.11,50.5 167.11,50.6 167.11,50.76 165.81,52.06 165.78,52.08
  BOTTOM w0.076: v2(161.09,58.59) 160.73,58.95 UC1.AR22
  BOTTOM w0.102: v2(223.08,14.71) 223.08,14.64 222.9,14.46 222.66,14.46 222.19,13.98 222.19,13.46 222.62,13.02 JDIMM2.240
DDR_B_MA0: length 90.2
  IN4 w0.076: 143.49,43.64 143.49,44.02 v2(144.43,44.96)
  IN4 w0.145: 143.49,43.64 143.49,39.9 159.68,23.71 162.87,23.71 163.33,24.18 170.23,24.18 171.07,23.34 179.86,23.34 180.38,22.82 185.8,22.82 186.04,23.06 186.83,23.06 187.37,22.52 187.42,22.52 188.48,22.52 190.84,20.15 191.63,20.15 193.32,18.47 193.32,17.33 193.03,17.04 193.03,12.79 193.17,12.65 194.39,12.65 194.54,12.79 194.54,13.75 194.68,13.9 195,13.9 195.15,13.75 195.15,12.85 195.29,12.71 196.48,12.71 196.62,12.85 196.63,12.85 v2(196.86,13.08)
  BOTTOM w0.076: 147.1,49.03 147.1,50.55 147.74,51.19 147.74,53.42 147.84,53.52 147.84,54.74 147.58,55.01 UC1.BA46
  BOTTOM w0.168: v2(144.43,44.96) 145.06,44.96 147.1,47.01 147.1,49.03 ; JDIMM2.144 196.62,12.85 v2(196.86,13.08)
DDR_B_MA1: length 90.6
  IN4 w0.076: v2(145.17,47.25) 145.17,47.22 145.54,46.85 145.54,45.28 144.34,44.08 144.34,43.64
  IN4 w0.145: v2(194.27,18.44) 194.27,18.71 193.88,19.11 193.88,20.76 193.67,20.97 193.47,20.97 192.85,20.34 192.64,20.34 192.43,20.56 192.43,21.25 192.06,21.62 191.59,21.62 191.36,21.39 191.15,21.39 190.95,21.59 190.95,21.8 191.24,22.09 191.24,22.29 191.04,22.5 190.83,22.5 190.73,22.39 190.52,22.39 190.32,22.6 190.32,22.8 190.36,22.85 190.36,23.06 190.05,23.36 187.72,23.36 187.43,23.66 187.18,23.91 185.69,23.91 185.45,23.67 182.69,23.67 181.33,25.03 181.27,25.03 180.56,25.03 180.41,24.88 180.41,24.34 180.27,24.19 179.98,24.19 179.83,24.34 179.83,24.88 179.69,25.03 179.4,25.03 179.25,24.88 179.25,24.34 179.11,24.19 178.82,24.19 178.67,24.34 178.67,24.88 178.53,25.03 178.26,25.03 178.11,24.88 178.11,24.36 177.97,24.21 177.68,24.21 177.53,24.36 177.53,24.88 177.39,25.03 177.1,25.03 176.95,24.88 176.95,24.36 176.81,24.21 176.52,24.21 176.38,24.36 176.38,24.88 176.23,25.03 175.94,25.03 175.8,24.88 175.8,24.36 175.65,24.21 175.36,24.21 175.22,24.36 175.22,24.88 175.07,25.03 174.78,25.03 174.64,24.88 174.64,24.36 174.49,24.21 174.2,24.21 174.06,24.36 174.06,24.88 173.91,25.03 173.62,25.03 173.48,24.88 173.48,24.62 173.33,24.47 173.05,24.47 172.9,24.62 172.9,24.88 172.76,25.03 162.98,25.03 162.52,24.56 160.03,24.56 144.34,40.25 144.34,43.64
  BOTTOM w0.076: UC1.AY46 147.48,55.58 147.38,55.47 147.31,55.28 147.31,55.1 147.35,54.97 147.35,54.72 147.31,54.64 147.31,54.38 147.49,54.2 147.49,53.66 147.41,53.59 147.41,51.35 146.43,50.36 146.43,49.39 146.07,49.04 146.07,49.03
  BOTTOM w0.168: v2(194.27,18.44) 193.87,18.84 JDIMM2.133 ; 146.07,49.03 146.07,48.15 v2(145.17,47.25)
DDR_B_MA2: length 91.6
  IN4 w0.076: v2(145.17,47.88) 145.17,47.81 144.39,47.02 144.39,46.46 143.9,45.98 143.9,45.01 143.07,44.18 143.07,43.64
  IN4 w0.145: 143.07,43.64 143.07,39.72 159.5,23.29 163.64,23.29 163.64,23.29 163.79,23.29 163.94,23.44 163.94,23.61 164.08,23.75 164.37,23.75 164.52,23.61 164.52,23.44 164.66,23.29 164.95,23.29 165.1,23.44 165.1,23.61 165.24,23.75 170.06,23.75 170.89,22.92 179.68,22.92 180.21,22.39 180.86,22.39 180.96,22.29 180.96,21.86 181.11,21.71 181.48,21.71 181.63,21.86 181.63,22.24 181.77,22.39 182.06,22.39 182.21,22.24 182.21,21.84 182.35,21.69 182.64,21.69 182.79,21.84 182.79,22.24 182.93,22.39 183.22,22.39 183.37,22.24 183.37,21.84 183.51,21.69 183.8,21.69 183.94,21.84 183.94,22.24 184.09,22.39 184.38,22.39 184.52,22.24 184.52,21.84 184.67,21.69 184.96,21.69 185.1,21.84 185.1,22.24 185.25,22.39 185.54,22.39 185.68,22.24 185.68,21.84 185.83,21.69 186.91,21.69 187.06,21.84 187.06,21.95 187.2,22.09 188.3,22.09 188.49,21.9 188.49,21.69 188.1,21.3 188.1,21.1 188.31,20.89 188.51,20.89 188.9,21.28 189.11,21.28 190.7,19.69 191.49,19.69 192.89,18.29 192.89,17.77 v2(192.45,17.33)
  BOTTOM w0.076: UC1.AY47 147.18,55.85 147.18,55.42 147.14,55.31 147.14,55.06 147.18,54.94 147.18,54.76 147.16,54.7 147.14,54.68 147.14,54.31 147.32,54.13 147.32,53.74 147.25,53.66 147.25,51.42 146.26,50.43 146.26,50.41 146.09,50.23 146.09,49.58 145.62,49.11 145.62,49.03
  BOTTOM w0.168: v2(192.45,17.33) 193.62,16.15 JDIMM2.132 ; 145.62,49.03 145.62,48.33 v2(145.17,47.88)
DDR_B_MA3: length 90.6
  IN4 w0.076: 143.92,43.64 143.92,43.91 145.05,45.04 v2(145.05,45.98)
  IN4 w0.145: 143.92,43.64 143.92,40.07 159.85,24.14 162.69,24.14 163.16,24.6 170.41,24.6 171.24,23.77 171.52,23.77 171.66,23.91 171.66,24.46 171.81,24.6 172.1,24.6 172.24,24.46 172.24,23.91 172.38,23.77 180.13,23.77 180.27,23.62 180.27,23.53 180.5,23.3 180.7,23.3 180.84,23.45 180.84,24.32 180.99,24.47 181.29,24.47 181.46,24.3 181.46,23.39 181.61,23.24 185.63,23.24 185.87,23.48 187,23.48 187.55,22.94 188.65,22.94 189.52,22.07 191.02,20.57 191.81,20.57 192.58,19.81 192.97,19.81 193.07,19.91 193.27,19.91 193.45,19.73 193.45,19.44 193.38,19.36 193.38,19.01 193.74,18.64 193.74,17.15 193.45,16.87 193.45,14.41 193.6,14.27 193.89,14.27 194.04,14.41 194.04,16.68 v2(194.27,16.91)
  BOTTOM w0.076: 146.6,49.03 146.6,50.3 147.58,51.28 147.58,53.51 147.68,53.61 147.68,54.43 UC1.BB46
  BOTTOM w0.168: v2(194.27,16.91) 194.03,16.91 193.37,17.56 JDIMM2.131 ; 146.6,49.03 146.6,47.38 145.33,46.12 145.19,46.12 v2(145.05,45.98)
DDR_B_MA4: length 89.8
  IN4 w0.076: v2(145.21,49.33) 144.96,49.08 144.95,49.08 143.86,47.99 143.86,46.6 143.24,45.98 143.24,44.89 142.22,43.86 142.22,43.64
  IN4 w0.145: v2(192.45,13.98) 192.09,13.62 192.09,11.55 191.95,11.41 191.62,11.41 191.48,11.55 191.48,18.24 190.94,18.77 190.42,18.77 189.22,19.98 187.95,19.98 187.09,20.84 180.75,20.84 180.05,21.55 179.86,21.55 179.33,22.07 170.46,22.07 169.63,22.91 165.8,22.91 165.34,22.44 159.15,22.44 158.9,22.69 152.32,29.26 151.07,29.26 148.12,32.21 148.12,33.47 142.22,39.37 142.22,43.64
  BOTTOM w0.076: UC1.BA47 146.69,55.28 146.69,55.06 146.69,55.05 146.68,55.05 146.68,55.04 146.65,54.96 146.65,54.76 146.68,54.66 146.68,54.26 146.56,54.14 146.56,51.28 145.73,50.45 145.73,49.85 v2(145.21,49.33)
  BOTTOM w0.168: JDIMM2.128 192.62,12.66 193,13.03 193,13.42 v2(192.45,13.98)
DDR_B_MA5: length 90.8
  IN4 w0.076: v2(145.24,50.58) 145.59,50.23 145.59,49.19 145.32,48.91 145.02,48.91 144.11,48 144.11,46.49 143.74,46.12 143.74,45.1 142.64,44.01 142.64,43.64
  IN4 w0.145: v2(192.45,15.81) 192.45,15.69 192.33,15.57 192.09,15.57 191.9,15.76 191.9,18.68 191.33,19.26 190.54,19.26 190.49,19.3 189.12,20.67 188.89,20.67 188.69,20.47 188.13,20.47 187.68,20.92 187.68,21.28 187.47,21.49 187.31,21.49 187.09,21.27 180.92,21.27 180.22,21.97 180.03,21.97 179.51,22.49 170.64,22.49 169.81,23.33 165.63,23.33 165.16,22.87 159.32,22.87 152.06,30.13 151.85,30.13 151.44,29.73 151.24,29.73 151.04,29.93 151.04,30.13 151.44,30.54 151.44,30.75 151.24,30.95 151.03,30.95 150.63,30.54 150.42,30.54 150.22,30.75 150.22,30.95 150.62,31.36 150.62,31.57 150.42,31.77 150.21,31.77 149.81,31.36 149.6,31.36 149.4,31.57 149.4,31.77 149.8,32.18 149.8,32.39 149.59,32.6 149.39,32.6 148.99,32.2 148.79,32.2 148.58,32.41 148.58,32.71 148.92,33.06 148.92,33.27 142.64,39.55 142.64,43.64
  BOTTOM w0.076: v2(145.24,50.58) 145.55,50.89 145.61,50.89 146.4,51.67 146.4,54.25 146.52,54.38 146.52,54.63 146.48,54.72 146.48,54.99 146.52,55.08 146.52,55.28 146.49,55.37 146.49,55.37 146.45,55.47 146.45,55.63 UC1.AY48
  BOTTOM w0.168: JDIMM2.126 192.12,12.69 191.98,12.83 191.98,15.34 v2(192.45,15.81)
DDR_B_MA6: length 89.2
  IN4 w0.076: v2(145.3,52.43) 143.53,50.66 143.53,47.07 142.73,46.27 142.73,45.06 141.44,43.77
  IN4 w0.145: 141.44,43.77 141.37,43.7 141.37,39.02 143.52,36.87 143.52,36.48 143.32,36.29 143.32,35.81 151.37,27.76 151.58,27.76 152,28.18 152.2,28.18 152.41,27.97 152.41,27.77 151.99,27.35 151.99,27.14 152.19,26.94 152.4,26.94 152.82,27.36 153.02,27.36 153.23,27.15 153.23,26.95 152.81,26.53 152.81,26.32 153.01,26.12 153.22,26.12 153.64,26.54 153.84,26.54 154.05,26.33 154.05,26.13 153.69,25.77 153.69,25.57 153.99,25.28 154.19,25.28 154.55,25.63 154.76,25.63 158.55,21.84 158.8,21.59 168.08,21.59 168.54,22.05 169.17,22.05 169.32,21.9 169.32,21.34 169.46,21.19 177.17,21.19 177.42,20.94 177.66,20.7 179.69,20.7 180.4,19.99 186.74,19.99 187.6,19.13 188.86,19.13 189.75,18.24 189.75,17 190.32,16.43 190.32,15.91 190.41,15.83 v2(190.87,15.83)
  BOTTOM w0.076: UC1.BA48 146.25,54.95 145.98,54.69 145.98,54.37 146.07,54.28 146.07,53.74 145.97,53.64 145.97,53.1 v2(145.3,52.43)
  BOTTOM w0.168: v2(190.87,15.83) 191.6,16.56 191.6,17.39 191.9,17.69 191.9,18.55 191.9,18.55 191.92,18.55 192.37,19.01 JDIMM2.127
DDR_B_MA7: length 92.1
  IN4 w0.076: 145.3,53.88 145.3,56.37 145.07,56.6 145.07,57.36 145.35,57.64 145.71,57.64 145.92,57.85 145.92,59.49 v2(145.55,59.86)
  IN4 w0.145: 145.3,53.88 142.45,51.03 142.45,45.19 140.95,43.68 140.95,38.84 142.89,36.9 142.89,35.64 143.14,35.39 153.68,24.85 154.93,24.85 158.62,21.17 168.81,21.17 169.21,20.77 176.99,20.77 177.51,20.25 179.54,20.25 180.22,19.57 186.56,19.57 187.43,18.7 188.69,18.7 189.33,18.06 189.33,16.82 189.9,16.25 189.9,14.34 190.1,14.14 190.1,13.05 190.24,12.91 190.73,12.91 190.87,13.05 v2(190.87,14.31)
  BOTTOM w0.076: v2(145.55,59.86) 145.8,59.6 UC1.AP48
  BOTTOM w0.168: v2(190.87,14.31) 191.12,14.05 JDIMM2.122
DDR_B_MA8: length 87.2
  IN4 w0.076: 141.79,43.64 141.79,43.72 142.96,44.89 142.96,46 143.7,46.74 143.7,49.66 v2(145.27,51.23)
  IN4 w0.145: 141.79,43.64 141.79,39.19 144.24,36.75 144.24,36.57 143.8,36.14 143.8,35.93 144,35.73 144.21,35.73 144.62,36.14 144.83,36.14 145.03,35.93 145.03,35.73 144.62,35.32 144.62,35.11 144.82,34.91 145.03,34.91 145.44,35.32 145.65,35.32 145.85,35.11 145.85,34.91 145.44,34.5 145.44,34.29 145.64,34.09 145.85,34.09 146.26,34.5 146.47,34.5 146.67,34.3 146.67,34.09 146.26,33.68 146.26,33.47 146.46,33.27 146.67,33.27 147.08,33.68 147.28,33.68 147.49,33.48 147.49,33.27 147.08,32.86 147.08,32.65 150.92,28.81 152.18,28.81 156.88,24.11 156.88,24.11 158.97,22.02 166.09,22.02 166.24,22.16 166.24,22.34 166.38,22.48 166.67,22.48 166.82,22.34 166.82,22.16 166.96,22.02 167.28,22.02 167.42,22.16 167.42,22.34 167.57,22.48 169.43,22.48 170.3,21.61 178.2,21.61 178.69,21.12 179.87,21.12 180.57,20.42 186.91,20.42 187.78,19.55 189.04,19.55 190.18,18.41 190.18,17.19 190.4,16.97 190.54,16.97 190.87,17.31 v2(190.87,17.53)
  BOTTOM w0.076: v2(145.27,51.23) 146.23,52.19 146.23,54.32 146.25,54.34 UC1.BB48
  BOTTOM w0.168: v2(190.87,17.53) 190.97,17.53 191.48,18.04 191.48,18.79 191.87,19.19 JDIMM2.125
DDR_B_MA9: length 87.5
  IN4 w0.076: 142.95,53.33 142.95,54.93 144.27,56.25 144.27,58.85 v2(144.63,59.22)
  IN4 w0.145: 142.95,53.33 142.33,52.71 141.56,51.94 140.91,51.29 140.67,51.04 140.67,46.03 139.67,45.03 139.67,37.06 153.51,23.22 154.76,23.22 158.09,19.9 168.24,19.9 168.64,19.49 176.46,19.49 176.98,18.97 179.02,18.97 180.04,17.95 183.84,17.95 185.23,16.56 187.24,16.56 187.66,16.14 v2(188.76,16.14)
  BOTTOM w0.076: UC1.AP50 v2(144.63,59.22)
  BOTTOM w0.168: v2(188.76,16.14) 189.14,16.14 190.22,17.21 190.22,18.42 190.87,19.07 JDIMM2.121
DDR_B_MA10: length 91.1
  IN4 w0.076: v2(147.88,49.07) 147.52,48.7 147.52,48.2 147.35,48.03 147.35,43.94 147.1,43.69 147.1,43.64
  IN4 w0.145: v2(199.1,13.03) 198.18,13.03 198.04,12.89 198.04,12.45 198.18,12.31 198.44,12.31 198.59,12.16 198.59,11.88 198.44,11.74 197.51,11.74 197.36,11.88 197.36,13.05 197.7,13.39 197.7,21.34 196.9,22.14 196.65,22.39 196.65,24.03 192.55,28.13 186.82,28.13 186.49,27.8 160.62,27.8 147.1,41.32 147.1,43.3 147.1,43.3 147.1,43.64
  BOTTOM w0.076: 147.43,49.38 147.43,50.44 147.91,50.91 147.91,53.35 148.01,53.45 148.01,55.17 147.77,55.41 147.77,55.9 147.67,56.11 147.48,56.3 UC1.AW46
  BOTTOM w0.102: v2(147.88,49.07) 147.75,49.07 147.43,49.38
  BOTTOM w0.168: JDIMM2.146 199.12,13.01 v2(199.1,13.03)
DDR_B_MA11: length 93.3
  IN4 w0.076: 143.79,54.96 144.91,56.08 144.91,56.52 144.91,56.53 144.91,57.45 145.17,57.71 145.17,60.25 v2(145.55,60.63)
  IN4 w0.145: v2(189.42,14.72) 189.42,14.19 189.28,14.05 188.93,14.05 188.79,14.19 188.79,15.17 189.27,15.65 189.27,16.28 188.91,16.65 188.91,17.89 188.51,18.28 187.25,18.28 186.38,19.15 180.05,19.15 179.37,19.82 177.34,19.82 176.82,20.34 168.99,20.34 168.59,20.74 158.44,20.74 155.12,24.07 154.89,24.07 154.75,24.22 154.75,24.28 154.6,24.43 154.36,24.43 154.22,24.28 154.22,24.22 154.07,24.07 153.86,24.07 141.97,35.96 141.97,36.17 142.37,36.57 142.37,36.77 142.16,36.98 141.96,36.97 141.55,36.57 141.36,36.57 141.13,36.79 141.13,36.99 141.52,37.37 141.52,37.67 140.52,38.67 140.52,44.68 141.51,45.68 141.51,50.73 143.79,53.01 143.79,54.96
  BOTTOM w0.076: UC1.AN48 145.94,60.25 v2(145.55,60.63)
  BOTTOM w0.168: v2(189.42,14.72) 190.27,13.87 190.27,12.87 190.62,12.52 JDIMM2.120
DDR_B_MA12: length 92.6
  IN4 w0.076: v2(144.63,60.51) 144.48,60.51 143.35,59.37 143.35,57.11 142.61,56.36 142.61,55.57 141.33,54.29
  IN4 w0.145: v2(187.62,15.42) 184.82,15.42 183.82,16.42 179.63,16.42 179.25,16.04 179.25,15.76 178.95,15.47 178.95,15.47 178.88,15.4 178.52,15.4 176.57,17.36 176.57,18.14 176.06,18.65 168.29,18.65 167.88,19.05 157.74,19.05 154.41,22.37 152.35,22.37 143.08,31.64 143.08,32.45 138.83,36.7 138.83,45.71 139.23,46.12 139.23,51.18 141.33,53.28 141.33,54.29
  BOTTOM w0.076: v2(144.63,60.51) 144.89,60.25 UC1.AN50
  BOTTOM w0.168: JDIMM2.119 190.37,19.21 189.8,18.63 189.8,17.41 189,16.62 188.53,16.62 188.23,16.31 187.84,16.31 187.62,16.08 v2(187.62,15.42)
DDR_B_MA13: length 87.9
  IN4 w0.076: 149.22,44.45 149.22,44.57 149.07,44.73 149.07,48.85 v2(149.41,49.19)
  IN4 w0.145: 149.22,44.45 149.22,44.45 149.22,42.57 149.22,42.2 158.76,32.66 160.92,32.66 162.95,30.62 164.56,30.62 164.94,30.25 173.36,30.25 173.7,29.92 185.47,29.92 185.81,30.25 194.47,30.25 200.12,24.61 200.12,20.92 200.36,20.68 200.37,20.68 200.8,20.24 200.8,16.36 201.08,16.08 201.08,15.88 200.8,15.6 200.8,15.17 200.96,15.01 201.29,15.01 201.48,14.82 201.82,14.82 201.97,14.68 201.97,13.77 202.17,13.57 202.39,13.57 v2(202.6,13.78)
  BOTTOM w0.076: 149.05,50.74 149.05,51.24 148.9,51.39 148.9,52.84 149.26,53.2 149.26,53.28 149.64,53.65 149.64,54.14 149.5,54.28 149.5,54.41 149.5,54.41 149.5,54.67 149.55,54.8 149.55,54.91 149.51,55.01 149.5,55.04 149.5,55.28 UC1.BA43
  BOTTOM w0.102: 149.05,50.74 149.05,49.55 v2(149.41,49.19)
  BOTTOM w0.168: JDIMM2.158 202.12,13.3 v2(202.6,13.78)
DDR_B_MA14: length 91.8
  IN4 w0.076: v2(147.9,45.86) 148.28,45.47 148.28,44.93 147.95,44.59 147.95,43.64
  IN4 w0.145: v2(199.45,18.11) 199.53,18.19 199.53,18.52 199.38,18.66 198.8,18.66 198.65,18.81 198.65,19.06 198.8,19.21 199.38,19.21 199.53,19.35 199.53,19.64 199.38,19.78 198.99,19.78 198.84,19.93 198.84,24.08 193.95,28.98 186.33,28.98 186,28.65 166.75,28.65 166.6,28.79 166.6,28.84 166.46,28.98 166.17,28.98 166.02,28.84 166.02,28.79 165.88,28.65 165.59,28.65 165.44,28.79 165.44,28.84 165.3,28.98 165.01,28.98 164.86,28.84 164.86,28.79 164.72,28.65 164.43,28.65 164.28,28.79 164.28,29.1 164.14,29.25 163.85,29.25 163.71,29.1 163.71,28.79 163.56,28.65 163.27,28.65 163.13,28.79 163.13,29.18 162.98,29.33 162.69,29.33 162.55,29.18 162.55,28.79 162.4,28.65 162.11,28.65 161.97,28.79 161.97,29.23 161.82,29.37 161.53,29.37 161.39,29.23 161.39,28.79 161.24,28.65 160.97,28.65 160.57,29.04 160.57,29.25 161.4,30.08 161.4,30.28 161.2,30.49 160.99,30.49 160.21,29.7 160,29.7 159.8,29.91 159.8,30.11 160.34,30.65 160.34,30.99 159.97,31.36 158.26,31.36 147.95,41.67 147.95,42.95 147.95,43.64
  BOTTOM w0.076: UC1.AY44 148.7,55.59 148.81,55.48 148.81,55.47 148.88,55.26 148.88,55.13 148.82,54.9 148.82,54.76 148.87,54.64 148.87,54.37 148.67,54.17 148.67,53.11 148.57,53.01 148.57,51.1 148.59,51.08 148.62,51.08 148.7,51.01 148.7,50.82 148.68,50.81 148.68,48.36 148.75,48.29 148.75,47.78
  BOTTOM w0.168: v2(147.9,45.86) 147.97,45.86 148.75,46.65 148.75,47.78 ; v2(199.45,18.11) 200.16,18.11 200.37,18.33 JDIMM2.151
DDR_B_MA15: length 92.6
  IN4 w0.076: v2(149.43,47.86) 149.43,44.84 149.65,44.62 149.65,44.48
  IN4 w0.145: 149.65,44.48 149.65,42.37 158.94,33.08 161.09,33.08 161.62,32.56 163.13,31.05 164.74,31.05 165.11,30.68 173.54,30.68 173.87,30.34 185.3,30.34 185.63,30.68 194.65,30.68 200.54,24.78 200.54,21.1 201.22,20.42 201.22,16.55 201.6,16.17 201.6,15.81 201.45,15.65 201.45,15.45 201.65,15.24 201.86,15.24 202.01,15.4 202.37,15.4 202.86,14.91 203.07,14.91 203.28,15.12 203.49,15.12 203.69,14.92 203.69,14.71 203.48,14.5 203.48,14.1 203.68,13.9 v2(203.87,13.9)
  BOTTOM w0.076: UC1.AY43 149.08,55.87 149.08,55.76 149,55.61 149,55.42 149.05,55.27 149.05,55.12 148.99,54.9 148.99,54.79 149.04,54.67 149.04,54.3 148.85,54.11 148.85,53.03 148.74,52.92 148.74,51.23 148.86,51.1 148.86,50.74
  BOTTOM w0.102: 148.86,50.74 148.86,48.43 v2(149.43,47.86)
  BOTTOM w0.168: v2(203.87,13.9) 202.73,15.04 202.09,15.04 201.62,14.57 JDIMM2.156
DDR_B_MA16: length 90.1
  IN4 w0.076: v2(147.88,50.37) 148.75,49.5 148.75,44.56 148.8,44.51 148.8,44.03
  IN4 w0.145: 148.8,44.03 148.8,42.75 148.8,42.02 158.59,32.23 160.74,32.23 162.77,30.2 164.39,30.2 164.76,29.83 173.19,29.83 173.52,29.49 185.65,29.49 185.98,29.83 194.3,29.83 199.69,24.43 199.69,20.75 199.94,20.5 200.13,20.32 200.37,20.07 200.37,14.73 200.52,14.58 201.11,14.58 201.44,14.26 201.44,13.7 201.7,13.44 201.7,12.32 201.55,12.17 201.2,12.17 201.05,12.32 v2(201.05,13.14)
  BOTTOM w0.076: v2(147.88,50.37) 148.07,50.56 148.07,53.26 148.17,53.36 148.17,55.17 148.41,55.41 148.41,55.88 148.43,55.94 148.54,56.16 148.7,56.32 UC1.AW44
  BOTTOM w0.168: v2(201.05,13.14) 200.62,12.71 JDIMM2.152
DDR_B_ODT0: length 94
  IN4 w0.145: v2(203.26,17.1) 203.26,17.3 202.73,17.84 202.73,24.72 199.61,27.84 199.61,28.05 200.23,28.67 200.23,28.87 200.02,29.08 199.82,29.08 199.2,28.46 198.99,28.46 198.79,28.66 198.79,28.87 199.41,29.49 199.41,29.69 199.2,29.9 199,29.9 198.38,29.28 198.17,29.28 197.97,29.48 197.97,29.68 198.58,30.29 198.58,30.5 198.37,30.7 198.17,30.7 197.56,30.09 197.35,30.09 197.15,30.3 197.15,30.5 197.74,31.1 197.74,31.3 197.54,31.51 197.33,31.51 196.74,30.91 196.53,30.91 196.33,31.12 196.33,31.32 196.76,31.75 196.76,31.96 196.54,32.18 184.76,32.18 184.43,31.84 174.5,31.84 174.41,31.93 174.16,32.18 172.5,32.18 171.55,33.13 170.79,33.13 169.86,34.06 165.4,34.06 162.24,34.06 161.31,34.99 159.18,34.99 158.93,35.24 151.32,42.85 151.32,43.72 151.32,44.48 151.32,44.8 151.2,44.92 151.2,45.77 150.51,46.46 150.51,51.45 v2(149.29,52.67)
  BOTTOM w0.076: UC1.BA42 149.93,54.97 149.71,54.74 149.66,54.64 149.66,54.43 149.67,54.43 149.67,54.35 149.8,54.21 149.8,53.58 149.54,53.32 149.54,52.92 v2(149.29,52.67)
  BOTTOM w0.168: v2(203.26,17.1) 201.8,17.1 201.43,17.47 201.37,17.53 JDIMM2.155
DDR_B_ODT1: length 95
  IN4 w0.076: v2(149.04,57.23) 149.04,54.96 149.77,54.23 149.77,53.01 150.83,51.95 150.83,46.59 151.12,46.31
  IN4 w0.145: 151.12,46.31 151.62,45.8 151.62,45.1 151.74,44.98 151.74,44.3 151.74,43.03 159.36,35.41 161.49,35.41 162.41,34.49 165.57,34.49 170.03,34.49 170.96,33.55 171.73,33.55 172.68,32.6 174.63,32.6 174.96,32.27 184.2,32.27 184.53,32.6 197.16,32.6 200.95,28.81 200.95,28.61 200.29,27.94 200.29,27.76 200.51,27.53 200.7,27.53 201.36,28.2 201.57,28.2 201.77,27.99 201.77,27.79 201.14,27.15 201.14,26.95 201.34,26.74 201.55,26.74 202.18,27.38 202.39,27.38 202.59,27.17 202.59,26.97 201.96,26.33 201.96,26.13 202.16,25.92 202.37,25.92 203,26.56 203.21,26.56 203.4,26.36 203.4,25.99 203.54,25.85 203.63,25.85 203.77,25.7 203.77,25.41 203.63,25.27 203.31,25.27 203.16,25.13 203.16,24.84 203.31,24.69 203.63,24.69 203.77,24.55 203.77,24.26 203.63,24.11 203.28,24.11 203.15,23.98 203.15,23.66 203.28,23.53 203.63,23.53 203.77,23.39 203.77,23.1 203.63,22.95 203.33,22.95 203.19,22.81 203.19,22.52 203.33,22.37 203.63,22.37 203.77,22.23 203.77,21.94 203.63,21.8 203.28,21.8 203.15,21.67 203.15,21.35 203.28,21.22 203.63,21.22 203.77,21.07 203.77,20.78 203.63,20.64 203.38,20.64 203.24,20.49 203.24,18.76 v2(203.34,18.66)
  BOTTOM w0.076: v2(149.04,57.23) 149.46,57.23 149.93,56.76 UC1.AW42
  BOTTOM w0.168: v2(203.34,18.66) 202.87,19.12 JDIMM2.161
DDR_B_PARITY: length 93.3
  IN4 w0.076: 146.65,43.69 146.68,43.72 146.68,43.82 146.89,44.03 146.93,44.07 147.02,44.07 147.19,44.23 147.19,48.19 147.35,48.35 147.35,51.1 148.27,52.02 148.27,53.9 148.67,54.3 148.67,58.84 148.32,59.19 v2(148.32,59.24)
  IN4 w0.145: v2(197.09,18.72) 197.09,21.35 195.92,22.52 195.92,22.72 196.22,23.02 196.22,23.35 196.08,23.49 195.88,23.49 195.51,23.13 195.31,23.13 195.1,23.34 195.1,23.54 195.66,24.1 195.66,24.3 195.46,24.51 195.25,24.51 194.69,23.95 194.49,23.95 194.28,24.16 194.28,24.36 194.89,24.96 194.89,25.16 194.67,25.37 194.48,25.37 193.87,24.77 193.67,24.77 193.47,24.97 193.47,25.18 194,25.71 194,25.92 193.79,26.12 193.59,26.12 193.06,25.59 192.85,25.59 192.65,25.79 192.65,26 193.25,26.6 193.24,26.8 193.03,27.01 192.84,27.01 192.24,26.41 192.03,26.41 191.83,26.61 191.83,26.82 192.23,27.22 192.23,27.43 192.03,27.63 191.82,27.63 191.42,27.23 191.21,27.23 191.11,27.33 189.97,27.33 189.68,27.63 189.39,27.63 189.1,27.33 188.81,27.33 188.52,27.63 188.23,27.63 187.94,27.33 187.65,27.33 187.36,27.63 187.07,27.63 186.78,27.33 160.48,27.33 146.65,41.17 146.65,43.69
  BOTTOM w0.076: v2(148.32,59.24) 148.68,59.6 UC1.AP43
  BOTTOM w0.168: v2(197.09,18.72) 196.37,19.44 JDIMM2.143
DDR_DRAMRST#: length 127.9
  TOP w0.102: RD29.2 79.64,12.3 RD2.2 79.51,11.64 v2(78.62,11.64)
  IN2 w0.122: v2(166.61,57.97) 166.2,57.56 166.2,41.89 165.45,41.15 105.96,41.15 102.35,37.53 99.32,37.53 98.66,36.87 94.49,36.87 v2(94.47,36.89)
  IN4 w0.089: v2(94.47,36.89) 94.54,36.82 94.54,29.44 85.03,19.93 85.03,12.49 84.18,11.64 v2(78.62,11.64)
  BOTTOM w0.076: v2(166.61,57.97) 166.28,58.3 UC1.AT13
DDR_DRAMRST#_R: length 121.3
  TOP w0.102: v2(171.49,10.39) 171.49,10.62 CD35.1 ; v2(78.45,12.27) 78.7,12.27 RD29.1 79.71,13.28 79.71,13.85 CD6.1
  IN3 w0.122: v2(78.45,12.27) 78.69,12.27 79.99,10.98 105.19,10.98 v2(105.88,10.29) 106.51,10.92 146.42,10.92 146.42,10.93 146.72,10.93 146.81,10.84 147.2,10.84 147.44,11.08 147.44,11.27 150.98,14.81 155.28,14.81 158.81,11.28 170.43,11.28 171.31,10.39 v2(171.49,10.39) 172.09,10.99 187.27,10.99 v2(187.82,10.44)
  BOTTOM w0.102: JDIMM2.108 187.62,10.64 v2(187.82,10.44) ; v2(105.88,10.29) 105.88,10.62 105.62,10.88 JDIMM1.108
DDR_VTT_CTRL: length 100.8
  TOP w0.102: v2(75.56,12.23) 75.56,12.61 75.99,13.04 76.55,13.04 76.78,13.27 UD1.2 ; v2(90.03,33.09) 90.26,33.32 104.28,33.32 114.91,43.95 124.19,43.95 125.05,44.8 129,44.8 129.76,45.56 129.76,48.61 130.11,48.96 130.11,49.91 130.24,50.03 130.24,51.95 132.4,54.11 132.4,55.29 132.16,55.53 129.93,55.53 129.73,55.33 v2(127.39,55.33)
  IN1 w0.089: v2(75.56,12.23) 73.83,13.96 73.83,17.87 78.32,22.37 79.89,22.37 90.03,32.51 v2(90.03,33.09)
  BOTTOM w0.076: UC1.AW67 134.71,56.48 134.61,56.58 133.97,56.58 133.95,56.6 132.6,56.6 132.34,56.34 131.5,56.34 130.96,55.8 130.57,55.8 130.12,55.35 129.5,55.35
  BOTTOM w0.102: 129.5,55.35 129.44,55.29 127.72,55.29 127.69,55.33 v2(127.39,55.33)
