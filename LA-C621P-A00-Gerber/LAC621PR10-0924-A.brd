# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 25.5
  TOP w0.305: v2(287.18,38.26) 287.4,38.47 CA17.2
  TOP w0.381: v2(285,30.43) 285.38,30.81 CA9.2 285.7,31.5 CA8.2
  TOP w0.508: CA25.2 286.35,32.85 286.57,33.07 v2(286.57,33.25) ; v2(286.79,27.13) 286.79,26.52 286.23,25.96 286.19,25.96 286.15,25.92 285.88,25.92 285.71,25.76 RA36.1 ; CA51.2 v2(283.04,27.13) ; QA2.1 290.98,42.39 291.2,42.17 291.2,41.43 291.54,41.09 QA2.4 v2(292.05,40.23) ; CA35.1 287.03,29.67 v2(287.07,29.71) ; v2(285.2,39.78) CA52.2 285.2,41.18 RA37.1 ; CA1.2 291.1,33.63 v2(290.74,33.63) ; v2(283.93,39.78) CA16.2 ; CA3.2 291.76,38.63 291.27,39.11 v2(291.27,39.23) ; RA35.1 295.34,22.79 293.84,21.29 v2(293.84,21.29) ; v2(292.44,37.04) 292.31,36.91 CA2.2 ; CA18.2 v2(288.56,39.83)
  VCC w0.203: 295.07,18.85 JHP1.7 ; JHP1.7 295.07,19.52 ; JHP1.7 297.23,19.52 ; JHP1.7 296.15,19.52 ; JHP1.7 297.23,18.85
  vias: v2(281.87,37.06) v2(282.51,37.06) v2(283.04,31.45) v2(283.45,30.99) v2(285.1,27.97) v2(288.28,40.72) v2(290.79,31.55) v3(288.71,31.1) v3(290.08,29.47) v3(290.18,43.57)
VCC_GT_SENSE: length 67.8
  TOP w0.254: PC618.2 PC620.1 79.71,59.64 80.08,60.02 v2(80.08,60.36)
  IN4 w0.254: v2(80.08,60.36) 80.1,60.34 81.58,60.34 82.12,60.87 87.63,60.87 88.9,62.14 88.9,62.2 88.89,62.21 88.89,62.61 88.9,62.63 88.9,66.68 89.97,67.75 98.69,67.75 98.94,67.49 104.63,67.49 106.15,69.02 107.12,69.02 107.86,68.28 114.92,68.28 115.91,69.27 v2(115.91,69.35)
  BOTTOM w0.254: UC1.J70 133.38,72.27 133.2,72.09 132.82,71.9 132.2,71.9 132.04,71.75 130.04,71.75 128.87,70.58 125.9,70.58 124.91,70.58 124.85,70.64 RC161.2 122.32,70.64 121.02,69.35 v3(120.21,69.35) 120.17,69.31 115.95,69.31 v2(115.91,69.35) ; PC617.1 PR622.1 78.98,59.08 79.67,59.08 80.08,59.5 v2(80.08,60.36)
VCCIO_SENSE: length 65.9
  TOP w0.254: RC165.2 158.3,65.21 158.53,64.98 158.53,64.27 158.58,64.22 158.58,61.19 v2(159.26,60.51)
  IN3 w0.254: v2(159.26,60.51) 159.72,60.05 159.72,56.27 159.73,56.27 160.51,55.48 160.51,55.07 166.97,48.61 178.78,48.61 180.58,46.81 186.08,46.81 187.01,47.73 187.81,47.73 188.54,48.47 189.67,48.47 191.5,50.3 191.5,51.91 193.13,53.53 193.13,56.04 195.34,58.25 195.54,58.46 196.88,58.46 197.62,57.71 198.41,57.71 198.59,57.89 201.36,57.89 v2(201.87,58.4)
  BOTTOM w0.254: PR422.1 201.31,58.07 201.64,58.4 v2(201.87,58.4) ; v2(159.26,60.51) 159.66,60.9 UC1.AM23
VCCSA_B+:
  vias: v2(104.58,79.91) v2(105.24,79.91) v3(103.95,79.92)
VCCSENSE: length 85.5
  TOP w0.254: v2(87.24,64.14) 87.69,64.6 PC653.1 PR648.1 ; RC140.2 120.36,68.84 v2(120.36,68.15)
  IN4 w0.254: v2(87.24,64.14) 87.24,65.26 87.51,65.54 87.51,67.09 89.69,69.26 104.6,69.26 106.01,70.67 118.43,70.67 120.38,68.71 120.38,68.17 v2(120.36,68.15) 122.04,66.48 144.87,66.48 145.25,66.86 147.08,66.86 147.57,67.34 148.93,67.34 149.13,67.14 152.72,67.14 154.14,68.55 154.14,72.11 155.18,73.16 155.18,73.65 v2(154.74,74.1)
  BOTTOM w0.254: v2(154.74,74.1) 155.08,74.44 UC1.E32 ; PR648.1 87.39,63.71 87.24,63.86 v2(87.24,64.14) 87.69,64.6 PC651.2
VCCST_PWRGD: length 215.9
  TOP w0.102: v2(223.1,75.96) 223.1,76.08 222.66,76.52 222.06,76.52 221.89,76.7 221.89,77.82 222.14,78.07 RE308.1 224.43,78.07 224.62,77.87 UE4.4 ; v2(97.1,43.16) 96.98,43.03 96.95,43.03 96.36,42.44 96.36,36.32 94.58,34.53 90.95,34.53 87.94,37.55 86.56,37.55 85.69,38.41 RC123.1 ; v2(167.76,88.98) 167.44,88.66 162.41,88.66 160.83,87.09 158.52,87.09 156.46,89.15 152.95,89.15 149.03,93.07 149.03,94.57 147.91,95.7 138.2,95.7 136.73,94.23 134.08,94.23 131.35,91.51 v2(131.23,91.51) 131.05,91.69 131.05,91.7 130.81,91.94 130.3,91.94 129.45,91.09 128.54,91.09 127.55,90.09 127.55,88.42 126.78,87.66 125.69,87.66 125.23,88.12 124.01,88.12 123.68,87.79 123.68,86.78 122.33,85.42 121.3,85.42 120.84,84.97 120.15,84.97 118.32,83.14 117.55,83.14 116.96,82.55 v2(116.96,80.09)
  IN1 w0.089: v2(116.96,80.09) 116.96,77.88 120.86,73.97 120.86,70.71 119.11,68.96 v2(119.11,68.33)
  IN2 w0.122: v2(223.1,75.96) 223.1,76.12 222.15,77.07 204.36,77.07 203.99,76.7 200.75,76.7 200.53,76.92 189.53,76.92 189.28,77.17 186.89,79.56 186.89,80.79 184.03,83.65 183.3,83.65 181.36,85.59 179.5,85.59 178.77,86.31 177.91,86.31 176.11,88.11 173.47,88.11 171.27,88.11 170.69,88.68 168.06,88.68 v2(167.76,88.98)
  IN4 w0.089: v2(119.11,68.33) 118.83,68.05 118.83,64.56 111.06,56.79 111.06,51.29 108.85,49.08 103.02,49.08 v2(97.1,43.16)
  BOTTOM w0.102: v2(131.23,91.51) 131.23,90.74 130.36,89.87 129.3,89.87 127.73,88.29 127.61,88.29 v3(127.45,88.13) 127.01,87.69 127.01,87.43 CC301.1 RC71.2 127.27,86.8 RC78.1
VCCST_PWRGD_CPU: length 15.3
  BOTTOM w0.076: UC1.B65 136.77,76.78 136.77,77.32 136.54,77.54 136.54,78.15 135.77,78.92 131.89,78.92 131.8,79.01 131.31,79.01 130.56,79.76
  BOTTOM w0.102: RC78.2 127.62,84.71 127.62,84.17 129.22,82.57 129.22,81.82 129.47,81.58 v3(129.47,81.11) 129.47,80.67 130.38,79.76 130.56,79.76
VCCST_PWRGD_EC: length 51.1
  TOP w0.102: RE308.2 223.18,77.16 v3(223.41,76.93) 223.51,76.83 223.51,74.99 223.76,74.73 226.03,74.73 226.28,74.98 v2(226.28,75.94) ; v2(258.74,60.05) 258.85,60.05 259.36,59.54 UE2.A44
  IN2 w0.122: v2(239.72,72.94) 239.44,73.22 239.33,73.22 236.81,75.75 234.07,75.75 233.63,75.3 226.84,75.3 226.28,75.86 v2(226.28,75.94)
  IN4 w0.089: v2(258.74,60.05) 258.74,60.05 258.74,60.06 258.02,60.06 256.68,61.4 256.02,61.4 254.85,62.56 254.85,62.98 254.81,63.01 254.81,66.92 251.98,69.75 246.57,69.75 243.52,72.8 240.87,72.8 240.62,72.55 240.1,72.55 v2(239.72,72.94)
VDD_1.2V: length 7.9
  TOP w0.102: v3(88.51,51.32) 88.56,51.28 v2(88.56,50.7)
  IN2 w0.508: v2(93.58,52.02) 93.58,51.41 93.07,50.91 90.16,50.91 89.95,50.7 v2(88.56,50.7)
  BOTTOM w0.508: PR203.1 88.89,51.03 v2(88.56,50.7)
VIN_1.8VALW:
  vias: v2(210.63,104.52) v2(210.84,106.07) v2(211.42,106.07) v2(211.37,104.45) v3(211.42,105.07)
VIN_1V_PRIM:
  vias: v2(201.27,73.75) v2(201.85,73.82) v3(201.79,75.25)
VIN_1VS_VCCIO:
  vias: v2(207.05,53.83) v2(207.66,53.83) v3(207.92,54.37)
VSS_GT_SENSE: length 66.7
  TOP w0.254: v2(79.96,60.98) 79.74,60.98 PC620.2 78.47,60.56 PC619.2 ; PU602.6 v2(82.63,61.93)
  IN4 w0.254: v2(115.28,69.35) 115.28,69.17 114.76,68.66 108.02,68.66 107.28,69.4 105.99,69.4 104.47,67.87 99.1,67.87 98.84,68.13 89.81,68.13 88.52,66.83 88.52,62.79 88.51,62.77 88.51,62.28 87.48,61.26 83.3,61.26 v2(82.63,61.93) 81.96,61.26 81.96,61.26 81.51,60.81 80.14,60.81 v2(79.96,60.98)
  BOTTOM w0.076: 132.31,72.43 132.46,72.59 132.64,72.59 132.84,72.54 132.98,72.5 133.04,72.5 133.04,72.5 133.16,72.5 133.27,72.54 133.28,72.55 133.76,72.55 UC1.J69
  BOTTOM w0.254: v2(115.28,69.35) 115.43,69.5 115.43,69.55 115.71,69.83 116.11,69.83 116.21,69.73 118.11,69.73 v3(118.18,69.79) 119.88,69.79 119.95,69.87 121,69.87 122.57,71.43 RC163.1 123.61,71.15 124.98,71.15 125.17,70.96 128.72,70.96 129.85,72.09 131.74,72.09 132.31,72.43
VSSIO_SENSE: length 61.4
  TOP w0.254: v2(160.27,60.57) 160.39,60.69 RC167.1
  IN3 w0.254: v2(202.5,58.4) 202.5,58.58 202.2,58.88 201.56,58.88 200.95,58.27 198.43,58.27 198.25,58.09 197.78,58.09 197.04,58.84 195.39,58.84 195.18,58.63 192.75,56.2 192.75,53.69 191.12,52.06 191.12,50.46 189.51,48.85 188.39,48.85 187.65,48.12 186.85,48.12 185.93,47.19 180.74,47.19 178.94,48.99 167.13,48.99 161.07,55.05 161.07,56.6 160.64,57.03 160.64,60.2 v2(160.27,60.57)
  BOTTOM w0.254: UC1.AM22 160.6,60.9 v2(160.27,60.57) ; PR412.1 203.21,58.07 202.88,58.4 v2(202.5,58.4)
VSSSENSE: length 85.3
  TOP w0.203: PU602.18 85.72,66.67
  TOP w0.254: v2(121.04,68.48) 121.04,68.53 121.5,68.99 RC141.1 ; PC653.2 87.77,65.51 87.03,66.25 v2(87.03,66.42) 86.78,66.67 85.72,66.67
  IN4 w0.254: v2(87.03,66.42) 87.04,66.41 87.04,67.15 89.53,69.64 104.44,69.64 105.85,71.05 118.63,71.05 121.04,68.63 v2(121.04,68.48) 121.04,68.36 122.54,66.86 144.72,66.86 145.1,67.24 146.93,67.24 147.41,67.72 149.08,67.72 149.29,67.52 152.56,67.52 153.76,68.71 153.76,72.44 154.27,72.95 154.27,74.38 v2(154.68,74.79)
  BOTTOM w0.254: v2(154.68,74.79) 154.59,74.79 UC1.E33 ; PC654.2 87.46,65.84 87.46,65.84 87.31,65.99 87.31,65.99 87.03,66.27 v2(87.03,66.42) 86.64,66.82 v3(86.43,66.82)
3301_ACAV_IN_NB: length 2.5
  TOP w0.102: PR922.1 25.34,85.88 25.34,85.6 26.18,84.76 PU901.24
3301_PWRSRC: length 2.8
  TOP w0.254: PU901.15 v3(30.95,81.79) 32.04,81.79 PR939.1
+BL_PWR_SRC:
  vias: v2(88.45,85.27) v2(88.45,84.66) v2(89.11,85.25) v2(89.14,84.66) v3(87.9,86.02) v3(87.88,82.9) v3(89.31,84.12)
+CAP_LDO: length 8.1
  TOP w0.305: v2(251.09,78.85) 251.14,78.79 UE1.B46
  TOP w0.508: v2(253.71,75.06) 253.96,75.06 254.98,74.04 CE7.1
  BOTTOM w0.508: v2(251.09,78.85) 251.09,78.8 251.82,78.07 251.91,78.07 253.71,76.27 v2(253.71,75.06)
+COINCELL: length 8.7
  TOP w0.508: PR2.1 PC8.2 278.01,9.5 v3(277.49,8.98) 277.24,8.74 v2(276.54,8.74)
  BOTTOM w0.508: JRTC1.1 274.29,8.04 274.99,8.74 v2(276.54,8.74)
+CRT_VCC: length 7
  TOP w0.254: v2(247.53,104.5) 247.53,103.75 v3(247.51,103.72)
  BOTTOM w0.381: RV38.1 241.74,100.84
  BOTTOM w0.457: v2(240.9,104.1) CV50.1 ; RV35.1 v2(236.36,104.02)
  BOTTOM w0.508: CV50.1 240.9,102.85 241.74,102.01 241.74,100.84 RV37.1
  vias: v2(246.93,104.5)
+DC_IN: length 52.7
  TOP w0.508: PR830.1 v2(59.83,94.82) 60.22,95.22 v3(60.37,95.22) ; PR921.1 v2(24.37,75.39)
  IN4 w0.508: v2(24.37,75.39) 23.71,76.05 23.71,77.65 24.83,78.77 29.91,78.77 31.1,77.58 32.7,77.58 33.62,78.49 33.62,84.92 35.67,86.97 37.81,86.97 v2(37.83,87) 37.86,86.97 46.14,86.97 50.51,91.34 55.51,91.34 58.99,94.82 59.82,94.82 59.83,94.83 v2(59.83,94.82)
  vias: v3(36.21,89.68) v3(38.97,91.66)
+DC_IN_SS: length 194.5
  TOP w0.508: v2(54.44,82.45) 54.44,83 PD801.2 ; v2(55.97,73.56) v3(57.65,73.56) 59.57,73.56 63.13,70.01 69.46,70.01 74.72,75.26 82.31,75.26 85.18,72.4 85.18,70.18 86.27,69.08 86.66,69.08 86.88,68.85 89.84,68.85 90.73,67.96 91.23,67.96 91.74,67.45 91.74,66.95 90.29,65.51 90.29,62.7 v2(90.03,62.44)
  IN2 w0.508: v2(55.97,73.56) 55.42,74.11 49.95,74.11 45.95,78.11 38.04,78.11 v2(36.26,79.89)
  IN3 w0.508: v2(90.03,62.44) 90.03,62.11 91.68,60.46 94.24,60.46 95.37,59.33 95.37,58.31 95.82,57.85 96.36,57.85 97.2,57.01 97.2,54.85 v2(97.01,54.66) ; v2(54.44,82.45) 53.05,83.85 49.59,83.85 46.84,81.11 45.79,81.11 45.17,81.11 43.95,79.89 v2(36.26,79.89) 32.14,79.89 v2(31.58,79.33)
  BOTTOM w0.508: v2(31.58,79.33) 31.05,79.33 30.21,78.49 28.28,78.49 27.72,79.05 26.33,79.05 PR935.1 ; v2(58.64,10.52) 58.64,10.52 59.12,10.52 61.05,12.45 61.05,13.85 64.54,17.34 68.37,17.34 68.89,17.86 71.08,17.86 73.32,20.1 73.32,21.03 74.62,22.33 74.62,35.44 82.14,42.97 94.07,42.97 94.47,42.57 95.84,42.57 97,41.41 97.53,41.41 98.28,42.16 98.28,42.83 98.8,43.34 98.8,50.14 97.85,51.08 97.85,54 97.19,54.66 v2(97.01,54.66)
+DCIN_JACK:
  vias: v2(43.45,90.59) v2(43.49,91.25) v2(43.79,91.75) v2(44.08,91.11) v2(44.06,90.53) v2(44.66,91.19) v2(44.69,90.58) v3(48.18,90.92) v3(50.09,91.91) v3(51.36,90.11)
+DCPRTC: length 12.3
  TOP w0.102: CC214.1 174.84,46.68 v3(173.13,48.39) 172.81,48.71 172.81,50.25 v2(173.01,50.45)
  BOTTOM w0.076: 172.3,51.16 172.3,51.23 171.1,52.43 170.91,52.43 170.56,52.79 169.63,52.79 167.79,54.62 UC1.BB10
  BOTTOM w0.102: 172.3,51.16 v2(173.01,50.45)
+DDR_VREF_A_CA: length 4.5
  TOP w0.508: v2(121.12,10.29) 121.17,10.34 RD20.1 ; RD20.1 RD18.2 ; RD20.1 RD19.1
  BOTTOM w0.305: JDIMM1.164 121.62,10.8 121.12,10.29 v2(121.12,10.29)
+DDR_VREF_A_DQ: length 11.2
  TOP w0.508: T132.1 131.58,47.17 131.58,51.33 131.91,51.66 131.91,52.43 132.91,53.44 v2(134.54,55.06)
  BOTTOM w0.254: v2(134.54,55.06) 134.5,55.09 UC1.AY68
+DDR_VREF_B_CA: length 140
  TOP w0.102: v1(76.09,10.21) 75.81,10.21 75.64,10.38 v2(75.64,10.85)
  TOP w0.508: v2(75.64,10.85) 75.64,11.18 75.21,11.61 RD24.1 74.74,12.28 75.12,12.66 RD22.2 75.07,13.01 RD75.1
  IN3 w0.381: v2(203.62,10.41) 202.83,11.21 188.13,11.21 187.58,11.75 171.3,11.75 171.02,12.04 159.13,12.04 155.59,15.57 150.17,15.57 146.28,11.68 112.59,11.68 112.53,11.74 80.3,11.74 78.52,13.52 77.79,13.52 75.64,11.37 v2(75.64,10.85)
  BOTTOM w0.356: JDIMM2.164 v2(203.62,10.41)
+DDR_VREF_B_DQ: length 93.8
  TOP w0.508: v2(73.34,14.78) 73.34,14.47 73.34,14.47 CD54.1 RD75.2
  BOTTOM w0.152: UC1.BA67 135.14,55.07 134.82,54.75 134.82,54.34 134.79,54.31
  BOTTOM w0.203: 134.79,54.31 134.69,54.21 134.64,54.21 134.09,53.66 131.67,53.66 130.54,52.53 129.45,52.53 129.2,52.28
  BOTTOM w0.508: 129.2,52.28 128.71,51.79 128.71,50.56 124.73,46.57 106.14,46.57 101.26,41.69 100.14,41.69 99.22,40.77 98.33,40.77 97.95,40.39 96.58,40.39 95.66,41.32 94.29,41.32 93.75,41.85 83.98,41.85 83.43,41.3 83.43,40.85 82.69,40.11 80.72,40.11 75.71,35.1 75.71,20.69 72.71,17.69 v3(72.71,16.6) 72.71,15.41 v2(73.34,14.78)
+DDR_VREF_CA: length 79.4
  TOP w0.508: CD36.1 RD19.2 122.03,12.93 v2(121.83,13.14)
  IN4 w0.508: v2(121.83,13.14) 120.38,13.14 118.86,14.66 118.86,19.31 118.12,20.04 114.74,20.04 113.4,21.39 113.4,23.47 105.87,31 105.87,44.26 v2(105.52,44.61)
  BOTTOM w0.203: 131.85,53.24 131.95,53.34 134.99,53.34 135.47,53.82 135.47,55.62 135.26,55.83 UC1.AY67
  BOTTOM w0.381: 131.85,53.24 129.88,51.28 129.88,50.38 v1(129.46,49.96) 125.12,45.62 106.54,45.62 v2(105.52,44.61)
+DOCK_PWR_BAR: length 41.3
  TOP w0.508: v2(53.58,84.28) 54.27,84.97 PD802.2 54.8,84.97 55.51,85.68 58.01,85.68 59.17,84.52 59.17,82.7 58.43,81.96 v2(58.43,81.96)
  IN3 w0.508: v2(31.81,82.63) 31.96,82.63 34.07,80.52 43.6,80.52 44.82,81.74 46.05,81.74 46.05,81.74 46.58,81.74 49.47,84.64 53.22,84.64 v2(53.58,84.28)
  BOTTOM w0.508: PR924.2 25.98,80.67 26.94,80.67 27.98,81.72 30.39,81.72 31.3,82.63 v2(31.81,82.63)
  vias: v2(74.79,16.11) v2(75.07,16.72) v2(75.37,16.11) v2(75.65,16.72) v2(75.96,16.11) v2(76.24,16.7) v2(76.54,16.11) v2(77.36,18.71) v2(77.38,17.75) v2(96.05,92.61) v2(96,92) v2(96.63,92.61) v2(96.58,92) v2(97.22,92.61) v2(97.19,92) v2(97.8,92.61) v2(97.78,92) v2(98.39,92.64) v2(98.36,92.03) v2(127.21,99.93) v2(127.19,99.29) v2(127.93,99.95) v2(127.95,99.27) v2(128.71,99.93) v2(128.71,99.24) v3(129.93,97.46)
+LCDVDD:
  vias: v2(82.51,87.46) v2(82.64,85.3) v2(83.4,85.3) v2(94.09,84.56) v2(94.58,84.15) v2(95.06,84.54) v3(83.35,86.97) v3(84.6,85.76) v3(85.17,87.73)
+LOM_VCT: length 5
  TOP w0.508: C316.1 v3(164.98,108.19) 164.98,107.61 v2(165.18,107.42)
  BOTTOM w0.254: JDOCK1.118 165.5,107.81 165.18,107.49 v2(165.18,107.42) 165,107.6 JDOCK1.116
+MIC1_VREF_OUT: length 19.5
  TOP w0.203: UA1.30 282.67,33.28 282.92,33.53 v2(283.3,33.53)
  TOP w0.508: DA4.2 280.94,23.07 v3(280.94,22.69) 281.41,22.22 283.17,22.22 283.58,22.63 283.58,23.36 DA5.2 283.04,24.11 283.67,24.73 283.67,25.6 283.96,25.89 283.96,26.57 v2(284.14,26.75)
  IN1 w0.508: v2(283.3,33.53) 283.13,33.7 282.49,33.7 282.25,33.46 282.25,31.35 282.84,30.76 282.84,29.89 283.76,28.98 283.76,27.05 284.06,26.75 v2(284.14,26.75)
+NBDOCK_DC_IN_SS: length 269.2
  TOP w0.508: v2(28.46,88.13) 28.54,88.06 PR927.2 ; PD905.2 59.37,12.23 v2(58.93,12.68)
  IN1 w0.508: v2(28.46,88.13) 28.46,83.09 29.08,82.48 29.08,77.91 28.31,77.14 28.31,76.51 30.54,74.27 43.48,74.27 44.08,73.67 45.95,73.67 46.93,72.7 50.76,72.7 52.67,70.79 52.75,70.79 52.78,70.76 56.23,70.76 56.26,70.79 56.3,70.79 57.8,72.29 61,72.29 68.46,64.82 68.46,61.39 67.63,60.55 67.63,59.14 v2(66.51,58.02)
  IN2 w0.508: v2(58.93,12.68) 58.9,12.7 56.32,12.7 54.04,14.99 54.04,15.73 58.8,20.49 62.02,20.49 63.14,19.37 63.14,18.43 63.71,17.86 67.71,17.86 72.3,22.45 72.3,37.77 69.2,40.87 69.2,50.3 68.31,51.18 68.31,51.97 68.06,52.22 68.06,56.47 v2(66.51,58.02)
  IN3 w0.508: v2(141.34,104.37) 141.34,104.02 139.51,102.19 136.36,102.19 132.45,98.28 122.83,98.28 120.36,95.81 118,95.81 117.49,95.3 117.49,93.85 115.84,92.21 110.61,92.21 109.98,92.84 106.01,92.84 105.6,93.25 102.34,93.25 101.93,93.25 100.01,95.17 89.35,95.17 89.14,95.39 71.44,95.39 70.46,94.4 68.48,94.4 68.47,94.41 68.45,94.41 68.01,94.85 65.01,94.85 63.85,96.01 62.49,96.01 61.93,96.57 55.15,96.57 45.2,86.62 40.43,86.62 37.65,89.4 29.73,89.4 v2(28.46,88.13)
  BOTTOM w0.254: JDOCK1.41 144.5,102.28 142.4,104.37 v2(141.34,104.37)
+PBATT: length 172.9
  TOP w0.508: 72.23,26.09 72.97,26.83 72.97,29.32 74.37,30.71 v2(76.62,30.71)
  IN2 w0.508: v2(76.62,30.71) 76.62,30.74 76.44,30.91 76.44,39.63 75.25,40.82 75.25,42.57 78.07,45.39 78.07,47.6 78.9,48.44 91.65,48.44 94.42,51.21 94.42,56.97 93.02,58.37 93,58.37 92.26,59.11 86.26,59.11 85.73,59.64 81.38,59.64 80.79,59.06 78.87,59.06 76.72,61.2 73.02,61.2 71.59,62.63 71.59,66.18 69.92,67.86 69.92,68.41 v2(71.67,70.16)
  IN3 w0.508: v2(31.79,83.34) 33.53,83.34 35.71,81.16 43.33,81.16 44.55,82.38 46.32,82.38 49.21,85.27 54.04,85.27 54.6,84.71 54.6,83.37 55.21,82.76 v2(55.21,82.4) 55.65,82.4 59.6,86.35 59.6,90.05 60.36,90.81 61.76,90.81 62.11,90.45 63.31,90.45 64.3,89.46 68.61,89.46 v2(69.58,88.49)
  IN4 w0.508: v2(71.67,70.16) 73.1,71.59 73.1,74.44 73.67,75 76.99,75 78.33,76.34 78.33,77.21 77.57,77.97 77.57,80.66 76.68,81.54 76.68,81.8 75.6,82.88 75.6,86.85 74.23,88.22 69.85,88.22 v2(69.58,88.49)
  BOTTOM w0.508: PR933.2 25.89,82 27.24,82 v3(27.6,82.35) 30.13,82.35 31.12,83.34 v2(31.79,83.34) ; v2(55.21,82.4) 55.18,82.42 55.18,82.8 54.72,83.27 PD803.2 ; v2(69.58,88.49) 68.81,89.26 PR826.2
  vias: v2(66.67,26.46) v2(67.23,27) v2(67.24,26.29) v2(67.33,27.7) v2(67.89,26.96) v2(67.9,26.29) v2(67.99,27.68) v2(68.56,26.95) v2(68.55,26.26) v2(69.21,26.91)
+PECI_VREF: length 0.9
  TOP w0.203: v3(259.48,56.52) 259.48,55.62 259.45,55.59
+PWR_SRC: length 66.1
  TOP w0.508: RZ85.1 275.14,10.28 v2(275.31,10.1)
  IN1 w0.508: v2(247.08,16.15) 249.57,16.15 251.38,17.96 255.46,17.96 256.15,18.64 256.15,19.16 256.86,19.88 260.75,19.88 262.63,18 265.22,18 265.9,17.31 268.06,17.31 268.46,16.91 268.46,13.08 271.87,9.67 274.88,9.67 v2(275.31,10.1)
  IN4 w0.508: v2(229.42,33.51) 231.31,31.61 231.31,26.9 232.15,26.06 232.15,24.3 233.64,22.82 234.85,22.82 238.5,19.16 241.1,19.16 242.33,17.93 243.58,17.93 245.36,16.15 v2(247.08,16.15)
  vias: v2(78.26,33.39) v2(78.26,32.77) v2(78.26,32.12) v2(78.27,31.52) v2(78.6,31.02) v2(78.8,32.96) v2(78.84,32.26) v2(78.93,31.59) v2(79.19,31.02) v2(79.41,79.76) v2(79.41,78.95) v2(79.47,32.27) v2(79.58,31.65) v2(79.78,31.05) v2(80.15,79.76) v2(80.15,78.95) v2(80.19,31.65) v2(80.41,31.04) v2(80.89,79.73) v2(80.86,78.95) v2(81.62,79.76) v2(81.6,78.95) v2(82.36,79.79) v2(82.36,78.97) v2(83.17,79.81) v2(83.2,78.97) v2(83.83,78.97) v2(84.06,59.01) v2(84.72,58.98) v2(85.33,58.98) v2(226.01,68.47) v2(226.47,69.04) v2(226.65,68.48) v2(227.06,69.04) v2(227.24,68.47) v2(227.65,69.07) v2(227.84,68.46) v2(228.05,60.18) v2(228.23,69.07) v2(228.43,68.52) v2(228.57,67.95) v2(228.66,60.18) v2(234.4,48.42) v2(234.45,47.29) v2(234.61,47.86) v2(234.78,48.87) v2(234.98,48.31) v2(235.02,47.13) v2(235.24,49.33) v2(235.21,47.69) v2(235.37,48.75) v2(235.65,49.76) v2(235.58,48.16) v2(235.81,49.2) v2(235.98,48.64) v2(236.13,50.22) v2(236.23,49.65) v2(236.39,49.06) v2(236.54,50.65) v2(236.71,50.09) v2(236.82,49.5) v2(237.1,50.82) v3(85.61,60.47)
+PWR_SRC_AC: length 23
  TOP w0.508: v2(31.61,78.62) 31.94,78.62 32.24,78.92 PR939.2
  IN3 w0.508: v2(50.99,82.43) 49.16,82.43 47.2,80.47 47.11,80.47 47.11,80.47 45.53,80.47 45.5,80.47 44.28,79.25 32.47,79.25 31.84,78.62 v2(31.61,78.62)
  vias: v2(50.81,83.19) v2(51.47,83.19) v2(51.75,82.43) v2(52.11,83.19) v2(52.46,82.43) v2(52.74,83.19) v2(117.26,100.59) v2(117.41,101.15) v2(117.55,100.11) v2(117.74,101.93) v2(117.94,101.36) v2(117.98,102.65) v2(117.99,100.59) v3(48.66,81.04)
+PWR_SRC_R: length 3.3
  TOP w0.305: v3(273.58,9.82) 272.83,9.82 272.46,9.44 JUSH1.26
  TOP w0.508: RZ85.2 274.22,10.39 273.65,9.82 v3(273.58,9.82)
+REGCTL_PNP10: length 2.5
  TOP w0.203: v2(258.94,86.03) 259.31,86.03 v3(259.55,86.27) 259.76,86.48 260.38,86.48 260.63,86.73 UL1.7
+RREF: length 3.6
  TOP w0.229: UR2.9 260.1,43.04 259.97,43.18 259.97,43.55
  TOP w0.305: 259.97,43.55 260.39,43.97 260.39,44.39 259.31,45.47 RR20.1
+RSVD_VCC3P3_1:
  vias: v3(259.91,90.08)
+RTC_CELL: length 248.1
  TOP w0.254: RC69.2 166.41,45.95 166.41,45.95 166.56,45.8 166.56,45.8 166.94,45.42 CC213.1 166.97,44.19 167.38,43.78 167.38,42.25 v2(167.19,42.07) 167.19,41.38 172.11,36.47 198.48,36.47 200.84,38.83 211.91,38.83 v2(212.77,39.69)
  TOP w0.508: v2(277.74,15.75) 277.5,15.51 PC2.1 277.5,12.85 PD1.1 ; v2(189.14,47.25) 189.35,47.04 189.35,45.79 188.89,45.33 RC56.2 187.89,44.66 186.85,44.66 186.55,44.95 RC57.2 ; 276.67,51.4 276.91,51.4 277.4,50.91 RE31.1 277.55,50.65 v3(278.39,49.82) 279.12,49.09 281.14,49.09 282.35,47.88 288.4,47.88 293.05,43.23 RA21.1 ; 276.67,51.4 276.67,51.41 276.62,51.46 276.62,53.27 275.02,54.87 274,54.87 273.39,55.47 273.39,56.42 273.95,56.98 276.54,56.98 ; 276.67,51.4 v2(276.62,51.4) ; RE62.1 RE32.1 v2(275.7,51.36)
  IN1 w0.381: v2(167.19,42.07) 167.19,45.11 165.36,46.94 v2(165.36,53.98) 164.12,53.98 162.39,55.71 162.39,56.47 162.44,56.52
  IN1 w0.508: v2(212.77,39.69) 213.21,39.69 213.72,39.17 215.32,39.17 217.7,36.8 219.59,36.8 220.47,35.92 224.61,35.92 225.28,36.59 227.73,36.59 228.01,36.87 235.36,36.87 236.41,35.82 238.8,35.82 239.18,35.44 241.93,35.44 244.12,37.63 248.12,37.63 248.29,37.8 249.59,37.8 249.77,37.62 250.54,37.62 250.81,37.35 253.6,37.35 255.73,39.48 257.62,39.48 258.08,39.02 263.91,39.02 265.38,40.48 267.16,40.48 v2(269.4,42.73)
  IN2 w0.508: v2(212.77,39.69) 212.49,39.41 197.34,39.41 189.64,47.11 189.28,47.11 v2(189.14,47.25)
  IN3 w0.508: v2(277.74,15.75) 277.74,16.95 274.66,20.02 273.72,20.02 272.57,21.17 272.57,22.85 271.44,23.98 271.44,25.57 269.55,27.46 269.55,29.09 269.33,29.31 269.33,40.5 269.01,40.82 269.01,40.86 268.95,40.92 268.95,42.27 v2(269.4,42.73) 269.84,43.16 269.84,45.93 275.27,51.36 v2(275.7,51.36)
  BOTTOM w0.178: v2(165.36,53.98) 165.37,53.99 UC1.BB14
  BOTTOM w0.254: UC1.AK19 162.62,61.66 162.62,61.45 v2(162.91,61.15)
  BOTTOM w0.508: v2(275.7,51.36) 275.68,51.36 275.71,51.4 v2(276.62,51.4)
+RTC_CELL_VBAT: length 10.5
  TOP w0.254: v2(267.9,57.36) UE2.B64
  TOP w0.508: RE32.2 275.07,52.79 273.43,54.42 CE11.1 272.35,54.81 271.22,55.93 v2(270.32,55.93)
  IN4 w0.457: v2(267.9,57.36) 269.32,55.93 v2(270.32,55.93)
+SDC_IN: length 31.1
  TOP w0.508: PR928.1 28.08,74.12 v2(28.56,74.12)
  IN3 w0.508: v2(45.66,83.27) 46.31,83.27 48.95,85.91 54.65,85.91 55.33,86.59 55.33,87.91 55.69,88.27 v2(58.33,88.27) ; v2(28.56,74.12) 37.45,74.12 39.58,76.25 v2(39.74,76.25)
  BOTTOM w0.203: PU801.3 58.93,88.13 58.88,88.19 58.41,88.19 v2(58.33,88.27)
  BOTTOM w0.508: v2(58.33,88.27) 58.28,88.27 57.7,88.85 PR812.2
  vias: v3(42.74,80.03)
+SDREG2:
  vias: v3(265.68,38.91)
+SIM_PWR: length 64
  IN3 w0.508: v2(286.22,83.59) 286.22,82.94 285,81.72 285,80.06 283.15,78.21 283.15,74.5 282.04,73.4 278.53,73.4 276.59,71.46 272.28,71.46 269.1,74.63 266.41,74.63 265.95,74.17 261.99,74.17 260.98,73.17 v2(260.98,73.18)
  BOTTOM w0.305: JNGFF2.28 244.38,68.8 244.94,69.36 247.62,69.36 249.62,71.35 254.49,71.35 256.29,73.16 260.96,73.16 v2(260.98,73.18)
  BOTTOM w0.508: v2(286.22,83.59) 285.57,83.59 C263.1 286.06,84.38 288.34,84.38 290.07,86.11 JSIM1.1
+USB_LEFT_PWR:
  vias: v3(16.58,94.31) v3(17.89,89.3) v3(19.45,94.43)
+USB_REAR_PWR:
  vias: v3(72.1,94.03) v3(73.54,95.74) v3(73.8,93.54)
+UZ12_TPM: length 5.4
  TOP w0.102: RZ89.2 190.3,61.66 190.11,61.85 v1(190.11,61.99) 190.11,62.03 190.58,62.5 CZ73.1 191.25,63.03 RZ88.2 191.74,63.97 191.4,64.3 UZ12.8
+V_DDR_REF: length 2.6
  TOP w0.508: v2(93.13,57.03) 93.13,57.2 v3(92.7,57.62) 91.89,57.62 91.6,57.34 PC210.1
+VCHGR:
  vias: v2(69.46,36.22) v2(69.48,35.64) v2(69.48,35.06) v2(69.73,36.78) v2(70.12,36.25) v2(70.14,35.64) v2(70.14,35.06) v2(70.47,36.81) v2(70.75,36.2) v2(70.8,35.61) v2(70.8,35.03) v2(71.11,80.7) v2(71.11,80.09) v2(71.08,79.46) v2(71.08,78.85) v2(71.44,35.64) v2(71.49,35.06) v2(71.84,80.7) v2(71.84,80.09) v2(71.84,79.46) v2(71.84,78.85) v2(72.71,81.28) v2(72.68,80.67) v2(72.68,80.06) v2(72.68,79.43) v2(72.68,78.82) v3(71.14,36.77)
+VHDMI_VCC:
  vias: v2(91.02,99.85) v2(91.58,99.65) v2(92.03,100.11) v2(92.44,99.7) v3(91.46,100.24)
+VLDOIN_1.2V: length 3.6
  BOTTOM w0.254: v3(90.63,59.13) 89.52,58.02 89.52,55.98
+VR_CAP: length 14.4
  TOP w0.305: UE2.B12 269.56,62.79 269.08,63.27 269.08,63.74 v2(269.08,63.74)
  TOP w0.406: v2(273.85,66.4) 273.62,66.63 273.62,66.65 272.76,67.51 CE31.1 v3(272.76,68.91)
  IN1 w0.406: v2(273.85,66.4) 273.8,66.45 273.8,66.47 273.8,66.48 268.87,66.48 267.7,65.31 267.7,64.19 268.15,63.74 v2(269.08,63.74)
+VREFOUT: length 18.6
  TOP w0.203: 281.56,29.24 280.91,29.89 UA1.23
  TOP w0.508: v2(286.96,30.71) 287.44,30.71 287.8,30.35 287.8,29.4 287.36,28.96 286.45,28.96 286.14,28.66 CA26.1 284.97,29.01 v3(282.54,29.01) 281.79,29.01 281.56,29.24 ; v2(290.74,34.37) RA6.2 289.98,34.32 RA5.2
  IN2 w0.508: v2(290.74,34.37) 290.87,34.24 290.99,34.24 291.35,33.89 291.35,33.38 288.68,30.71 v2(286.96,30.71)
+Z4012: length 3.4
  TOP w0.508: v3(280.29,13.69) 280.29,13.09 PD1.2 279.22,11.69 279.76,11.15 PR2.2
/BATPRES: length 233.8
  IN3 w0.122: v2(252.26,86.41) 252.47,86.63 252.47,89.08 251.78,89.77 251.17,89.77 250.16,90.78 250.15,90.78 249.76,91.18 249.34,91.18 249.1,91.42 249.1,91.75 248.96,91.89 248.96,92.6 248.43,93.13 248.43,95.83 248.43,95.84 248.43,96.45 245.79,99.09 245.5,99.38 245.36,99.53 245.05,99.83 243.99,99.83 243.24,100.58 232.64,100.58 232.15,101.08 229.19,101.08 227.32,102.94 214.53,102.94 213.66,102.08 209.44,102.08 208.04,100.68 208.04,99.52 201.92,93.4 200.35,93.4 200.27,93.33 191.71,93.33 188.52,96.52 175.91,96.52 171.04,101.39 168.58,101.39 167.27,102.7 167.27,105.45 166.11,106.61 160.97,106.61 160.43,107.15 149.64,107.15 148.76,106.27 145.47,106.27 140.58,101.38 136.71,101.38 133.17,97.84 123.68,97.84 120.26,94.42 118.92,94.42 116.26,91.76 110.23,91.76 109.6,92.4 105.83,92.4 105.42,92.81 101.74,92.81 101.57,92.98 99.82,94.73 89.17,94.73 88.96,94.95 73.32,94.95 71.44,93.06 70.89,93.06 70.12,93.83 v2(68.22,93.83)
  BOTTOM w0.102: v2(68.22,93.83) 66.78,92.38 PR828.2 64.22,89.95 64,89.73 PU801.15 ; PR904.2 256.72,91.53 253.64,91.53 253.5,91.39 253.5,89.58 v3(253.16,89.24) 252.26,88.34 v2(252.26,86.41)
A_ON: length 47
  TOP w0.102: UE2.A4 272.18,59.04 v2(272.68,59.54) 273.32,58.91 275.78,58.91 276.29,59.42 276.29,60.65 276.24,60.7 v3(276.24,60.87) 276.52,61.15 RPE10.3 ; v2(248.47,46.31) 248.45,46.31 247.8,45.66 UZ8.3
  IN1 w0.089: v2(248.47,46.31) 248.82,46.65 249.15,46.65 249.82,47.32 249.82,49.91 251.26,51.36 255.83,51.36 256.97,52.5 257.25,52.5 257.74,52.99 259.26,52.99 261.14,51.11 261.94,51.11 v2(262.42,50.63)
  IN3 w0.122: v2(272.68,59.54) 272.26,59.12 270.53,59.12 270.2,59.45 269.01,59.45 268.74,59.72 267.65,59.72 266.42,58.49 266.42,57.19 263.87,54.64 262.57,54.64 262.18,54.25 262.18,53.35 262.42,53.12 v2(262.42,50.63)
AC_DIS: length 305.6
  TOP w0.102: PQ1.5 v2(43.13,88.12) ; UE1.A50 255.51,79.38 255.69,79.2 255.69,78.26 256.4,77.55 RE83.2 257.16,77.12 257.26,77.02 258.51,77.02 v2(258.74,77.25) ; v2(54.14,94.16) 54.34,93.96 54.34,91.53 53.17,90.36 PR837.1 53.95,90.15 PQ809.2
  IN2 w0.122: v2(258.74,77.25) 259.19,77.7 260.49,77.7 261.96,79.16 261.96,81.22 261.17,82.01 261.17,83.25 260.12,84.3 259.55,84.3 258.25,85.6 258.25,87.35 257.38,88.22 257.38,90.03 253.38,94.02 249.87,94.02 244.61,99.28 244.61,101.68 244.16,102.13 234.8,102.13 232.36,99.69 225.29,99.69 224.17,100.82 214.39,100.82 213.88,101.32 208.45,101.32 201.66,94.54 192.84,94.54 187.39,100 187.26,100 187.26,100 184.87,100 180.3,104.57 180.3,108.24 178.31,110.23 165.61,110.23 164.97,109.59 161.01,109.59 160.69,109.91 157.62,109.91 157.17,109.46 155.71,109.46 148.69,109.46 148.24,109.91 146.66,109.91 143.4,106.66 143.4,104.78 143.41,104.78 143.41,104.52 139.98,101.1 139.73,101.1 139.73,101.09 139.47,101.09 139.47,101.1 135.6,101.1 131.7,97.2 128.83,97.2 125.47,93.84 125.16,93.84 123.49,93.84 122.58,92.93 110.45,92.93 110.09,93.29 107.31,93.29 106.91,93.56 106.91,93.56 106.8,93.64 106.48,93.77 106.29,93.85 106.11,93.92 105.96,93.98 105.6,94.16 105.33,94.16 104.98,94.23 104.58,94.31 103.86,94.31 103.64,94.53 82.85,94.53 81.01,96.37 67.02,96.37 66.95,96.44 63.82,96.44 63.54,96.16 58.78,96.16 56.78,94.16 v2(54.14,94.16) ; v2(43.13,88.12) 42.83,88.12 42.33,88.62 39.83,88.62 38.84,89.62 37.27,89.62 v2(35.62,91.26)
  IN4 w0.089: v2(35.62,91.26) 36.65,91.26 39.33,88.57 45.81,88.57 50.02,92.79 50.94,92.79 52.72,94.57 53.73,94.57 v2(54.14,94.16)
  BOTTOM w0.102: v2(35.62,91.26) 35.62,87.11 38.72,84.01 v3(38.72,83.58) 37.71,82.57 PR916.1
AC_PRESENT: length 124.5
  TOP w0.102: v2(218.53,44.66) 218.53,45.55 RC243.1 ; UE2.A54 264.65,55.4 264.35,55.1 264.35,54.94 264.22,54.81 264.22,52.15 263.23,51.15 263.23,49.32 v2(263.21,49.29)
  IN1 w0.089: v2(263.21,49.29) 263.08,49.42 262.51,49.42 261.2,50.73 258.51,50.73 256.85,49.06 256.85,47.32 254.48,44.95 252.4,44.95 251.4,43.95 249.24,43.95 248.78,44.4 247.01,44.4 245.35,42.75 245.13,42.75 244.75,42.75 244.06,42.07 242.06,42.07 240.95,40.97 238.35,40.97 238.14,41.18 237.75,41.18 235.62,41.18 235.04,40.6 234.26,40.6 229.41,40.6 229.21,40.8 224.55,40.8 222.34,43.01 220.09,43.01 218.53,44.57 v2(218.53,44.66)
  BOTTOM w0.076: UC1.AY15 164.65,55.66 164.49,55.37 164.38,55.26 164.38,53.74 166.76,51.35 167.02,51.35 167.31,51.06
  BOTTOM w0.102: v2(218.53,44.66) 218.29,44.66 216.41,42.78 212.89,42.78 212.72,42.61 210.22,42.61 209.93,42.32 209.24,42.32 208.21,43.36 207.66,43.36 206.61,42.31 180.09,42.31 176.38,46.02 171.34,46.02 168.21,49.14 168.21,50.16 167.31,51.06
ACAV_DOCK_SRC#: length 158
  TOP w0.102: PR920.2 PR923.1 26.61,74.44 26.38,74.21 v1(26.38,73.78) 26.38,73.65 26.49,73.54 30.01,73.54 31.51,75.03 v2(31.51,76.71)
  IN2 w0.122: v2(145.15,110.71) 144.61,110.71 142.6,108.69 133.74,108.69 132.4,110.04 129.09,110.04 126.94,107.88 126.94,100.6 125.64,99.3 125.64,95.86 124.63,94.85 122.99,94.85 122.08,93.94 110.87,93.94 110.51,94.3 107.62,94.3 107.28,94.53 106.87,94.7 106.68,94.78 106.42,94.89 106.38,94.91 105.84,95.17 105.44,95.17 105.29,95.32 104.28,95.32 104.05,95.54 84.2,95.54 81.71,98.03 63.98,98.03 63.13,97.17 60.82,97.17 59.65,98.34 56.98,98.34 55.57,96.93 55.57,96.38 46.19,87.01 46.05,86.87 39.63,86.87 38.18,88.31 35.01,88.31 32.24,85.55 32.24,77.45 v2(31.51,76.71)
  BOTTOM w0.102: v2(145.15,110.71) 144.66,110.71 144.26,110.3 144.26,109.85 144.5,109.61 JDOCK1.42
ACAV_IN: length 392.2
  TOP w0.102: PR918.1 29.27,75.37 29.27,76.43 v2(28.92,76.79) ; v3(55.54,86.7) 55.71,86.88 PR817.1 56.07,88.45 56.17,88.45 PR801.2 56.22,89.26 PQ809.1 ; UE2.A64 269.65,55.42 269.96,55.11 v2(269.97,55.11) ; PQ809.1 55.05,89.87 v2(55.04,89.89) ; PQ809.1 PR815.1 ; PQ907.5 70.56,14.39 70.65,14.48 v2(71.64,14.48)
  IN1 w0.089: v2(28.92,76.79) 30.92,74.78 45.88,74.78 47.49,73.17 50.98,73.17 52.96,71.19 56.06,71.19 57.54,72.67 57.58,72.67 57.62,72.72 61.17,72.72 62.39,71.5 63.35,71.5 64.3,72.46 64.67,72.46 65.05,72.08 65.05,69.63 69.23,65.46 69.23,61.12 68.94,60.84 68.27,60.16 68.27,51.54 69.07,50.73 69.07,47.3 69.07,46.95 69.19,46.84 69.19,45.1 73.37,40.92 73.37,19.33 71.64,17.61 v2(71.64,14.48)
  IN2 w0.122: v2(269.97,55.11) 269.97,54.09 271.08,52.99 271.08,52.47 271.36,52.19 271.36,48.73 268.78,46.16 268.78,44.09 268.78,44.08 268.78,43.73 267.92,42.87 267.92,40.64 267.45,40.17 267.45,35.5 267.07,35.13 267.07,31.32 265.79,30.04 265.79,24.36 264.88,23.44 263.97,23.44 263.09,22.57 260.44,22.57 259.77,23.23 257.48,23.23 256.83,22.58 254.29,22.58 253,21.29 253,20.02 251.67,18.7 244.82,18.7 243.04,16.92 233.36,16.92 231.37,18.91 230.83,18.91 228.66,21.08 228.66,21.97 228.27,22.37 214.54,22.37 213.2,23.7 203.83,23.7 203.83,23.71 203.22,23.71 203.22,23.71 202.39,23.71 199.95,26.15 192.09,26.15 190.02,28.22 113.21,28.22 108.1,23.1 86.86,23.1 85.66,21.91 79.62,21.91 77.57,19.86 75.3,19.86 74.67,19.23 73.62,19.23 73.48,19.09 72.14,17.74 71.64,17.25 v2(71.64,14.48)
  IN4 w0.089: v2(55.04,89.89) 53.8,88.65 51.83,88.65 45.41,82.23 45.41,82.13 44.84,81.56 40.46,81.56 33.61,74.71 30.26,74.71 28.92,76.05 v2(28.92,76.79)
ACAV_IN#: length 6.8
  TOP w0.102: PQ907.3 69.91,15.77 v2(69.29,15.15) 69.07,14.94 69.07,13.01 68.79,12.73 PR914.2 69.86,11.79 70.56,12.49 PU903.2
ACAV_IN_NB: length 309.4
  TOP w0.102: v2(25.16,88.57) 25.03,88.57 24.63,88.17 24.63,87.5 PR922.2 ; UE2.B20 268.9,65.03 268.87,65.01 268.87,64.9 v2(268.34,64.37) ; PR833.1 64.22,95.41 63.68,95.95 v3(62.88,95.95) 62.44,95.95 62.01,95.53 v2(61.58,95.53)
  IN3 w0.122: v2(268.34,64.37) 267.83,64.37 266.43,65.77 264.82,65.77 263.81,66.78 261.18,66.78 260.17,67.78 254.67,67.78 248.34,74.12 247.98,74.48 247.15,74.48 246.42,75.21 246.42,76.56 246.04,76.94 244.94,76.94 244.75,77.14 244.25,77.63 244.25,78.15 244.55,78.44 244.55,81.8 245.03,82.28 245.03,86.8 246.11,87.89 246.11,90.5 246.61,91 246.61,94.68 242.54,98.74 230.01,98.74 229.42,99.34 228.47,99.34 227.2,100.6 225.15,100.6 224.55,101.2 217.39,101.2 216.52,100.33 211.62,100.33 210.52,99.24 210.22,99.24 202.06,91.08 189.2,91.08 185.25,95.03 178.96,95.03 177.4,93.46 177.4,92.52 176.64,91.76 174.39,91.76 173.64,92.51 173.64,94.93 170.73,97.84 158.84,97.84 158.21,98.47 143.82,98.47 141.9,96.55 123.46,96.55 120.35,93.45 119.08,93.45 116.57,90.94 108.11,90.94 107.4,91.65 105.52,91.65 105.16,92.01 101.38,92.01 100.06,90.7 91.41,90.7 91.2,90.9 89.78,90.9 88.97,91.71 88.97,92.4 87.16,94.2 74.27,94.2 72.2,92.13 69.24,92.13 68.29,93.08 64.31,93.08 62.42,94.97 62.42,95.01 61.91,95.53 v2(61.58,95.53)
  IN4 w0.089: v2(61.58,95.53) 61.58,96.3 60.82,97.06 54.6,97.06 50.63,93.09 50.02,93.09 49.94,93.01 49.93,93.01 45.72,88.79 39.5,88.79 35.52,92.76 34.33,92.76 33.27,91.7 30.53,91.7 29.59,90.75 27.39,90.75 25.22,88.57 v2(25.16,88.57)
ACAVDK_SRC: length 2.8
  TOP w0.102: PR923.2 26.61,76.71 26.18,77.14 PU901.4
ACAVIN: length 2.9
  TOP w0.102: PU901.8 28.18,77.68 28.32,77.53 28.32,76.17 PR918.2
ADJ: length 2.6
  TOP w0.102: UV29.2 233.42,96.25 RV659.2 RV660.1
ALW_PWRGD_3V_5V: length 55.4
  TOP w0.102: PR101.2 230.31,61.01 230.31,59.5 230.65,59.16 v2(230.91,59.16) 231.21,59.45 233.12,59.45 235.97,56.6 235.97,52.96 231.97,48.96 231.97,45.27 233.08,44.16 233.08,42.84 233.62,42.31 233.62,39.75 234.86,38.5 234.86,36.57 v3(234.61,36.31) v2(233.92,35.63) ; UZ6.2 220.94,29.93 221.37,30.36 v2(221.37,31.03)
  IN2 w0.122: v2(233.92,35.63) 233.67,35.88 232.26,35.88 230.88,34.5 227.69,34.5 225.81,32.62 223.92,32.62 222.72,31.42 221.77,31.42 v2(221.37,31.03)
  BOTTOM w0.102: PR120.2 227.97,60.58 227.85,60.58 227.64,60.37 227.64,59.13 PR119.2 228.6,59.16 v2(230.91,59.16)
ALWON: length 48.3
  TOP w0.102: v2(232.37,58.97) 232.09,58.69 230.76,58.69 230.08,59.38 230.08,60.3 229.73,60.65 226.62,60.65 226.07,60.1 PR114.1
  TOP w0.279: v2(267.85,54.8) 267.84,54.8 267.84,54.8 267.86,54.82 267.86,55.29 267.65,55.51 UE2.A60
  IN1 w0.089: v2(267.85,54.8) 267.7,54.65 264.83,54.65 263.66,55.81 258.97,55.81 258.58,56.21 258.16,56.21 252.28,56.21 252.27,56.21 251.11,56.21 250.08,57.23 244.14,57.23 243.15,58.22 240.8,58.22 239.76,57.18 236.66,57.18 235.77,58.07 234.39,58.07 233.49,58.97 v2(232.37,58.97)
AR_SMBUS_ALERT#: length 3.9
  TOP w0.102: v2(257.05,85.7) 256.66,85.31 256.66,85.15 255.64,84.13 255.64,83.68 255.34,83.38 UE1.A58
  BOTTOM w0.102: RE309.2 257.65,85.7 v2(257.05,85.7)
AUD_HP_NB_SENSE: length 169
  TOP w0.254: UE1.A41 249.89,76.87 250.2,76.56 250.33,76.43 v2(250.48,76.43) ; v2(270.29,27.61) 270.29,27.45 269.71,26.87 RA2.1 CA41.1 271.12,26.57 271.31,26.38 QA1.2 ; v2(303.31,27.69) 299.88,24.26 DA2.3 293.55,24.26 293.29,24.52 293.29,25.73 292.5,26.52 v2(292.5,26.97)
  IN1 w0.254: v2(303.31,27.69) 303.31,29.57 301.74,31.14 301.74,31.93 302.1,32.29 302.1,34.89 302.17,34.96 302.17,38.65 301.18,39.65 301.18,40.66 300.08,41.76 294.47,47.37 290.92,47.37 290.25,48.05 280.48,48.05 277.88,50.65 v2(276.74,50.65)
  IN3 w0.254: v2(270.29,27.61) 270.75,28.08 270.75,32.5 270.23,33.03 270.23,40.54 271.56,41.87 273.37,41.87 277.14,45.64 277.14,45.86 277.7,46.42 277.7,50.42 277.47,50.65 v2(276.74,50.65) 276.74,50.84 277.49,51.59 277.49,57.42 277.76,57.69 277.76,59.83 277.29,60.3 277.29,62.24 277.18,62.35 276.53,63 275.04,63 274.26,63.78 272.58,63.78 v2(272.33,64.04)
  IN4 w0.254: JHP1.6 295.29,8.39 292.01,8.39 290.59,9.81 290.59,11.17 291.02,11.6 291.02,16.11 290.59,16.54 290.59,18.16 291.73,19.31 292.24,19.31 292.75,19.82 292.75,25.2 292.5,25.44 v2(292.5,26.97) ; v2(272.33,64.04) 271.84,64.04 271.59,64.29 271.59,65.44 269.65,67.38 269.65,69.14 268.1,70.69 266.08,70.69 265.11,69.73 262.67,69.73 262.09,69.14 262.09,67.92 261.5,67.33 260.82,67.33 259.41,68.74 259.41,72.64 259.17,72.88 252.79,72.88 251.65,74.02 251.65,74.81 251.14,75.31 251.14,76.1 250.81,76.43 v2(250.48,76.43)
AUD_HP_OUT_L: length 25.8
  TOP w0.381: RA7.2 286.14,34.81 286.74,35.41 286.74,36.63 v3(287.47,37.35) 288.18,38.07 288.75,38.07 LA2.1 288.56,38.99 v2(288,38.99) ; v2(280.5,27.13) CA43.2 280.5,26.37 281.01,25.86 RA24.1
  IN2 w0.381: v2(280.5,27.13) 280.5,27.69 281.19,28.38 282.87,28.38 284.39,29.9 284.39,30.6 285.15,31.36 285.15,33.81 285.89,34.55 286.98,34.55 287.32,34.89 287.32,37.15 288,37.82 v2(288,38.99)
AUD_HP_OUT_L1: length 29.5
  TOP w0.381: v3(290.19,39.46) 289.87,39.15 LA2.2 CA3.1 290.84,38.26 291.36,37.74 291.47,37.74 292.79,37.74 293.47,37.06 DA1.3 v2(293.76,38.03)
  IN2 w0.381: JHP1.1 292.47,18.85 291.71,19.61 291.71,24.58 290.03,26.26 290.03,29.24 291.99,31.2 291.99,32.58 292.99,33.58 292.99,36.4 293.76,37.16 v2(293.76,38.03)
AUD_HP_OUT_R: length 23.5
  TOP w0.381: RA25.1 282.03,25.76 281.77,26.01 CA44.2 v2(281.77,27.13) ; v2(289.52,37.65) 289.12,37.25 LA3.1 288.14,36.91 287.38,36.15 287.38,34.98 v3(286.62,34.22) 286.32,33.92 RA8.2
  IN2 w0.381: v2(289.52,37.65) 288.91,37.04 288.4,37.04 287.96,36.59 287.96,34.63 287.24,33.91 286.15,33.91 285.79,33.55 285.79,30.4 283.07,27.68 282.82,27.68 282.27,27.13 v2(281.77,27.13)
AUD_HP_OUT_R1: length 51.1
  TOP w0.381: LA3.2 CA2.1 290.84,37.32 v2(290.56,37.6) ; v3(291.94,39.49) 291.94,39.49 292.56,39.49 v2(292.66,39.39) 293.37,39.39 DA1.2 293.23,38.46 v2(292.61,38.46)
  IN1 w0.381: JHP1.2 297.99,8.34 292.01,8.34 290.64,9.71 290.64,11.38 291.02,11.76 291.02,16.06 290.51,16.56 290.51,18.37 291.49,19.35 292.39,19.35 292.65,19.6 292.65,23.58 289.39,26.83 289.39,36 290.28,36.88 291.15,36.88 292.06,37.8 292.06,37.92 v2(292.61,38.46) ; v2(292.66,39.39) 290.87,37.6 v2(290.56,37.6)
AUD_NB_MUTE#: length 97.5
  TOP w0.076: 272.52,37.16 272.5,37.15 v2(272.5,37.11) 272.5,36.6 RA18.2
  TOP w0.102: 272.52,37.16 273.41,38.05 CA31.1 v3(274.86,38.05) 275.72,37.19 276.67,37.19 276.91,36.96 UA1.48 ; v2(249.39,76.18) 248.89,76.67 UE1.A39 ; v2(289.32,42.63) 289.32,42.27 289.85,41.74 QA2.2
  IN1 w0.089: v2(289.32,42.63) 289.12,42.82 289.03,42.82 288.47,43.39 282,43.39 280.77,42.15 273.14,42.15 273.06,42.07 272.65,42.07 272.65,42.08 272.62,42.08 271.96,41.42 270.88,41.42 270.59,41.13 270.59,40.25 271.64,39.19 271.64,37.97 v2(272.5,37.11)
  IN3 w0.122: v2(249.39,76.18) 249.39,75.97 250.25,75.12 251.21,75.12 251.73,74.61 251.73,74.57 253.25,73.05 259.34,73.05 260.64,71.74 263.65,71.74 264.25,72.35 266.57,72.35 267.92,71 267.92,68.57 267.77,68.42 267.77,67.29 268.04,67.02 271.07,67.02 271.69,67.64 275.09,67.64 278.98,63.75 278.98,60.99 281.22,58.76 281.22,52.07 289.32,43.97 v2(289.32,42.63)
AUD_OUT_L: length 2.6
  TOP w0.203: UA1.33 282.6,34.48 282.61,34.5 282.66,34.5 283.05,34.89 283.32,34.89
  TOP w0.381: 283.32,34.89 284.49,34.89 RA7.1
AUD_OUT_R: length 2.7
  TOP w0.203: UA1.32 282.67,34.08 282.85,34.26 283.06,34.26 283.15,34.34
  TOP w0.381: RA8.1 284.23,33.92 283.81,34.34 v3(283.53,34.34) 283.15,34.34
AUD_PC_BEEP: length 5.9
  TOP w0.102: CA28.2 CA27.2 274.24,28.49 274.09,28.64 274.09,29.12 v3(274.16,29.19) 274.17,29.2 275.2,29.2 275.93,29.93 276.47,30.46 276.47,31.14 276.33,31.28 UA1.12
AUD_PWR_EN: length 145.9
  TOP w0.102: UZ5.3 274.79,44.24 274.37,43.82 v2(273.67,43.82) 273.44,43.82 273.24,43.62 273.24,43.01 273.49,42.75 274.99,42.75 275.59,43.35 UZ5.5 ; RC279.2 174.33,44.05 174.33,46.55 172.58,48.3 172.58,50.82 172.27,51.13 172.27,52.23 173.01,52.96 v2(173.26,52.96)
  IN1 w0.089: v2(264.71,35.83) 264.71,36.44 263.17,37.98 259.34,37.98 259.34,37.98 258.08,37.98 258.08,37.98 257.91,37.98 257.2,37.27 256.87,37.27 255.96,38.18 255.04,38.18 253.79,36.92 250.64,36.92 250.37,37.2 249.59,37.2 249.42,37.37 248.47,37.37 248.3,37.2 244.3,37.2 242.96,35.86 242.17,35.07 241.92,34.82 239.19,34.82 238.62,35.39 236.02,35.39 235.08,36.34 232.28,36.34 231.33,35.39 227.59,35.39 227.58,35.39 225.48,35.39 224.87,34.77 222.71,34.77 222.51,34.98 220.46,34.98 219.64,34.16 214.06,34.16 213.23,35 191.28,35 184.12,42.16 181.67,42.16 174.79,49.04 174.79,51.43 v2(173.26,52.96)
  BOTTOM w0.076: v2(173.26,52.96) 172.88,53.34 171.26,53.34 170.99,53.61 169.97,53.61 169.38,54.2 169.38,54.92 UC1.BA7
  BOTTOM w0.102: v2(273.67,43.82) 273.26,43.41 273.26,42.14 273.07,41.95 v3(271.39,41.95) 271.15,41.95 270.86,41.66 268.03,41.66 266.46,40.09 266.46,37.25 265.03,35.83 v2(264.71,35.83)
AUD_SENSE_A: length 6.9
  TOP w0.254: QA1.1 273.77,26.14 274.33,26.7 274.66,26.7 274.76,26.8 274.76,28.11 v3(275.87,29.21) 276.43,29.21 276.91,29.69 UA1.13
AUD_SENSE_B: length 7.3
  TOP w0.203: UA1.14 277.31,29.6
  TOP w0.254: 277.31,29.6 277.31,29.56 276.39,28.64 276.12,28.64 275.27,27.79 v3(275.27,27.05) 275.27,26.55 RA28.1 RA27.1 276.01,25.99 RA38.1
AUX_EN_WOWL: length 83.6
  TOP w0.102: UE1.B67 253.83,86.13 253.68,85.98 253.68,85.36 v2(253.23,84.92) ; RZ38.2 251.12,42.88 v2(251.05,42.81) 251.05,42.39 251.04,42.38 RZ70.1
  IN3 w0.122: v2(251.05,42.81) 251.05,42.47 250.85,42.27 249.95,42.27 248.87,43.35 248.87,43.91 248.03,44.75 248.03,48.69 248.03,49.11 248.03,49.82 248.28,50.07 248.28,54.48 246.87,55.88 246.87,57.33 246.63,57.58 246.63,61.87 244.87,63.63 244.87,64.49 243.6,65.76 240.98,65.76 238.78,67.96 238.61,67.96 235.3,71.28 235.06,71.28 234.48,71.86 234.48,72.67 232.75,74.4 232.75,80.29 232.57,80.47 232.57,82.86 233.11,83.39 233.11,84.13 232.64,84.6 v2(231.46,84.6)
  IN4 w0.089: v2(231.46,84.6) 232.34,85.49 239.22,85.49 240.01,86.27 242.23,86.27 242.49,86.54 243.26,86.54 243.28,86.57 243.28,86.58 244.7,88 244.7,88 244.93,88.24 244.94,88.24 245.05,88.35 245.74,88.35 246.37,87.72 250.75,87.72 251.2,87.27 251.2,86.24 252.53,84.92 v2(253.23,84.92)
BAT1_LED#: length 5.4
  TOP w0.254: UE2.B1 270.84,57.29 271.18,56.95 v3(272.38,56.95) 272.68,56.95 273.62,57.89 274.66,57.89 RZ28.1
BAT2_LED#: length 1.6
  TOP w0.254: RZ25.1 264.76,54.99 265.15,55.39 UE2.A55
BATDRV#: length 81.9
  TOP w0.102: v2(65.96,88.29) 65.96,88.28 66.11,88.13 v3(67.63,88.13)
  IN2 w0.254: v2(65.96,88.29) 64,90.25 62.8,90.25 62.37,90.68 60.16,90.68 59.42,89.95 57.39,89.95 57.09,89.64 57.09,85.7 57.67,85.12 57.67,83.03 57.67,82.63 57.67,82.63 57.67,81.7 57.67,75.14 58.44,74.37 61.15,74.37 61.74,73.78 62.64,73.78 63.67,72.75 65.09,72.75 65.59,72.25 65.59,70.98 70.52,66.05 70.52,53.16 70.71,52.96 70.71,52.22 71.7,51.24 72.37,51.24 72.66,50.95 72.66,50.74 72.83,50.56 72.83,46.89 72.46,46.51 72.46,41.75 74.75,39.45 v2(74.75,36.94)
  BOTTOM w0.254: v2(65.96,88.29) 66.11,88.45 66.94,88.45 PR825.2
  BOTTOM w0.508: PQ903.4 72.53,34.71 v2(74.75,36.94)
BATT_WHITE#: length 60.6
  TOP w0.254: v2(264.76,52.91) RZ25.2 ; v2(281.45,12.25) 280.65,11.45 JLED1.5
  IN3 w0.254: v2(281.45,12.25) 280.95,11.75 280.35,11.75 278.71,13.39 277.68,13.39 277.42,13.14 274.64,13.14 273.93,13.84 272.51,13.84 272.49,13.86 271.93,13.86 268.11,17.68 268.11,22.75 266.46,24.4 266.46,26.44 266.05,26.85 266.05,29.29 265.37,29.97 265.37,33.53 265.37,35.96 264.2,37.13 264.2,39.14 266.06,40.99 266.06,41.31 266.41,41.66 266.41,43.38 267.25,44.22 267.25,44.78 265.04,46.99 265.04,49.15 265.69,49.8 265.69,52.72 265.42,52.99 264.83,52.99 v2(264.76,52.91)
BATT_YELLOW#: length 68.6
  TOP w0.254: RZ28.2 273.47,58.42 v2(272.66,57.61) ; v3(283.07,13.85) 282.41,13.19 281.54,13.19 v2(280.66,12.31) 280.27,11.92 280.27,10.32 280.15,10.2 JLED1.4
  IN3 w0.254: v2(280.66,12.31) 278.87,14.1 274.57,14.1 274.17,14.49 272.19,14.49 268.74,17.94 268.74,23.01 267.09,24.66 267.09,26.18 267.09,26.7 266.69,27.11 266.69,30.31 267.19,30.82 267.19,33.3 266.69,33.81 266.69,39.64 266.69,41.05 267.04,41.4 267.04,43.12 267.88,43.96 267.88,46.5 266.84,47.54 266.84,48.17 267.49,48.82 268.82,48.82 268.89,48.9 270.19,48.9 271.21,49.92 271.21,53.83 272.66,55.27 v2(272.66,57.61)
BC_CLK_ECE1117: length 108.3
  TOP w0.102: JKBTP1.10 209.3,33.16 209.2,33.06 209.02,33.06 208.91,32.95 208.91,32.3 209.64,31.58 211.71,31.58 217.17,26.12 220.15,26.12 v3(220.41,26.38) 220.7,26.1 221.94,26.1 v2(222.46,26.62) ; UE2.A20 268.15,67.38 v2(268.24,67.47)
  IN2 w0.122: v2(268.24,67.47) 268.34,67.36 268.34,66.4 267.93,65.99 267.93,64.55 267.92,64.54 267.92,64 268.22,63.7 268.22,62.52 268.1,62.41 268.1,61.86 268.32,61.64 268.32,57.18 267.03,55.9 265.48,55.9 265.33,55.75 265.33,55.75 263.46,53.88 263.26,53.88 261.7,52.32 261.7,49.62 263.6,47.72 263.6,46.7 262.74,45.84 262.74,44.21 264.05,42.9 264.05,40.61 262.46,39.02 262.46,35.8 261.44,34.78 261.44,29.64 260.14,28.34 256.47,28.34 255.67,27.53 252.77,27.53 252.57,27.74 250.81,27.74 246.36,23.29 243.2,23.29 242.34,24.14 240.62,24.14 240.01,23.53 239.65,23.53 238.87,22.76 235.7,22.76 235.14,23.32 232.99,23.32 230.54,25.76 225.38,25.76 224.97,26.18 224.61,26.54 223.87,26.54 223.63,26.77 222.62,26.77 v2(222.46,26.62)
BC_CLK_ECE5048: length 42.9
  TOP w0.102: v2(259.29,60.28) 259.53,60.04 UE2.A43 ; UE1.A30 243.54,79.88 v2(243.34,79.68)
  IN4 w0.086: v2(259.29,60.28) 259.12,60.45 258.41,60.45 256.56,62.31 256.07,62.31 255.21,63.18 255.21,67.1 251.35,70.96 245.92,70.96 243.68,73.19 241.12,73.19 240.72,73.59 240.72,74.65 241.16,75.09 241.26,75.09 241.26,75.09 241.77,75.09 241.77,75.09 243.65,75.09 244.03,75.47 244.03,77.95 244.56,78.49 244.56,78.74 244.44,78.87 244.03,78.87 243.93,78.97 243.93,79.18 244.03,79.28 245.13,79.28 245.22,79.37 245.22,80.48 245.13,80.57 244.91,80.57 244.82,80.48 244.82,79.81 244.69,79.68 v2(243.34,79.68)
BC_DAT_ECE1117: length 122.6
  TOP w0.102: UE2.B21 268.4,64.98 v2(268.37,64.95) ; v2(276.8,59.01) 277.1,59.01 277.38,58.73 RPE5.2 ; JKBTP1.8 208.3,33.16 208.4,33.06 208.58,33.06 208.69,32.95 208.69,32.2 209.54,31.35 211.62,31.35 217.1,25.86 v3(222.32,25.86) 222.57,25.86 v2(222.9,26.19)
  IN2 w0.122: v2(222.9,26.19) 223.11,26.41 223.23,26.52 223.53,26.52 223.76,26.29 224.51,26.29 224.89,25.91 225.28,25.52 230.44,25.52 232.88,23.07 235.04,23.07 235.6,22.51 238.98,22.51 239.75,23.29 240.11,23.29 240.72,23.9 242.24,23.9 243.1,23.04 246.46,23.04 250.91,27.49 252.46,27.49 252.67,27.28 255.77,27.28 256.58,28.09 260.25,28.09 261.69,29.53 261.69,34.67 262.71,35.7 262.71,38.91 264.3,40.51 264.3,43 262.99,44.31 262.99,45.74 263.85,46.59 263.85,47.83 261.95,49.72 261.95,52.22 263.36,53.63 263.56,53.63 265.58,55.65 267.13,55.65 268.56,57.08 268.56,61.75 268.35,61.96 268.35,62.3 268.67,62.62 268.67,64.06 268.75,64.15 268.75,64.57 v2(268.37,64.95)
  BOTTOM w0.102: v2(276.8,59.01) 276.69,59.01 276.38,59.31 275.45,59.31 275.12,59.64 275.12,64.12 272.23,67.01 270.43,67.01 v2(268.37,64.95)
BC_DAT_ECE5048: length 43.6
  TOP w0.102: UE1.B31 245.28,80.13 v2(245.71,79.71) ; v2(258.86,60.85) 258.19,60.85 RE36.2 ; UE2.B45 262.08,60.29 262.72,60.94 v2(262.72,61.24)
  IN3 w0.122: v2(258.86,60.85) 258.86,60.94 259.25,61.32 260.16,61.32 261,60.48 262.19,60.48 262.72,61.01 v2(262.72,61.24)
  IN4 w0.086: v2(258.86,60.85) 258.32,60.85 256.64,62.53 256.16,62.53 255.43,63.25 255.43,67.18 251.44,71.17 246,71.17 243.77,73.41 241.21,73.41 240.94,73.68 240.94,74.56 241.25,74.87 241.35,74.87 241.35,74.88 241.68,74.88 241.68,74.87 243.74,74.87 244.24,75.38 244.24,77.86 245.71,79.33 v2(245.71,79.71)
BC_INT#_ECE1117: length 114.8
  TOP w0.102: v2(223.35,25.78) 222.92,25.35 v3(218.89,25.35) 216.99,25.35 211.4,30.94 208.88,30.94 207.8,32.02 JKBTP1.7 ; v2(269.07,68.13) 269.07,68.12 268.65,67.69 UE2.A19
  IN2 w0.122: v2(269.07,68.13) 269.24,67.96 269.27,67.96 269.52,67.72 269.52,66.45 270.58,65.38 270.58,57.1 270.33,56.85 269.94,56.85 269,55.91 269,53.83 268.24,53.06 266.94,53.06 266.68,53.33 264.58,53.33 264.17,52.92 264.17,51.87 263.8,51.49 263.8,48.69 264.47,48.01 264.47,47.23 264.47,47.13 265.76,45.84 265.76,43.6 266.17,43.2 266.17,41.64 265.33,40.8 265.33,40.11 264.8,39.58 264.8,37.03 265.27,36.57 265.27,35.8 264.73,35.26 264.73,35.01 263.81,34.09 262.57,34.09 262.19,33.71 262.19,29.06 261.35,28.23 261.35,27.27 259.44,25.35 254.98,25.35 251.94,22.32 240.49,22.32 240.02,21.85 235.09,21.85 234.83,22.1 232.97,22.1 230.06,25.01 224.13,25.01 v2(223.35,25.78)
BC_INT#_ECE5048: length 32
  TOP w0.102: UE2.A42 259.78,60.54 v2(259.48,60.84) ; UE1.A29 243.41,80.38 v2(242.71,79.68)
  IN1 w0.089: v2(242.71,79.68) 244.23,78.16 244.23,77.17 245.2,76.2 245.2,74.3 246.08,73.42 247.72,73.42 v2(247.89,73.59)
  IN4 w0.089: v2(259.48,60.84) 259,61.32 258.4,61.32 256.88,62.84 256.88,63.14 256.66,63.35 256.03,63.35 255.83,63.56 255.83,67.96 251.32,72.47 250.33,72.47 249.21,73.59 v2(247.89,73.59)
BCM5882_ALERT#: length 126
  TOP w0.102: UE1.B62 v2(253.22,83.63) ; v2(264.71,6) 266.08,7.37 266.08,7.9 266.46,8.29 JUSH1.14
  IN2 w0.122: v2(280.74,53.64) 280.74,53.53 280.1,52.9 279.09,52.9 277.33,51.13 277.33,47.2 274.38,44.25 274.38,39.95 274.45,39.88 274.45,37.47 274.38,37.4 274.38,37.14 271.73,34.48 271.73,32.58 271.36,32.21 270.55,32.21 269.76,31.43 269.76,26.31 271.11,24.97 271.11,17.48 270.69,17.06 270.69,15.73 271.06,15.36 271.06,6.89 269.33,5.16 265.54,5.16 v2(264.71,6)
  IN3 w0.122: v2(280.74,53.64) 280.74,58.89 278.73,60.89 278.73,63.64 274.98,67.39 271.79,67.39 271.17,66.78 267.93,66.78 267.42,67.29 267.42,69.38 267.67,69.63 267.67,70.89 266.47,72.1 264.36,72.1 263.73,71.47 258.66,71.47 257.33,72.8 253.15,72.8 251.37,74.57 251.37,74.61 251.11,74.87 250.08,74.87 248.97,75.97 248.97,77.16 248.63,77.51 248.63,81.03 249.17,81.58 249.17,82.92 249.88,83.63 v2(253.22,83.63)
BEEP: length 52.4
  TOP w0.102: v2(270.18,28.61) 270.48,28.61 270.84,28.25 270.84,27.84 RA13.2 ; v2(269.25,64.85) 269.4,65 UE2.B19
  IN3 w0.122: v2(269.25,64.85) 269.25,64.82 268.75,64.33 268.75,64.19 268.74,64.18 268.74,64.16 268.67,64.09 268.67,63.35 268.93,63.08 270.52,63.08 271.12,62.47 276.23,62.47 276.23,62.47 276.43,62.47 276.85,62.05 276.85,60.11 277.21,59.75 277.21,57.77 277.05,57.61 277.05,52.42 276.19,51.56 276.19,51.22 275.66,50.7 275.23,50.7 270.45,45.91 270.45,43.02 269.45,42.03 269.45,41 269.77,40.68 269.77,29.5 270.18,29.08 v2(270.18,28.61)
  BOTTOM w0.102: v3(271.06,27.78) 270.23,28.61 v2(270.18,28.61)
BIA_PWM: length 5.3
  TOP w0.102: v2(87.73,84.51) 87.4,84.51 86.9,85.01 86.9,85.43 RV1.1 86.89,86.37 86.89,87.25 87.31,87.66 LV1.2
  BOTTOM w0.102: DV1.1 87.58,84.37 v2(87.73,84.51)
