# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_LED#: length 6
  BOTTOM w0.094: QZ3.6 285.23,73.09 QZ4.2 284.92,73.12 284.19,72.39 283.76,72.39 283.3,71.94 283.3,71.56 283.02,71.28 281.99,71.28 v3(281.6,71.67)
SATA_PRX_C_DTX_N0: length 12.4
  TOP w0.094: CN18.1 267.19,23.64 267.41,23.64 268.27,22.78 268.27,21.6 v4(268.45,21.43) 268.76,21.11 269.86,21.11 v2(269.99,21.24)
  BOTTOM w0.094: JSATA1.5 272.5,18.27 272.65,18.42 272.65,19.28 272.07,19.87 269.66,19.87 269.29,20.24 269.29,21.02 269.47,21.2 269.95,21.2 v2(269.99,21.24)
SATA_PRX_C_DTX_N1: length 5.7
  TOP w0.094: C313.2 149.22,104.16 149.22,104.51 149.53,104.82 149.53,105.2 v2(149.72,105.39)
  BOTTOM w0.094: JDOCK1.56 149,107.7 148.85,107.55 148.85,106.9 149.52,106.23 149.52,105.59 v2(149.72,105.39)
SATA_PRX_C_DTX_P0: length 12.4
  TOP w0.094: v2(269.99,20.63) 269.7,20.92 268.64,20.92 268.08,21.48 268.08,22.7 267.33,23.45 267.01,23.45 CN17.1
  BOTTOM w0.094: v2(269.99,20.63) 269.99,20.77 269.92,20.84 269.82,20.84 269.65,21.01 269.55,21.01 269.48,20.94 269.48,20.32 269.74,20.06 272.15,20.06 272.85,19.36 272.85,18.42 273,18.27 JSATA1.6
SATA_PRX_C_DTX_P1: length 5.7
  TOP w0.094: v2(149.14,105.39) 149.34,105.19 149.34,104.9 149.03,104.59 149.03,104.16 C312.2
  BOTTOM w0.094: v2(149.14,105.39) 149.32,105.58 149.32,106.15 148.65,106.82 148.65,107.55 148.5,107.7 JDOCK1.54
SATA_PRX_C_RD_DTX_N0: length 3.6
  TOP w0.094: UN7.4 259.76,23.94 259.69,23.87 259.27,23.87 259.01,23.6 v4(259.01,23.04) 259.01,22.6 258.86,22.46 258.71,22.46 258.59,22.57 258.23,22.57 258.13,22.67 CN45.2
SATA_PRX_C_RD_DTX_P0: length 3.6
  TOP w0.094: CN48.2 258.13,22.24 258.27,22.38 258.51,22.38 258.63,22.27 258.94,22.27 259.2,22.52 259.2,22.71 259.23,22.75 259.23,23.34 259.2,23.37 259.2,23.52 259.35,23.68 259.51,23.68 259.74,23.44 UN7.5
SATA_PRX_DTX_N0: length 162.2
  TOP w0.094: CN45.1 256.87,22.57 256.49,22.57 255.19,21.28 255.19,19.44 v2(254.95,19.21)
  IN4 w0.076: 162.63,75.06 162.63,75.04 162.57,74.99 162.57,74.49 162.41,74.33 162.27,74.33 162.01,74.07 v2(161.99,74.07)
  IN4 w0.112: v2(254.95,19.21) 255.13,19.38 255.13,19.57 254.93,19.77 253.78,19.77 253.35,20.19 253.35,20.57 252.05,21.88 247.68,21.88 244.17,25.39 243,25.39 241.94,26.46 241.94,27.51 242.12,27.69 242.12,30.43 239.07,33.49 239.07,34.83 231.84,42.06 231.84,42.82 232.12,43.11 232.12,43.96 231.76,44.33 231.62,44.47 231.62,49.94 232.38,50.71 234.53,52.86 234.53,56.37 234.29,56.61 234.29,61.48 233.34,62.43 233.34,68.76 233.04,69.07 233.04,72.59 228.55,77.08 209.44,77.08 208.68,76.32 205.51,76.32 195.18,76.32 193.54,77.96 189.5,77.96 188.21,79.25 188.21,79.61 185.09,82.73 184.64,82.73 182.26,82.73 179.03,79.5 176.52,79.5 175.52,80.5 173.62,80.5 173.22,80.9 171.08,80.9 169.61,82.37 166.29,82.37 165.21,83.44 164.65,83.44 163.92,82.71 163.92,81.46 163.36,80.9 162.91,80.9 162.59,80.58 162.59,80.36 162.52,80.29 162.52,75.66 162.63,75.56 162.63,75.06
  BOTTOM w0.076: UC1.F20 162.46,73.97 162.37,74.07 v2(161.99,74.07)
SATA_PRX_DTX_N1: length 37.8
  TOP w0.094: C313.1 149.26,102.59 149.26,102.11 149.37,102 v2(149.65,102)
  IN2 w0.122: v2(149.65,102) 149.43,101.78 149.43,100.7 149.8,100.33 149.8,98.47 150.45,97.82 150.45,93.63 152.34,91.75 154.46,91.75 157.36,88.85 157.36,87.51 158,86.87 158.33,86.87 160.16,85.04 160.16,77.5 160.61,77.04 161.07,77.04 161.86,76.25 161.86,75.32 161.53,74.99 161.53,73.94 v2(161.07,73.47)
  BOTTOM w0.076: UC1.G21 161.22,73.47 v2(161.07,73.47)
SATA_PRX_DTX_P0: length 162.3
  TOP w0.094: v2(255.54,19.21) 255.38,19.36 255.38,21.2 256.57,22.38 256.87,22.38 CN48.1
  IN4 w0.076: 162.38,75.06 162.38,75.05 162.41,75.02 162.41,74.56 162.34,74.5 162.27,74.5 v2(162.01,74.76)
  IN4 w0.112: v2(255.54,19.21) 255.38,19.37 255.38,19.67 255.03,20.02 253.88,20.02 253.6,20.3 253.6,20.67 252.15,22.12 247.79,22.12 244.27,25.64 243.11,25.64 242.18,26.56 242.18,27.41 242.37,27.59 242.37,30.54 239.32,33.59 239.32,34.93 232.08,42.16 232.08,42.72 232.37,43.01 232.37,44.07 231.86,44.57 231.86,49.84 232.49,50.47 234.78,52.76 234.78,56.47 234.54,56.71 234.54,61.58 233.59,62.53 233.59,68.86 233.29,69.17 233.29,72.69 228.65,77.33 209.34,77.33 208.57,76.56 205.61,76.56 195.29,76.56 193.64,78.21 189.6,78.21 188.46,79.35 188.46,79.71 185.19,82.98 184.74,82.98 182.16,82.98 178.92,79.75 176.62,79.75 175.62,80.75 173.72,80.75 173.32,81.15 171.18,81.15 169.72,82.62 166.39,82.62 165.32,83.69 164.55,83.69 163.67,82.81 163.67,81.56 163.26,81.15 162.81,81.15 162.34,80.68 162.34,80.46 162.27,80.4 162.27,75.56 162.38,75.46 162.38,75.06
  BOTTOM w0.076: v2(162.01,74.76) 162.15,74.76 UC1.E20
SATA_PRX_DTX_P1: length 37.8
  TOP w0.094: C312.1 149.06,102.51 149.06,102 149,101.94 v2(148.74,101.94)
  IN2 w0.122: v2(148.74,101.94) 148.74,102.02 148.86,102.14 149.12,102.14 149.2,102.06 149.2,100.6 149.56,100.24 149.56,98.38 150.22,97.72 150.22,93.54 152.24,91.52 154.37,91.52 157.13,88.75 157.13,87.41 157.9,86.64 158.23,86.64 159.93,84.95 159.93,77.4 160.51,76.81 160.97,76.81 161.63,76.15 161.63,75.42 161.3,75.09 161.3,74.17 161.25,74.12 v2(161.07,74.12)
  BOTTOM w0.076: v2(161.07,74.12) 161.22,74.12 UC1.F21
SATA_PRX_RD_DTX_N0: length 1.9
  TOP w0.094: UN7.12 264.56,23.94 264.71,23.79 265.04,23.79 265.12,23.72 265.35,23.72 CN18.2
SATA_PRX_RD_DTX_P0: length 1.9
  TOP w0.094: UN7.11 264.57,23.44 264.73,23.6 264.96,23.6 265.04,23.52 265.38,23.52 CN17.2
SATA_PTX_C_DRX_N0: length 12.8
  TOP w0.094: v2(269.96,21.95) 269.96,21.99 269.61,22.34 269.38,22.34 v4(268.16,23.56) 267.29,24.43 267.29,25.28 267.19,25.38 267.04,25.38 CN44.1
  BOTTOM w0.094: JSATA1.3 271.5,18.27 271.35,18.42 271.35,18.88 270.83,19.4 269.54,19.4 268.85,20.09 268.85,21.65 269.45,22.26 269.67,22.26 269.96,21.97 v2(269.96,21.95)
SATA_PTX_C_DRX_N1: length 5.6
  TOP w0.094: C315.1 150.99,104.17 150.99,104.27 v2(151.17,104.45)
  BOTTOM w0.094: v2(151.17,104.45) 150.99,104.63 150.99,105.74 150.35,106.39 150.35,107.55 150.5,107.7 JDOCK1.62
SATA_PTX_C_DRX_P0: length 12.9
  TOP w0.094: v2(269.99,22.53) 269.46,22.53 268.53,23.47 268.53,23.51 268.11,23.93 268.06,23.93 267.48,24.51 267.48,25.36 267.27,25.57 267.04,25.57 CN43.1
  BOTTOM w0.094: JSATA1.2 271,18.27 271.15,18.42 271.15,18.8 270.75,19.2 269.46,19.2 268.65,20.01 268.65,21.73 269.37,22.46 269.91,22.46 v2(269.99,22.53)
SATA_PTX_C_DRX_P1: length 5.6
  TOP w0.094: C314.1 150.8,104.15 150.8,104.24 v2(150.58,104.45)
  BOTTOM w0.094: JDOCK1.60 150,107.7 150.15,107.55 150.15,106.31 150.8,105.66 150.8,104.66 v2(150.58,104.45)
SATA_PTX_C_RD_DRX_N0: length 2.9
  TOP w0.094: CN50.2 258.51,24.18 258.76,24.18 259.09,24.51 259.09,24.96 259.23,25.1 259.49,25.1 259.64,24.94 UN7.2
SATA_PTX_C_RD_DRX_P0: length 2.9
  TOP w0.094: UN7.1 259.64,25.44 259.49,25.29 259.15,25.29 258.9,25.04 258.9,24.59 258.68,24.38 258.45,24.38 CN47.2
SATA_PTX_DRX_N0: length 160.5
  TOP w0.094: v2(254.75,21.09) 254.53,21.3 254.53,21.58 v4(254.77,21.82) 255.54,22.59 255.59,22.59 256.01,23.01 256.01,23.06 256.45,23.5 256.45,23.9 256.7,24.16 256.87,24.16 CN50.1
  IN4 w0.112: v2(161.14,81) 161.39,80.75 161.51,80.75 161.61,80.85 161.61,82.35 163.62,84.36 165.76,84.36 166.6,83.53 169.8,83.53 170.87,82.46 176.01,82.46 177.44,81.03 179.27,81.03 181.88,83.64 185.46,83.64 189.12,79.99 189.12,79.63 189.86,78.89 193.9,78.89 195.56,77.22 205.79,77.22 208.22,77.22 208.99,77.99 228.96,77.99 234,72.95 234,70.25 234.25,69.99 234.25,63.06 235.77,61.54 235.77,57.33 236.3,56.8 236.3,55.91 235.46,55.07 235.46,52.5 232.76,49.8 232.52,49.57 232.52,45.05 233.2,44.37 233.2,41.98 236.63,38.55 237.37,38.55 239.99,35.93 239.99,33.85 243.03,30.82 243.03,27.81 248.06,22.79 252.43,22.79 252.69,22.53 254.19,22.53 254.77,21.95 254.77,21.1 v2(254.75,21.09)
  BOTTOM w0.076: v2(161.14,81) 161.38,80.76 161.57,80.76 161.9,80.43 161.9,78.8 161.9,78.8 161.9,78.39 161.9,77.8 161.73,77.63 161.73,76.83 161.55,76.66 161.42,76.66 UC1.B21
SATA_PTX_DRX_N1: length 35.2
  TOP w0.094: C315.2 151.1,102.65 151.1,102.23 v2(151.36,101.98)
  IN2 w0.122: v2(161,78.48) 161.62,78.48 162.07,78.92 162.07,84.58 158.82,87.83 158.82,88.95 154.14,93.63 151.5,93.63 151.46,93.67 151.45,93.67 151.2,93.92 151.2,101.82 v2(151.36,101.98)
  BOTTOM w0.076: UC1.D21 160.98,75.74 160.98,75.74 160.98,75.92 160.92,76.12 160.9,76.2 160.85,76.35 160.84,76.4 160.84,76.64 160.86,76.7 160.86,76.96 160.84,77.02 160.84,77.44 161.23,77.83 161.23,78.26 v2(161,78.48)
SATA_PTX_DRX_P0: length 160.5
  TOP w0.094: CN47.1 256.87,24.35 256.62,24.35 256.26,23.98 256.26,23.58 255.87,23.19 v4(255.64,22.96) 255.46,22.79 254.86,22.19 254.82,22.19 254.4,21.77 254.4,21.72 254.34,21.66 254.34,21.26 v2(254.16,21.09)
  IN4 w0.112: v2(161.15,80.29) 161.36,80.5 161.61,80.5 161.86,80.75 161.86,82.25 163.72,84.11 165.66,84.11 166.49,83.28 169.7,83.28 170.77,82.21 175.91,82.21 177.34,80.79 179.37,80.79 181.98,83.4 185.36,83.4 188.87,79.88 188.87,79.53 189.76,78.64 193.8,78.64 195.46,76.98 205.68,76.98 208.32,76.98 209.09,77.74 228.86,77.74 233.75,72.85 233.75,70.14 234.01,69.89 234.01,62.96 235.53,61.44 235.53,57.22 236.05,56.7 236.05,56.01 235.21,55.17 235.21,52.61 232.66,50.05 232.28,49.67 232.28,44.95 232.42,44.8 232.96,44.27 232.96,41.88 236.53,38.31 237.27,38.31 239.75,35.83 239.75,33.75 242.79,30.71 242.79,27.71 247.96,22.54 252.32,22.54 252.58,22.28 254.09,22.28 254.52,21.85 254.52,21.44 v2(254.16,21.09)
  BOTTOM w0.076: UC1.A21 161.2,77.09 161.2,76.89 161.27,76.82 161.48,76.82 161.56,76.9 161.56,77.69 161.73,77.87 161.73,78.45 161.73,80.36 161.5,80.6 161.31,80.6 161.23,80.6 161.15,80.52 v2(161.15,80.29)
SATA_PTX_DRX_P1: length 35.1
  TOP w0.094: C314.2 150.9,102.45 150.9,102.09 v2(150.77,101.96)
  IN2 w0.122: v2(161.05,79.07) 161.2,79.07 161.28,79 161.28,78.8 161.36,78.71 161.53,78.71 161.84,79.02 161.84,84.48 158.58,87.74 158.58,88.85 154.04,93.4 151.4,93.4 151.36,93.44 151.36,93.44 150.97,93.83 150.97,101.75 150.77,101.94 v2(150.77,101.96)
  BOTTOM w0.076: UC1.C21 161.27,76.04 161.06,76.25 161,76.42 161,76.61 161.03,76.67 161.03,76.99 161,77.05 161,77.37 161.39,77.76 161.39,78.78 161.1,79.07 v2(161.05,79.07)
SATA_PTX_RD_DRX_N0: length 2
  TOP w0.094: CN44.2 265.44,25.36 265.22,25.36 264.96,25.1 264.67,25.1 264.51,24.94 UN7.14
SATA_PTX_RD_DRX_P0: length 2
  TOP w0.094: UN7.15 264.59,25.44 264.74,25.29 264.88,25.29 265.14,25.56 265.41,25.56 CN43.2
SATAGP1: length 11.8
  BOTTOM w0.076: UC1.H3 172,72.72 172.47,72.72 172.6,72.76 172.79,72.76 172.81,72.75 172.94,72.72 173.14,72.72 173.39,72.82 173.45,72.85 173.64,72.85 174.68,73.89 174.68,74.55 175.1,74.97 175.19,74.97
  BOTTOM w0.102: RC246.1 180.56,72.83 180.56,73.2 178.79,74.97 v3(178.35,74.97) 178.11,75.21 175.46,75.21 175.21,74.97 175.19,74.97
SD/MMCCD#: length 28.7
  TOP w0.102: UR2.30 265.38,42.24 v2(265.48,42.34)
  IN1 w0.089: v2(265.48,42.34) 267.24,42.34 269.15,44.25 270.27,44.25 271.28,43.23 272.09,43.23 272.43,42.89 272.43,42.44 271.89,41.9 269.95,41.9 269.56,41.51 269.56,40.72 271.14,39.14 271.14,35.7 271.87,34.97 271.87,34.38 272.98,33.28 275.1,33.28 v2(275.12,33.25)
  BOTTOM w0.102: v3(272.3,32.27) 272.58,32.55 JSD1.18 275.23,32.55 275.38,32.71 275.38,33 v2(275.12,33.25)
SD/MMCCLK: length 2.7
  TOP w0.102: RR1.1 259.8,38.59 260.31,39.09 261.05,39.09 261.12,39.16 UR2.17
SD/MMCCLK_R: length 30.1
  TOP w0.102: RR1.2 259.5,36.66 259.5,36.53 CR23.1 259.88,35.94 260.21,36.28 v2(260.22,36.28)
  IN1 w0.089: v2(260.22,36.28) 260.22,36.25 260.67,35.8 261.38,35.8 261.73,35.45 261.73,34.16 262.98,32.91 262.98,30.6 263.45,30.13 266.91,30.13 267.25,30.47 267.25,33 267.37,33.13 267.59,33.13 267.68,33.04 267.68,32.25 267.77,32.16 267.95,32.16 268.03,32.25 268.03,33.04 268.12,33.13 268.3,33.13 268.39,33.04 268.39,32.25 268.48,32.16 268.66,32.16 268.75,32.25 268.75,33.04 268.83,33.13 269.01,33.13 269.1,33.04 269.1,32.3 269.2,32.2 269.36,32.2 269.46,32.3 269.46,33.04 269.55,33.13 270.62,33.13 v2(270.72,33.23)
  BOTTOM w0.102: v2(270.72,33.23) 271.68,34.18 v3(272.25,34.18) 273.36,34.18 273.58,33.95 JSD1.5
SD/MMCCMD: length 1.9
  TOP w0.102: RR23.1 261.92,38.21 UR2.19
SD/MMCCMD_R: length 30.2
  TOP w0.102: RR23.2 261.46,36.84 v2(261.46,36.28)
  IN1 w0.089: v2(261.46,36.28) 262.13,35.61 262.13,34.36 262.9,33.58 265.36,33.58 265.8,34.01 266.28,34.01 266.35,33.95 266.5,33.95 266.76,33.68 269.28,33.68 269.63,34.04 269.63,38.92 269.51,39.04 269.33,39.04 269.2,38.92 269.2,34.75 269.02,34.57 v2(268.59,34.57)
  BOTTOM w0.102: v2(268.59,34.57) 268.64,34.57 269.53,35.46 269.53,36.79 v3(270.98,38.24) 272.4,39.65 JSD1.2
SD/MMCDAT0/RCLK+: length 3.3
  TOP w0.094: RR22.1 259.35,38.28 259.35,38.69 259.98,39.32 259.98,40.16 260.06,40.24 UR2.16
SD/MMCDAT0/RCLK+_R: length 30.8
  TOP w0.094: RR22.2 257.16,37.8 v2(257.03,37.67)
  IN1 w0.081: v2(271.96,29.43) 271.96,29.24 272.01,29.18 272.28,29.18 272.36,29.27 272.36,32.98 271.23,34.12 271.23,34.7 270.5,35.44 270.5,38.87 268.86,40.51 268.48,40.51 266.16,38.19 259.43,38.19 257.82,38.19 257.81,38.19 257.46,37.84 257.2,37.84 v2(257.03,37.67)
  BOTTOM w0.094: JSD1.7 273.83,29.76 273.43,29.36 273.43,28.98 273.2,28.74 272.65,28.74 v2(271.96,29.43)
SD/MMCDAT1/RCLK-: length 3.3
  TOP w0.094: RR21.1 258.74,38.82 258.74,38.99 258.91,39.17 259.29,39.17 259.6,39.48 259.6,40.32 259.92,40.64 UR2.15
SD/MMCDAT1/RCLK-_R: length 30.8
  TOP w0.094: RR21.2 257.49,38.69 v2(257.06,38.26)
  IN1 w0.081: v2(257.06,38.26) 257.22,38.09 257.36,38.09 257.7,38.44 257.71,38.44 259.33,38.44 266.06,38.44 268.38,40.76 268.96,40.76 270.75,38.98 270.75,35.54 271.48,34.8 271.48,34.22 272.62,33.09 272.62,29.17 272.23,28.78 v2(271.94,28.78)
  BOTTOM w0.094: v2(271.94,28.78) 272.37,28.36 JSD1.8
SD/MMCDAT2: length 2
  TOP w0.102: UR2.21 262.72,38.97 263.36,38.33 RR18.1
SD/MMCDAT2_R: length 30.4
  TOP w0.102: v2(263.14,35.67) 262.82,35.99 262.82,36.42 RR18.2
  IN1 w0.089: v2(268.69,35.82) 268.67,35.82 268.24,36.25 268.24,39.09 268.11,39.22 267.91,39.22 267.78,39.09 267.78,37.19 267.65,37.06 267.47,37.06 267.35,37.19 267.35,38.31 267.22,38.43 267.04,38.43 266.91,38.31 266.91,37.09 266.79,36.96 265.37,36.96 265.24,36.83 265.24,35.39 264.22,34.37 263.86,34.37 263.14,35.1 v2(263.14,35.67)
  BOTTOM w0.102: JSD1.9 273.71,41.69 273.38,41.69 273.1,41.41 271.18,41.41 270.29,40.51 v3(270.05,40.51) 268.52,40.51 267.54,39.54 267.54,36.22 267.95,35.82 v2(268.69,35.82)
SD/MMCDAT3: length 1.8
  TOP w0.102: RR17.1 262.47,38.65 262.31,38.81 262.32,38.81 UR2.20
SD/MMCDAT3_R: length 30.6
  TOP w0.102: v2(262.05,36.3) 262.05,36.54 RR17.2
  IN1 w0.089: v2(262.05,36.3) 262.52,35.83 262.52,34.52 263.07,33.98 265.2,33.98 265.49,34.27 265.49,35.08 265.63,35.22 265.63,35.54 265.76,35.67 266.46,35.67 266.58,35.79 266.58,36 266.46,36.12 265.75,36.12 265.63,36.24 265.63,36.45 265.75,36.57 266.9,36.57 266.99,36.48 266.99,35.28 266.86,35.16 266.51,35.16 266.38,35.03 266.38,34.47 266.51,34.34 267.27,34.34 267.4,34.47 267.4,36.53 267.52,36.66 267.65,36.66 267.78,36.53 267.78,34.44 267.9,34.32 268.07,34.32 268.19,34.44 268.19,35.09 268.29,35.18 v2(268.62,35.18)
  BOTTOM w0.102: JSD1.1 273.82,41.06 273.12,40.35 272.1,40.35 v3(271.99,40.24) 269.12,37.38 269.12,35.64 268.67,35.18 v2(268.62,35.18)
SD_GPIO: length 2
  TOP w0.102: UR2.28 265.14,41.44 265.24,41.34 266.12,41.34 RR16.2
SD_RCOMP: length 16
  TOP w0.381: v2(180.81,69.21) 182.03,69.21 182.42,68.83 RC96.1
  IN3 w0.381: v2(180.81,69.21) 180.27,69.75 176.11,69.75 175.86,69.5 173.29,69.5 171.8,68.01 170.59,68.01 170.55,67.98 170.55,67.97 170.5,67.92 170.27,67.69 170.03,67.45 169.53,66.96 v2(169.53,66.61)
  BOTTOM w0.254: UC1.AB7 169.53,66.42 v2(169.53,66.61)
SD_UHS2_D0N: length 45.8
  TOP w0.094: UR2.25 265.35,40.24 266.72,38.87 268.23,38.87 v2(268.7,38.41)
  IN4 w0.081: v2(300.45,51.38) 300.25,51.18 300.25,48.02 297.6,45.37 278.94,45.37 275.23,41.66 271.97,41.66 271.55,41.24 271.16,41.24 270.05,40.13 270.05,39.39 269.63,38.98 269.27,38.98 v2(268.7,38.41)
  BOTTOM w0.094: v2(300.45,51.38) 299.65,50.58 JSD1.12
SD_UHS2_D0P: length 45.8
  TOP w0.094: v2(268.68,39.76) 268.17,39.25 266.88,39.25 265.51,40.62 265.51,40.63 265.5,40.64 UR2.26
  IN4 w0.081: v2(268.68,39.76) 269.22,39.23 269.53,39.23 269.8,39.49 269.8,40.24 271.05,41.49 271.45,41.49 271.87,41.91 275.12,41.91 278.83,45.62 297.49,45.62 300,48.12 300,51.22 299.88,51.34 v2(299.35,51.34)
  BOTTOM w0.094: v2(299.35,51.34) 298.55,50.54 JSD1.11
SD_UHS2_D1N: length 72.5
  TOP w0.094: v2(268.72,37.67) 268.72,37.48 268.63,37.39 267.5,37.39 266.72,36.61 264.54,36.61 264.23,36.92 264.23,38.44 263.52,39.14 UR2.23
  IN4 w0.081: v2(303.46,20.46) 303.46,20.19 303.14,19.87 302.69,19.87 301.63,20.93 301.63,23.42 301.57,23.49 299.98,25.08 299.98,35.47 298.44,37.01 298.44,42.47 296.99,43.92 278.46,43.92 275.59,41.05 274.69,41.05 273.34,39.7 272.21,39.7 271.81,39.31 271.07,39.31 269.15,37.4 268.84,37.4 268.72,37.52 v2(268.72,37.67)
  BOTTOM w0.094: JSD1.15 299.26,20.62 299.26,20.24 299.5,20 303.31,20 303.46,20.16 v2(303.46,20.46)
SD_UHS2_D1P: length 72.6
  TOP w0.094: UR2.22 263.12,39.01 263.85,38.28 263.85,36.77 264.38,36.23 266.87,36.23 267.66,37.01 v2(268.72,37.01)
  IN4 w0.081: v2(268.72,37.01) 268.85,37.14 269.26,37.14 271.17,39.06 271.92,39.06 272.31,39.45 273.45,39.45 274.8,40.8 275.69,40.8 278.56,43.67 296.88,43.67 298.18,42.37 298.18,36.91 299.72,35.37 299.72,24.98 301.38,23.32 301.38,20.82 301.86,20.34 302.58,19.62 v2(303.45,19.62)
  BOTTOM w0.094: v2(303.45,19.62) 299.34,19.62 298.88,20.08 298.88,20.68 JSD1.16
SDWP: length 6
  TOP w0.102: QR1.1 266.06,45.83 265.27,45.05 v2(265.27,44.62) ; UR2.29 265.18,41.84 265.37,41.65 265.59,41.65 v2(265.75,41.81)
  IN3 w0.122: v2(265.27,44.62) 265.52,44.38 265.52,43.44 265.92,43.04 265.92,41.98 v2(265.75,41.81)
SDWP_Q: length 42
  TOP w0.102: v2(269.25,48.04) 269.25,47.74 QR1.3
  IN3 w0.122: v2(269.25,48.04) 268.85,47.63 268.85,43.58 267.99,42.73 267.99,41.01 267.64,40.65 267.64,34.2 267.78,34.06 268.16,33.68 268.16,29.15 268.61,28.7 268.61,25.06 269.53,24.13 v2(269.81,24.13)
  BOTTOM w0.102: v2(269.81,24.13) 269.56,24.13 267.32,26.37 267.32,28.95 267.69,29.32 270.23,29.32 272.59,26.95 JSD1.19
SIM_DET: length 12.9
  TOP w0.102: v2(245.89,61.99) 245.8,61.9 244.31,61.9 243.96,62.26 243.96,65.45 v1(243.61,65.79) 243.61,66.31 243.32,66.6 243.32,67.82 RI31.2
  BOTTOM w0.102: v2(245.89,61.99) 243.07,61.99 242.38,61.3 JNGFF2.58
SIM_DET_R: length 63
  TOP w0.102: RI31.1 243.46,69.18 v2(243.91,69.62) v1(244.48,70.2)
  IN3 w0.122: v2(287.37,84.99) 287.37,83.46 285.44,81.53 285.44,79.88 283.59,78.02 283.59,74.32 282.22,72.96 278.72,72.96 276.78,71.02 272.09,71.02 271.4,71.71 v2(271.08,71.71)
  BOTTOM w0.102: v2(271.08,71.71) 271.08,72.06 270.73,72.42 264.95,72.42 263.07,74.3 256.64,74.3 254.51,72.17 249.1,72.17 247.09,70.16 244.44,70.16 v2(243.91,69.62) ; JSIM1.9 287.7,88.39 287.7,85.32 v2(287.37,84.99)
SIO_EXT_SCI#: length 113.7
  TOP w0.102: v2(259.76,65.26) 259.76,65.15 259.87,65.04 UE2.A33 ; v2(169.33,59.19) 169.33,59.86 170.03,60.56 170.85,60.56 172.62,58.78 178.86,58.78 179.13,58.51 185.68,58.51 185.7,58.49 v2(186.03,58.49) 186.03,58.76 RC237.1
  IN1 w0.089: v2(186.03,58.49) 186.1,58.42 190.07,58.42 190.85,59.2 200.53,59.2 200.78,58.95 203.1,58.95 208.49,53.56 208.49,52.6 210.46,50.63 214.28,50.63 215.88,49.03 220.85,49.03 221.02,49.2 221.03,49.2 221.12,49.3 225.05,49.3 225.49,49.74 227.37,49.74 229.32,51.69 232.29,51.69 235.21,54.61 235.99,55.39 239.77,55.39 240.62,56.24 241.47,57.09 242.62,57.09 243.58,56.12 243.93,56.12 244.28,55.77 251.22,55.77 256.92,55.77 258,55.77 258.27,55.5 v2(258.41,55.5)
  BOTTOM w0.076: v2(169.33,59.19) 169.33,59.8 UC1.AN7
  BOTTOM w0.102: v2(258.41,55.5) 257.8,56.11 257.8,63.29 v2(259.76,65.26)
SIO_EXT_SMI#: length 130.6
  TOP w0.102: RC236.2 179.53,85.47 178.77,85.47 v2(178.32,85.03) ; UE2.A6 271.99,60.04 v2(272.08,60.13)
  IN1 w0.089: v2(244.32,59.91) 244.59,59.91 244.85,59.65 249.65,59.65 250.25,59.05 252.42,59.05 253.48,60.1 257.74,60.1 258.52,59.32 260.41,59.32 261.47,60.38 263.46,60.38 263.49,60.41 268.87,60.41 268.91,60.37 270.51,60.37 270.93,59.95 271.9,59.95 v2(272.08,60.13)
  IN2 w0.122: v2(178.32,85.03) 180.11,83.24 180.11,76.75 181.77,75.1 184.4,75.1 185.55,76.25 199.98,76.25 200.21,76.02 204.27,76.02 204.6,76.35 220.95,76.35 222.86,74.44 232.16,74.44 234.15,72.44 234.15,71.76 234.78,71.12 239.33,71.12 241.39,69.07 241.39,62.75 244.23,59.91 v2(244.32,59.91)
  BOTTOM w0.102: UC1.A6 170.73,77.05 170.73,77.84 171.01,78.13 174.12,78.13 175.66,79.68 175.66,80.1 176.31,80.74 176.31,81.87 176.8,82.36 176.8,82.89 178.32,84.42 v2(178.32,85.03)
SIO_EXT_WAKE#: length 157.1
  TOP w0.102: UE2.B5 270.29,59.29 270.06,59.52 269.61,59.52 v2(269.2,59.92)
  IN1 w0.089: v2(269.2,59.92) 269.05,59.92 268.78,60.19 263.58,60.19 263.55,60.16 261.56,60.16 260.5,59.1 258.37,59.1 257.63,59.85 253.63,59.85 252.61,58.83 249.16,58.83 v2(248.96,59.03)
  IN2 w0.122: v2(181.78,62.86) 181.78,59.82 180.09,58.13 179.61,58.13 178.35,56.87 178.35,56.87 178.18,56.7 178.18,55.82 177.25,54.89 173.34,54.89 172.5,54.05 171.86,53.41 171.86,53.19 170.24,51.57 170.24,49.22 170.93,48.53 171.62,47.85 173.36,46.1 175.17,44.29 188.14,44.29 189.29,44.29 196.57,37.02 213.63,37.02 214.98,38.37 214.98,38.41 215.3,38.73 215.59,38.73 218.19,41.33 218.46,41.33 218.95,41.81 219.16,41.81 221.52,41.81 221.98,41.35 229.5,41.35 229.95,40.89 235.73,40.89 236.3,40.32 240.22,40.32 241.41,41.51 241.41,41.54 241.43,41.55 241.43,42.27 242.08,42.93 242.08,45.17 242.48,45.56 242.48,49.53 243.85,50.9 244.76,50.9 248.48,54.62 248.48,56.71 248.96,57.19 v2(248.96,59.03)
  BOTTOM w0.076: UC1.AD3 172.33,64.09 172.85,64.09 173.31,63.9 173.36,63.88 173.8,63.69 174.41,63.69 174.9,63.21 174.9,62.7 175.05,62.55 176.96,62.55 177.47,62.05 178,62.05 178.31,62.35
  BOTTOM w0.102: 181.78,62.85 181.69,62.94 180.8,62.94 180.36,62.5 v3(180.08,62.5) 179.92,62.65 178.61,62.65 178.31,62.35 ; 181.78,62.85 182.13,63.2 RC283.2 ; 181.78,62.85 v2(181.78,62.86)
SIO_PWRBTN#: length 274.8
  TOP w0.102: v2(219.16,44.66) 219.16,44.23 219.54,43.84 v3(219.54,43.35) 219.54,40.54 v2(219.79,40.3) ; RC241.2 CC269.1 88.12,40.44 88.51,40.44 88.61,40.53 ; UE2.B58 264.9,57.49 v2(265.39,57.98) ; 88.61,40.53 v2(88.61,40.52) ; 88.61,40.53 89.61,41.53 JXDP1.41
  IN1 w0.089: v2(258.09,52.48) 257.61,52 257.14,52 256.38,51.24 256.38,50.17 256.38,50.17 256.38,49.38 256.38,47.51 254.29,45.42 252.21,45.42 251.62,44.83 249.21,44.83 248.96,45.09 247.03,45.09 245.16,43.22 244.55,43.22 243.87,42.54 241.86,42.54 240.87,41.55 238.43,41.55 238.34,41.65 237.56,41.65 235.42,41.65 234.84,41.07 234.46,41.07 229.61,41.07 229.41,41.27 224.74,41.27 222.54,43.48 220.28,43.48 219.16,44.6 v2(219.16,44.66)
  IN2 w0.122: v2(88.61,40.52) 88.61,37.78 88.6,37.77 88.6,37.41 88.6,36.84 89,36.43 92.34,36.43 92.66,36.11 98.79,36.11 99.58,36.9 102.61,36.9 106.22,40.52 172.48,40.52 174.33,42.37 186.8,42.37 186.8,42.37 188.05,42.37 188.76,42.37 195.62,35.51 215.68,35.51 216.87,36.7 216.87,37.06 218.05,38.24 218.45,38.24 219.62,39.41 219.62,40.14 v2(219.79,40.3)
  IN4 w0.089: v2(258.09,52.48) 259.13,52.48 261.34,54.69 262.83,54.69 263.73,55.59 263.73,56.35 264.94,57.57 264.94,57.57 265.22,57.84 265.22,57.84 265.35,57.98 v2(265.39,57.98)
  BOTTOM w0.076: 168.69,50.17 167.22,51.65 166.7,51.65 164.54,53.81 164.54,54.92 UC1.BA15
  BOTTOM w0.102: 168.69,50.17 168.69,49.37 170.32,47.74 171.56,46.5 176.58,46.5 180.29,42.79 205.92,42.79 207.01,43.88 210,43.88 210.79,43.09 212.52,43.09 212.69,43.26 216.21,43.26 218.09,45.14 218.73,45.14 219.16,44.7 v2(219.16,44.66)
SIO_RCIN#: length 152.5
  TOP w0.102: v2(264.43,68.08) 264.43,67.79 264.65,67.57 UE2.A27 ; v2(169.8,50.23) 169.8,49.49 169.8,49.49 169.8,49.09 169.8,49.09 169.8,47.03 170.14,46.69 RC13.2
  IN1 w0.089: v2(226.15,30.69) 226.04,30.8 225.81,30.8 225.32,31.28 224.84,31.28 224.32,31.8 223.13,31.8 222.63,31.31 222.07,31.31 221.55,31.83 220.03,31.83 219.59,31.39 213.86,31.39 212.89,32.36 187.53,32.36 180.37,39.52 176.18,39.52 172.76,42.94 172.76,46.17 169.8,49.13 v2(169.8,50.23)
  IN2 w0.122: v2(226.15,30.69) 226.86,30.69 228.03,31.86 230.24,31.86 231.71,30.38 238.77,30.38 239.08,30.69 241.97,30.69 243.47,29.19 247.03,29.19 248.81,30.97 248.81,32.96 249.18,33.33 249.79,33.33 254.17,37.71 254.17,38.62 256.39,40.84 256.39,45.36 257.28,46.24 257.28,49.46 256.55,50.18 256.55,52.7 259.2,55.35 259.23,55.35 261.02,57.14 261.02,60.79 262.01,61.78 263.85,61.78 264.3,62.23 264.3,63.04 264.36,63.1 264.36,63.45 264.3,63.51 264.3,67.95 v2(264.43,68.08)
  BOTTOM w0.076: UC1.AW13 165.86,56.31 165.64,55.6 165.64,55.42 165.6,55.31 165.6,55.06 165.64,54.94 165.64,54.76 165.62,54.7 165.6,54.68 165.6,54.29 165.81,54.09 165.81,53.9 165.87,53.83 165.87,53.83 167.14,52.56 167.41,52.56 169.11,50.86
  BOTTOM w0.102: v2(169.8,50.23) 169.74,50.23 169.11,50.86
SIO_SLP_A#: length 228.5
  TOP w0.102: v2(297.97,28.47) 297.98,28.45 JAPS1.6 ; v2(264.86,65.03) 264.86,65.46 264.9,65.5 UE2.B28 ; v2(172.56,38.41) 172.56,37.93 172.96,37.53 183.23,37.53 RC339.2
  IN1 w0.089: v2(297.97,28.47) 297.41,29.03 297.41,36.04 296.14,37.3 296.14,39.81 295.54,40.41 293.4,40.41 290.13,43.67 289.38,43.67 288.82,44.24 277.39,44.24 275.91,42.75 273.11,42.75 v2(272.81,42.45) ; 172.56,38.07 v2(172.56,38.41) 169.04,41.93 169.04,44.49 165.92,47.61 165.92,54.37 163.44,56.86 163.44,59.46 v2(163.84,59.86)
  IN1 w0.102: 172.56,38.07 172.56,37.81 179.46,30.91 212.26,30.91 213.5,29.67 223.1,29.67 224.73,29.67 226.1,28.29 230.9,28.29 233.9,31.29 234.68,31.29 237.65,31.29 238.16,31.8 241.94,31.8 242.45,31.29 245.15,31.29 245.86,32 247.49,32 249.44,33.96 250.08,33.96 250.24,34.12 254.15,34.12 254.59,33.67 257.85,33.67 258.29,34.12 260.08,34.12 v2(261.29,35.32)
  BOTTOM w0.076: UC1.AN16 v2(163.84,59.86)
  BOTTOM w0.102: v2(261.29,35.32) 261.72,35.32 263.03,36.63 265.51,36.63 266.23,37.35 266.23,40.18 267.94,41.89 268.18,41.89 268.86,41.89 268.86,41.89 270.62,41.89 271.77,43.04 272.21,43.04 v2(272.81,42.45) 272.99,42.63 272.99,43.71 273.75,44.47 273.75,45.93 273.39,46.28 265.81,46.28 265.75,46.33 265.44,46.33 261.67,50.1 261.67,50.22 260.8,51.09 260.8,52.22 261.23,52.65 261.23,55.22 262.41,56.39 264.14,56.39 264.98,57.24 264.98,63.78 265.29,64.09 265.29,64.6 v2(264.86,65.03)
SIO_SLP_LAN#: length 126.2
  TOP w0.102: UE2.B37 261.71,64.29 262.01,63.99 262.01,63.71 v2(261.99,63.68) ; v2(220.43,44.66) 220.43,45.27 220.03,45.67 RC68.1
  TOP w0.203: v2(248.45,48.47) 248.26,48.65 UZ2.5
  IN1 w0.089: v2(220.43,44.66) 220.67,44.42 222.93,44.42 225.13,42.21 229.8,42.21 230,42.01 234.46,42.01 235.03,42.59 235.86,42.59 236.79,43.51 237.17,43.51 237.67,44.01 238.79,44.01 239.89,45.11 243.52,45.11 243.66,45.25 244.11,45.25 244.27,45.09 245.22,45.09 245.68,45.55 245.68,46.89 246.46,47.67 247.01,47.67 247.81,48.47 v2(248.45,48.47) ; v2(261.99,63.68) 261.76,63.68 260.62,62.54 259.58,62.54 259.52,62.49 257.13,62.49 257.08,62.54 254.11,62.54 253.81,62.23 253.71,62.23 v2(253.5,62.03)
  BOTTOM w0.076: UC1.AW15 164.76,56.34 164.92,56.18 165.07,55.85 165.07,54.37 164.99,54.29 164.99,53.83 166.51,52.3 167.31,52.3 169.38,50.23
  BOTTOM w0.102: v2(220.43,44.66) 220.43,44.8 219.13,46.1 217.69,46.1 216.82,45.23 206.38,45.23 205.86,44.71 205.86,44.71 204.94,43.78 180.66,43.78 176.98,47.46 171.96,47.46 169.38,50.04 169.38,50.23 ; v2(248.45,48.47) 249.24,49.26 249.28,49.46 249.49,49.97 249.49,50.59 248.85,51.24 RC344.1 248.85,53.27 251.01,55.43 v1(251.01,57.08) 251.01,58.38 251.57,58.93 252.1,58.93 253.5,60.34 v2(253.5,62.03)
SIO_SLP_S0#: length 256.1
  TOP w0.102: v2(300.87,33.57) 300.25,32.95 JAPS1.15 ; v2(199.27,73.61) 199.27,75.31 199.68,75.72 205.21,75.72 205.85,75.07 205.85,73.82 205.34,73.31 204.91,73.31 PR426.1 ; RZ112.1 v2(186.3,65.96) ; PR425.1 206.2,49.98 206.34,49.84 v2(206.34,49.83)
  IN1 w0.089: v2(206.34,49.83) 206.11,49.59 206.11,49.08 207.5,47.69 208.71,47.69 209.27,47.13 213.91,47.13 214.61,46.43 215.08,46.43 215.94,45.57 220.76,45.57 221.26,45.06 223.2,45.06 224.25,44.01 237.01,44.01 237.06,44.01 237.49,44.44 238.61,44.44 239.71,45.54 243.34,45.54 243.48,45.68 243.93,45.68 243.93,45.69 244.11,45.69 244.29,45.69 244.45,45.52 244.93,45.52 245.17,45.77 245.17,47.2 245.99,48.01 245.99,49.92 248.87,52.81 257.26,52.81 257.65,53.2 259.43,53.2 260.29,52.35 261.26,52.35 263.31,50.3 263.31,49.76 264.4,48.67 265.58,48.67 266.68,47.57 269.42,47.57 270.32,48.47 278.85,48.47 280.13,47.19 289.89,47.19 290.56,46.52 294.11,46.52 299.72,40.9 300.32,40.31 300.32,39.29 301.31,38.3 301.31,35.32 300.87,34.87 v2(300.87,33.57) ; v2(199.27,73.61) 198.21,72.56 198.21,71.13 196.56,69.49 194.99,69.49 192.28,66.78 187.53,66.78 186.71,65.96 v2(186.3,65.96) 184.95,65.96 184.66,66.25 182.66,66.25 182.61,66.21 181.63,66.21 181.42,66.01 180.11,66.01 v2(179.82,66.3)
  IN2 w0.122: v2(206.34,49.83) 206.34,49.84 206.16,50.02 206.16,50.38 206.84,51.06 207.54,51.06 208.25,51.78 208.25,52.72 208.82,53.29 208.82,53.91 208.82,53.91 208.82,54.63 205.4,58.05 205.4,58.4 203.1,60.7 200.05,60.7 196.53,64.22 196.53,66.28 198.18,67.93 198.18,72.53 v2(199.27,73.61) ; v2(177.66,81.64) 178.2,81.1 178.2,75.81 178.4,75.61 178.4,73.44 177.57,72.61 177.57,71.28 178.26,70.59 178.69,70.59 179.63,69.65 179.63,66.48 v2(179.82,66.3) 179.82,65.24 179.61,65.04 179.32,64.74 179.34,64.73 179.34,60.4 177.05,58.11 176.77,57.83 171.73,57.83 170.71,58.85 170.71,60.06 170.46,60.31 170.11,60.31 169.77,59.97 168.88,59.97 168.58,60.27 168.25,60.27 167.93,59.95 167.93,58.93 v2(167.52,58.53)
  BOTTOM w0.076: UC1.AT11 167.26,58.53 v2(167.52,58.53)
  BOTTOM w0.102: v2(177.66,81.64) 177.78,81.64 183.07,86.93 183.07,92.64 181.76,93.95 177.76,93.95 176.95,94.76 174.7,94.76 v3(174.18,94.23) UC13.1
SIO_SLP_S3#: length 469.9
  TOP w0.102: UE5.1 254.72,63.94 255.13,63.53 257.47,63.53 RE280.1 258.28,63.99 258.52,63.75 v2(259,63.75) 259.44,64.19 259.95,64.19 260.09,64.04 UE2.A35 ; v2(179.76,32.78) 178.88,33.66 170.41,33.66 165.95,38.11 RZ120.1 ; v2(230.56,84.67) 231.11,84.13 231.11,83.15 231.82,82.44 231.82,79.9 231.03,79.11 230.55,79.11 229.07,77.64 229.07,76.37 228.69,75.99 228.21,75.99 227.87,76.33 UE3.2 ; JAPS1.2 299.99,26.45 303.01,29.47 303.01,33.57 v2(302.61,33.97)
  IN1 w0.089: v2(164.75,59.24) 164.75,59.15 164.35,58.75 164.35,58.39 164.63,58.11 164.63,56.3 167.53,53.41 167.53,47.78 170.23,45.08 170.23,42.07 173.87,38.43 173.87,37.77 178.11,33.53 179.01,33.53 v2(179.76,32.78) 181.41,31.13 212.36,31.13 213.6,29.89 224.82,29.89 226.2,28.52 230.81,28.52 233.8,31.51 234.77,31.51 237.27,31.51 237.78,32.02 242.03,32.02 242.54,31.51 245.05,31.51 245.77,32.22 247.4,32.22 249.39,34.22 249.97,34.22 250.1,34.34 254.24,34.34 254.69,33.9 257.76,33.9 258.2,34.34 259.69,34.34 v2(260.68,35.33)
  IN2 w0.122: v2(177.08,80.24) 177.46,79.86 177.46,75.5 177.65,75.3 177.65,73.74 176.83,72.92 176.83,70.97 177.95,69.85 178.14,69.85 178.87,69.12 178.87,65.34 178.58,65.05 178.58,61.2 177.79,60.41 176,60.41 175.71,60.12 175.71,59.35 175.08,58.72 172.93,58.72 171.41,60.24 171.41,60.31 170.52,61.2 166.51,61.2 166.19,60.88 166.19,60.45 164.98,59.24 v2(164.75,59.24) ; v2(148.21,94.12) 148.21,93.84 147.92,93.55 146.63,92.26 136.47,92.26 134.86,90.65 133.24,90.65 v2(133.07,90.48) ; v2(263.77,73) 263.77,72.62 262.34,71.2 261.96,71.2 261.67,70.91 261.67,70.37 262.07,69.97 262.07,68.17 261.72,67.81 261.72,67.78 261.47,67.53 261.44,67.53 261.07,67.17 261.07,65 260.38,64.31 259.32,64.31 259,64 v2(259,63.75)
  IN3 w0.122: v2(229.04,91.16) 229.04,87.68 230.97,85.75 230.97,85.16 230.56,84.75 v2(230.56,84.67) ; v2(302.61,33.97) 302.61,35.38 296.89,41.1 292.95,41.1 281.82,52.22 281.82,58.85 280.12,60.56 280.12,64.2 278.95,65.37 278.19,65.37 275.1,68.46 273.87,68.46 273.06,69.26 270.88,69.26 267.14,73 v2(263.77,73) ; v2(168.84,95.14) 168.84,95.31 168.29,95.86 150.78,95.86 149.04,94.12 v2(148.21,94.12) ; v2(260.68,35.33) 260.21,34.86 258.53,34.86 258.52,34.87 258.51,34.87 258.27,35.11 258.27,35.12 258.23,35.16 258.23,35.49 259.04,36.3 259.04,38.34 260.54,39.84 260.54,44.91 262.13,46.51 262.13,48.7 261.5,49.33 261.5,51.29 261.67,51.45 261.67,52.81 261.41,53.07 261.41,56.11 259.43,58.09 258.83,58.09 258.32,58.6 258.32,62.13 258.17,62.29 258.17,63.13 258.46,63.43 258.68,63.43 v2(259,63.75)
  IN4 w0.089: v2(263.77,73) 263.77,72.83 262.65,71.72 261.66,71.72 258.97,74.41 256,74.41 253.23,77.18 253.23,80.35 252.61,80.97 252.61,84.12 252.61,84.4 251.83,85.18 249.98,85.18 249.68,85.48 249.68,86.88 249.09,87.47 246.87,87.47 246.79,87.39 244.41,87.39 243.35,86.33 242.69,86.33 242.42,86.06 240.1,86.06 239.22,85.18 232.71,85.18 231.71,84.19 231.04,84.19 v2(230.56,84.67)
  BOTTOM w0.076: UC1.AP15 165.11,59.6 v2(164.75,59.24)
  BOTTOM w0.102: QE11.2 132.43,87.61 132.49,87.67 132.49,89.89 v2(133.07,90.48) ; v2(168.84,95.14) 168.94,95.14 169.65,94.43 169.65,92.7 169.12,92.18 RC320.1 169.46,91.8 171.42,91.8 171.61,91.61 UC13.2 172.3,91.61 175.07,94.38 v3(176.39,94.38) 176.92,94.38 177.58,93.72 181.66,93.72 182.84,92.55 182.84,87.14 177.83,82.12 177.56,82.12 177.08,81.63 v2(177.08,80.24)
  BOTTOM w0.254: v2(229.04,91.16) 229.72,91.16 230.04,91.48 230.04,92.28 230.2,92.45 230.2,95.38 229.63,95.95 229.63,102.38 230.1,102.85 230.1,103.91 229.73,104.28 229.29,104.28 227.77,105.81 226.33,105.81 224.59,104.07 PR511.1
SIO_SLP_S4#: length 587.9
  TOP w0.102: UE2.B36 261.5,64.79 261.96,65.26 v2(261.98,65.26) ; JAPS1.5 299.86,27.95 300.8,28.89 v2(300.8,29.2) ; UC14.2 188.96,29.64 188.08,28.76 181.43,28.76 180.72,29.46 180.72,30.62 v2(178.57,32.78) ; v2(230.03,46.05) 230.36,46.05 230.55,46.24 230.55,47.07 PR1500.1 230.03,48.14 v2(230.49,48.6)
  IN1 w0.089: v2(300.8,29.2) 301.31,29.71 301.31,32.18 301.64,32.51 301.64,35.04 301.74,35.14 301.74,38.48 300.75,39.47 300.75,40.49 299.9,41.34 299.9,41.34 294.29,46.95 290.74,46.95 290.07,47.62 280.31,47.62 279.03,48.9 269.37,48.9 268.66,49.61 265.65,49.61 265.44,49.83 265.44,51.09 265.35,51.18 263.38,51.18 260.61,53.95 257.39,53.95 v2(257.29,54.06) 256.75,53.52 244.74,53.52 243.44,54.82 243.08,54.82 242.84,54.57 242.84,53.27 242.07,52.49 242.07,50.7 241.62,50.25 241.62,48.41 238.3,45.09 237.22,45.09 236.79,44.66 231.43,44.66 v2(230.03,46.05) ; v2(258.71,65.26) 258.71,65.04 259.02,64.73 259.96,64.73 260.49,65.26 261.96,65.26 261.96,65.26 v2(261.98,65.26)
  IN2 w0.122: v2(178.57,32.78) 105.71,32.78 v2(105.03,33.46)
  IN3 w0.122: v2(167.73,89.59) 167.59,89.59 167.1,90.08 167.1,93.13 167.86,93.89 169.43,93.89 174.51,88.81 177.21,88.81 177.66,89.27 177.66,90.3 180.29,92.92 184.65,92.92 188.37,89.21 190.22,89.21 191.34,88.09 204.76,88.09 207.1,85.74 208.13,85.74 v2(208.55,86.16) ; v2(97.01,53.98) 97.07,53.98 97.62,53.42 97.62,50.2 98.77,49.05 98.77,46.79 101.77,43.78 104.42,43.78 v2(104.63,43.58) 105.78,42.42 128.89,42.42 131.64,39.67 170.95,39.67 171.58,40.3 174.62,40.3 175.26,39.67 208.49,39.67 212.43,43.61 212.43,44.55 214.78,46.9 219.37,46.9 220.48,48.01 222.64,48.01 223.89,46.77 229.32,46.77 v2(230.03,46.05) 230.03,46.08 230.27,45.85 238.69,45.85 243.57,50.73 243.57,53.14 244.31,53.88 244.31,55.03 243.04,56.31 243.04,61.32 241.19,63.17 236.71,63.17 236.63,63.09 235.16,63.09 234,64.26 234,68.46 231.72,70.74 231.72,71.96 228.28,75.39 228.28,79.05 229.16,79.92 229.16,79.94 229.68,80.46 229.68,82.76 v2(230.09,83.18)
  IN4 w0.089: v2(105.03,33.46) 104.93,33.55 104.93,43.27 v2(104.63,43.58)
  BOTTOM w0.076: 166.95,50.99 166.9,50.99 164.21,53.67 164.21,55.48 UC1.BA16
  BOTTOM w0.102: v2(257.29,54.06) 257.16,54.18 257.16,62.98 258.71,64.53 v2(258.71,65.26) ; v2(230.09,83.18) 230.06,83.21 230.06,84.36 229.88,84.54 229.17,84.54 228.69,84.06 228.69,82.09 228.18,81.59 v3(228.18,81.22) 228.18,81.02 227.71,80.55 219.39,80.55 218.87,80.03 211.1,80.03 209.71,81.41 209.71,85.81 209.28,86.24 208.62,86.24 v2(208.55,86.16) ; PR208.1 96.96,53.93 v2(97.01,53.98) ; 166.95,50.99 167.91,50.03 167.91,49.12 171.24,45.79 176.24,45.79 179.92,42.1 206.74,42.1 207.76,43.13 208.11,43.13 209.15,42.09 210.02,42.09 210.32,42.38 212.82,42.38 212.98,42.55 216.51,42.55 218.13,44.17 220.53,44.17 221.78,45.43 227.32,45.43 230,48.11 v2(230.49,48.6) ; UZ21.4 167.31,89.31 167.59,89.59 v2(167.73,89.59)
SIO_SLP_S5#: length 206.5
  TOP w0.102: JAPS1.4 299.99,27.45 301.38,28.84 v2(301.38,29.19) ; v2(269.1,67.54) 269.1,67.39 269.15,67.34 UE2.A18
  IN1 w0.089: v2(231.18,47.64) 230.49,46.95 230.49,46.16 231.77,44.87 236.7,44.87 237.13,45.3 238.21,45.3 241.41,48.5 241.41,50.34 241.85,50.79 241.85,52.62 242.61,53.38 242.61,54.65 242.99,55.03 243.53,55.03 244.75,53.81 250.75,53.81 251.66,54.72 257.36,54.72 257.56,54.72 257.89,54.39 261.35,54.39 263.16,52.57 v2(263.49,52.57)
  IN2 w0.122: v2(269.1,67.54) 269.1,66.51 270.33,65.28 270.33,57.43 270.04,57.15 270.04,57.15 270.01,57.12 269.86,57.12 268.67,55.93 268.67,54.08 268.01,53.42 266.97,53.42 266.81,53.58 264.48,53.58 263.92,53.02 263.92,52.99 263.5,52.57 v2(263.49,52.57)
  IN3 w0.122: v2(301.38,29.19) 301.66,29.47 301.66,35.98 296.79,40.85 292.85,40.85 281.58,52.12 281.58,58.75 279.87,60.46 279.87,64.1 278.84,65.12 278.3,65.12 278.09,65.12 275,68.21 273.77,68.21 272.96,69.02 270.57,69.02 v2(269.1,67.54)
  BOTTOM w0.076: 166.92,50.68 164.05,53.55 164.05,55.07 163.89,55.22 163.89,55.67 164.18,55.96 UC1.AY16
  BOTTOM w0.102: v2(231.18,47.64) 230.11,47.64 227.67,45.2 221.88,45.2 220.62,43.95 218.23,43.95 216.6,42.32 213.12,42.32 212.96,42.15 210.69,42.15 209.89,41.35 207.3,41.35 206.81,41.85 179.85,41.85 176.15,45.56 171.01,45.56 167.47,49.1 167.47,50.12 166.92,50.68
SIO_SLP_SUS#: length 353.7
  TOP w0.102: v2(245.02,47.78) 245.81,46.99 245.81,45.97 246.29,45.49 RZ64.1 ; PR406.1 202.81,73.4 203.61,73.4 203.86,73.15 v2(203.86,73.05) ; UC14.1 188.31,29.37 187.93,28.98 181.52,28.98 180.95,29.56 180.95,30.99 v2(179.18,32.77) ; v2(245.25,55.22) 247.12,57.09 250.34,57.09 253.1,54.33 253.1,53.46 253.52,53.04 255.74,53.04 255.82,52.96 259.74,52.96 260.25,52.45 261.25,52.45 261.46,52.66 RC76.2 ; PR312.2 221.7,47.53 v2(221.86,47.37) ; RC340.2 183.02,40.51 182.54,40.02 182.54,39.06 181.26,37.79 173.47,37.79 v2(173.12,38.14)
  IN1 w0.089: v2(164.76,59.84) 164.3,59.38 164.3,59.01 164.13,58.84 164.13,58.3 164.28,58.16 164.28,56.35 166.37,54.26 166.37,47.98 169.69,44.67 169.69,41.99 173.12,38.56 v2(173.12,38.14) 173.12,37.57 178.35,32.34 178.74,32.34 v2(179.18,32.77) ; v2(176.87,77.14) 178.4,77.14 180.83,74.71 185.99,74.71 189.32,78.03 191.63,78.03 192.28,78.68 197.53,78.68 197.91,78.68 198.69,79.46 204.95,79.46 205.86,80.36 205.96,80.36 v2(206.21,80.61)
  IN2 w0.122: v2(221.86,47.37) 221.82,47.41 210.4,47.41 208.83,48.98 208.83,52.95 209.07,53.19 209.07,54.01 209.07,54.01 209.07,54.73 208.92,54.88 205.7,58.1 205.7,58.45 203.19,60.96 200.14,60.96 196.79,64.32 196.79,66.1 198.43,67.74 198.43,72.42 199.2,73.2 199.44,73.2 199.69,73.44 199.69,73.91 200.03,74.26 202.65,74.26 v2(203.86,73.05) ; v2(164.76,59.84) 165.15,60.23 165.15,61.26 165.42,61.53 166.19,61.53 166.3,61.42 170.61,61.42 171.63,60.4 171.63,60.37 172.91,59.09 175.09,59.09 175.46,59.45 175.46,60.22 175.9,60.66 177.68,60.66 178.18,61.15 178.18,62.57 177.41,63.34 177.41,64.24 178.62,65.45 178.62,69.02 178.04,69.6 177.85,69.6 176.72,70.72 176.72,70.72 176.58,70.86 176.58,73.02 177.4,73.85 177.4,75.2 176.87,75.73 v2(176.87,77.14)
  IN3 w0.122: v2(221.86,47.37) 222.82,46.41 229,46.41 230,45.41 238.61,45.41 240.81,47.61 244.85,47.61 v2(245.02,47.78) 245.48,48.24 245.48,48.72 245.3,48.9 245.3,55.17 v2(245.25,55.22) ; v2(229.51,83.32) 229.32,83.14 229.32,82.4 228.69,81.77 228.69,81.21 228.17,80.69 223.64,80.69 220.93,77.98 215.15,77.98 214.39,77.22 210.91,73.74 210.38,73.22 208.16,73.22 207.05,74.33 204.54,74.33 203.86,73.65 v2(203.86,73.05)
  BOTTOM w0.076: v2(164.76,59.84) 164.83,59.84 165.21,60.17 UC1.AN15
  BOTTOM w0.102: v2(176.87,77.14) 176.14,77.88 176.14,79.92 176.77,80.56 176.77,81.69 177.25,82.17 177.25,82.7 179.79,85.24 180.02,85.24 182.38,87.61 182.38,92.27 181.39,93.27 179.37,93.27 179.03,92.92 177.45,92.92 176.79,93.58 175.18,93.58 174.94,93.34 174.94,90.79 174.78,90.63 RZ82.2 ; v2(229.51,83.32) 229.3,83.11 v3(229.3,82.64) 229.3,82.38 228.64,81.72 228.64,80.88 228.08,80.32 219.49,80.32 218.97,79.8 207.02,79.8 v2(206.21,80.61) 206.2,80.63 206.2,82.9 205.14,83.95 205.14,89.44 205.6,89.89 205.6,90.55 206.06,91.01 206.06,100.48 207.06,101.49 207.06,104.3 208.14,105.37 208.14,106.73 207.78,107.09 PR504.1
SIO_SLP_SUS#_R: length 3.1
  TOP w0.102: UE2.B52 261.9,56.26 261.57,55.93 v3(261.57,54.84) 261.46,54.73 RC76.1
SIO_SLP_WLAN#: length 169.8
  TOP w0.102: UE1.A14 246.89,88.52 v2(247.28,88.9) ; v2(239.32,38.9) 239.32,38.28 239.52,38.09 240.94,38.09 242.23,39.37 244.89,39.37 v3(244.89,39.38) 244.9,39.37 247.15,39.37 247.51,39.73 247.51,40.44 248.04,40.97 249.31,40.97 RZ71.1 250.15,42.55 v2(250.43,42.83)
  IN1 w0.089: v2(239.32,38.9) 238.94,38.9 237.63,40.21 235.98,40.21 235.43,39.66 233.87,39.66 229.02,39.66 228.82,39.86 224.16,39.86 221.95,42.07 219.68,42.07 218.73,43.01 v2(218.03,43.01)
  IN3 w0.122: v2(247.28,88.9) 247.28,88.55 247.59,88.24 248.91,88.24 249.44,87.71 249.44,85.21 248.88,84.64 248.88,81.64 248.37,81.13 248.37,77.42 248.72,77.06 248.72,75.87 252.05,72.55 256.83,72.55 v2(257.36,72.01)
  IN4 w0.089: v2(250.43,42.83) 248.8,44.46 248.23,44.46 246.09,46.61 246.09,48.4 247.36,49.67 247.36,50.59 250.94,54.17 250.94,55.41 248.42,57.93 248.42,61.19 v2(249.87,62.64)
  BOTTOM w0.076: 166.4,49.99 166.4,50.6 163.72,53.29 163.72,54.43 UC1.BB17
  BOTTOM w0.102: v2(257.36,72.01) 257.36,70.02 256.23,68.89 250.84,68.89 249.39,67.44 249.39,63.12 v2(249.87,62.64) ; 166.4,49.99 166.4,48.96 171.47,43.9 175.79,43.9 178.34,41.35 178.78,41.35 179.19,40.94 181.47,40.94 182.25,40.16 209.64,40.16 210.81,41.33 212.6,41.33 213.03,40.9 215.91,40.9 v2(218.03,43.01)
SL_BAT_PRES#: length 2.1
  TOP w0.102: PR926.1 27.68,86.21 PU901.21
SLEEVE:
  vias: v2(283.09,32.97) v2(283.68,32.97) v2(288.5,35.03) v2(288.5,34.42) v2(289.55,40.44) v2(289.55,39.81) v3(288.23,35.6)
SLEEVE_R:
  vias: v2(292.67,31.22) v2(292.67,30.64) v2(294.04,34.98) v2(294.63,34.95) v3(292.07,20.87)
SLICE_BAT_ON: length 297.4
  TOP w0.102: UE1.A31 243.65,79.38 243.37,79.1 242.28,79.1 242.18,79.2 241.04,79.2 240.66,79.59 240.66,80.01 RE17.2 239.72,79.75 238.2,79.75 237.17,80.78 v3(237.17,81.27) 237.17,83 240.18,86.01 240.18,88.41 239.28,89.31 238.92,89.31 238.7,89.54 238.7,90.12 238.95,90.38 239.3,90.38 240.01,89.67 242.13,89.67 242.56,89.23 243.14,89.23 243.5,89.59 243.5,97.9 239.86,101.53 v2(239.89,101.53) ; v2(23.2,89.51) 23.5,89.51 23.94,89.07 23.94,87.46 PR930.2
  IN3 w0.122: v2(239.89,101.53) 237.54,101.53 237.08,101.99 232.39,101.99 231.85,102.53 230.31,102.53 230.16,102.38 228.94,102.38 227.63,103.69 214.22,103.69 213.35,102.82 209.13,102.82 207.29,100.99 207.29,99.83 201.61,94.15 200.04,94.15 199.97,94.08 192.07,94.08 188.75,97.4 181.75,97.4 180.92,98.23 178.5,100.65 178.5,100.86 178.5,100.86 178.5,107.67 177.97,108.2 177.97,108.93 177.24,109.66 162.4,109.66 162.33,109.59 161.21,109.59 160.89,109.91 158.66,109.91 156.7,107.95 149.39,107.95 148.62,107.19 135.77,107.19 132.8,110.16 129.05,110.16 127.3,108.41 127.3,104.54 119.66,96.9 119.51,96.75 118.02,96.75 118.02,96.75 117.61,96.75 117.1,96.24 116.55,95.69 116.55,94.24 115.45,93.15 111.02,93.15 110.39,93.78 106.4,93.78 105.99,94.19 104.22,94.19 101.28,97.14 93.34,97.14 92.56,96.36 89.85,96.36 89.51,96.7 62.78,96.7 62.36,97.11 62.22,97.26 62.22,97.26 61.74,97.74 60.03,97.74 59.43,98.34 57.58,98.34 56.5,97.26 54.87,97.26 44.92,87.31 40.72,87.31 37.81,90.22 28.73,90.22 28.06,89.55 28.06,89.37 27.7,89.01 26.31,89.01 25.81,89.51 v2(23.2,89.51)
SLICE_BAT_PRES#: length 443.1
  TOP w0.102: v2(264.63,76) 264.37,76.25 263.94,76.25 263.87,76.18 RPE12.1 ; v2(246.5,80.16) 246.5,79.9 245.74,79.13 UE1.B33 ; v2(24.37,91.14) 25.6,89.91 25.8,89.91 26.11,89.6 26.92,89.6 27.23,89.91 27.67,89.91 28.03,89.55 28.03,87.53 PR926.2 ; v2(239.1,89.95) 240.41,88.64 240.41,85.91 237.94,83.44 v3(237.94,83.07) 237.94,82.19 v2(238.64,81.49) ; v2(57.97,13.85) 57.38,13.85 55.97,12.44 53.74,12.44 PR4.1
  IN1 w0.089: v2(264.63,76) 263.94,75.31 256.65,75.31 254.98,73.64 249.72,73.64 249.14,74.22 245.84,74.22 245.49,74.57 245.49,76.24 245.47,76.27 245.47,76.39 244.54,77.32 244.54,78.45 245.4,79.3 245.88,79.3 246.5,79.92 v2(246.5,80.16) 246.46,80.2 243.81,80.2 243.7,80.09 242.61,80.09 242.58,80.11 242.58,80.12 242.35,80.35 242.35,80.35 241.21,81.49 v2(238.64,81.49) ; v2(170.02,99.13) 168.35,97.46 137.29,97.46 136.73,98.02 134.93,98.02 133.96,97.05 119.5,97.05 119.49,97.04 118.81,97.04 118.31,96.53 114.81,96.53 114.06,95.78 107.35,95.78 107.19,95.94 105.04,95.94 101.76,99.22 95.41,99.22 94.12,100.51 81.42,100.51 79.64,98.73 61.02,98.73 59.73,97.44 59.09,97.44 58.58,96.93 53.96,96.93 53.48,96.45 52.39,96.45 51.47,97.36 50.66,97.36 50.13,96.83 50.13,95.05 48.12,93.04 26.28,93.04 v2(24.37,91.14)
  IN2 w0.122: v2(170.02,99.13) 170.15,99.13 170.61,98.68 174.6,98.68 175.74,97.53 175.74,97.52 176.13,97.13 177.53,95.73 180.06,95.73 180.85,94.94 181.53,94.26 181.54,94.26 181.61,94.19 184.14,94.19 188.6,89.74 189.2,89.74 190.72,88.22 197.82,88.22 198.18,87.86 199.25,87.86 199.63,88.24 204.77,88.24 205.86,87.15 212.08,87.15 213.18,86.06 213.18,85.22 213.59,84.81 220.08,84.81 220.75,85.48 220.75,86.37 221.29,86.91 221.3,86.91 221.3,87.65 221.34,87.69 222.07,88.42 222.92,88.42 224.31,89.8 224.76,90.26 229.33,90.26 229.64,89.95 235.27,89.95 235.29,89.97 235.84,89.97 235.87,89.95 v2(239.1,89.95) ; v2(57.97,13.85) 58.05,13.92 58.05,15.86 60,17.8 61.97,17.8 62.35,17.42 67.89,17.42 72.74,22.27 72.74,37.96 69.64,41.06 69.64,50.48 68.75,51.37 68.75,52.15 68.5,52.41 68.5,64.39 65.02,67.87 64.03,67.87 59.8,72.09 57.46,72.09 55.64,70.28 52.73,70.28 50.82,71.27 49.8,71.78 47.37,72.56 46.4,73.54 32.02,73.54 31.6,73.96 30.5,73.96 30.08,73.54 27.04,73.54 26.62,73.95 25.52,73.95 25.13,73.56 19.82,73.56 18.16,75.22 18.16,84.35 17.79,84.71 17.79,87.72 21.51,91.43 24.08,91.43 v2(24.37,91.14)
  BOTTOM w0.102: JDOCK1.143 172,101.73 171.82,101.91 171.68,101.91 171.5,101.73 JDOCK1.141 171.5,99.54 171.15,99.19 170.08,99.19 v2(170.02,99.13)
SLOT2_CONFIG_0: length 59.9
  TOP w0.102: v2(248.56,85.93) 248.25,85.93 248.14,86.03 UE1.B12 ; RPE11.2 242.82,74 242.96,74.15 242.96,74.65 242.68,74.93 242.68,76.84 v2(242.86,77.02) 243.78,77.02 244.59,77.83 v2(244.99,77.83)
  IN1 w0.089: v2(244.99,77.83) 244.97,77.83 245.07,77.73 247.1,77.73 248.27,78.9 248.27,85.32 248.56,85.61 v2(248.56,85.93) ; v2(230.82,88.85) 230.82,89.19 231.08,89.44 233.76,89.44 234.83,88.37 235.75,88.37 238.24,85.88 238.24,81.33 238.48,81.09 240.24,81.09 242.34,78.99 242.34,78.82 242.35,78.81 242.35,77.52 v2(242.86,77.02)
  IN3 w0.122: v2(230.82,88.85) 231.53,88.14 231.53,86.74 232.32,85.96 232.35,85.96 233.36,84.95 233.36,83.21 232.82,82.67 232.82,80.58 233,80.4 233,74.53 v2(235.11,72.42)
  BOTTOM w0.102: v2(235.11,72.42) 234.98,72.55 JNGFF2.13
SLOT2_CONFIG_1: length 38.6
  TOP w0.102: v2(243.09,85.79) 243.18,85.88 UE1.A18 ; RPE11.4 241.79,73 241.49,73.31 v2(241.49,73.84)
  IN1 w0.089: v2(235.77,64.06) 236.16,63.68 237.06,63.68 237.45,64.07 238.74,64.07 241.22,66.55 241.22,73.3 241.51,73.59 241.51,73.82 v2(241.49,73.84)
  BOTTOM w0.102: v2(235.77,64.06) 235.93,63.91 235.93,61.77 234.71,60.55 JNGFF2.61 ; v2(243.09,85.79) 243.24,85.64 243.24,84.74 241.16,82.66 241.16,79.94 242.05,79.05 243.65,79.05 243.92,78.78 243.92,74.84 242.92,73.84 v2(241.49,73.84)
SLOT2_CONFIG_2: length 39.4
  TOP w0.102: RPE11.3 242.03,73.5 241.9,73.64 241.9,74.1 v2(241.51,74.48) ; v2(252.49,76.31) 252.18,76.61 251.57,76.61 251.39,76.79 UE1.A44
  IN1 w0.089: v2(241.51,74.48) 241.49,74.48 241.01,73.99 241.01,66.64 238.65,64.28 237.36,64.28 237.13,64.05 236.47,64.05 v2(236.41,64.11)
  IN4 w0.089: v2(241.51,74.48) 241.71,74.28 246.16,74.28 246.99,75.11 246.99,76.43 247.47,76.91 251.88,76.91 v2(252.49,76.31)
  BOTTOM w0.102: v2(236.41,64.11) 236.31,64.01 236.31,61.53 235.77,61 235.77,59.44 235.38,59.05 JNGFF2.67 232.96,59.05 232.58,59.43 v3(231.77,59.43)
SLOT2_CONFIG_3: length 16.3
  TOP w0.102: UE1.B34 244.63,78.63 243.5,77.5 v3(243.2,77.5) 242.73,77.5 242.45,77.22 242.45,74.55 RPE11.1 242.1,74.5 241.67,74.93 241.24,74.93 240.89,74.59 240.61,74.59 v2(240.17,74.15)
  BOTTOM w0.102: v2(240.17,74.15) 238.72,74.15 235.32,77.55 JNGFF2.1
SM_RCOMP0: length 2.9
  TOP w0.381: RC5.1 162.19,60.43 162.46,60.16 v1(162.46,59.58) 162.46,59.05 v2(162.92,58.59)
  BOTTOM w0.254: UC1.AR18 163.35,58.93 162.93,58.59 v2(162.92,58.59)
SM_RCOMP1: length 12.7
  TOP w0.381: v2(162.92,57.95) 162.57,57.76 162.24,57.24 161.95,56.81 161.63,56.08 161.61,56.06 RC6.1
  BOTTOM w0.254: UC1.AT18 163.35,58.28 162.93,57.95 v2(162.92,57.95)
SM_RCOMP2: length 11.8
  TOP w0.381: RC7.1 162.3,46.51 v3(162.3,54.52) 162.3,55.92 162.9,57.32 v2(162.92,57.32)
  BOTTOM w0.254: v2(162.92,57.32) 162.93,57.32 163.35,57.63 UC1.AU18
SML0_SMBCLK: length 171.2
  TOP w0.102: v2(265.29,85.06) 265.7,85.06 266.57,85.93 UL1.28 ; RC347.1 183.71,66.93 v2(183.71,67.47)
  IN1 w0.089: v2(177.51,67.3) 179.1,67.3 179.49,66.91 182.34,66.91 182.39,66.96 183.3,66.96 183.71,67.36 v2(183.71,67.47) 183.76,67.47 184.21,67.02 186.4,67.02 187.42,68.04 189.31,68.04 191.83,70.56 194.95,70.56 200.29,75.9 219.76,75.9 221.03,74.63 227.45,74.63 229.61,72.47 229.61,70.29 230.1,69.8 230.1,69.42 230.21,69.32 230.21,62.38 231.8,60.79 232.34,60.79 234.59,58.54 235.92,58.54 236.79,59.4 239.61,59.4 239.81,59.2 242.84,59.2 244.33,57.7 250.28,57.7 250.94,57.04 252.91,57.04 253.1,57.23 254.06,57.23 254.34,57.5 255.01,57.5 255.82,56.69 259.58,56.69 259.91,56.37 263.8,56.37 264.64,55.53 267.91,55.53 269.21,54.23 270.84,54.23 271.67,55.06 273.88,55.06 274.1,54.84 276.44,54.84 v2(276.62,54.66)
  IN2 w0.122: v2(276.62,54.66) 276.63,54.66 277.72,55.75 277.72,64.13 276.36,65.49 276.36,66.24 274.83,67.77 274.46,67.77 274.2,67.77 273.29,68.68 273.29,69.31 273.29,69.32 273.29,69.54 271.55,71.28 270.64,71.28 269.31,72.61 269.31,73.3 267.04,75.56 267.04,75.91 265.96,76.98 265.96,81.19 265.97,81.19 265.97,81.82 265.29,82.49 v2(265.29,85.06)
  BOTTOM w0.076: 176.84,66.63 176.8,66.59 173.3,66.59 173.02,66.65 172.48,66.65 172.44,66.69 171.96,66.69 171.72,66.94 171.72,67.22 171.11,67.82 169.85,67.82 169.64,68.04 169.64,68.43 168.89,69.18 UC1.R9
  BOTTOM w0.102: 176.84,66.63 v2(177.51,67.3) 177.69,67.11 177.69,66.75 RC19.1
SML0_SMBDATA: length 168.6
  TOP w0.102: v2(183.11,67.45) 182.9,67.24 RC348.1 ; v2(265.98,87.98) 266.36,87.6 266.36,87.42 266.65,87.13 UL1.31
  IN1 w0.089: v2(276.62,55.43) 276.5,55.31 274.29,55.31 274.07,55.53 271.47,55.53 270.64,54.7 269.41,54.7 268.1,56 264.83,56 263.99,56.84 260.1,56.84 259.78,57.16 256.02,57.16 255.2,57.97 254.14,57.97 253.87,57.7 252.91,57.7 252.72,57.51 251.13,57.51 250.47,58.17 244.53,58.17 243.03,59.67 240.01,59.67 239.8,59.87 236.59,59.87 235.73,59.01 234.78,59.01 232.54,61.26 232,61.26 230.68,62.58 230.68,69.51 230.57,69.62 230.57,69.99 230.08,70.48 230.08,72.66 227.64,75.1 221.23,75.1 219.96,76.37 200.48,76.37 200.09,76.37 200.09,76.37 194.76,71.03 191.63,71.03 189.11,68.51 186.94,68.51 186.46,68.03 185.86,68.03 185.6,67.77 184.99,67.77 184.83,67.94 183.51,67.94 183.11,67.54 v2(183.11,67.45) 182.68,67.45 182.25,67.88 181.88,67.88 181.37,67.38 179.92,67.38 179.53,67.77 177.3,67.77 v2(176.84,67.31)
  IN2 w0.122: v2(276.62,55.43) 277.22,56.03 277.22,63.92 275.65,65.49 275.65,66.24 274.62,67.27 274.25,67.27 273.99,67.27 272.79,68.47 272.79,69.11 272.78,69.11 272.78,69.33 271.34,70.77 270.43,70.77 268.8,72.4 268.8,73.09 266.54,75.35 266.54,75.7 265.46,76.77 265.46,81.4 265.46,81.61 264.79,82.28 264.79,85.06 264.79,85.06 264.79,85.31 265.46,85.99 265.46,87.64 265.8,87.98 v2(265.98,87.98)
  BOTTOM w0.076: UC1.W2 172.9,66.82 173.04,66.82 173.32,66.76 176.28,66.76 176.38,66.85
  BOTTOM w0.102: 176.38,66.85 v2(176.84,67.31) 177.02,67.5 177.31,67.78 177.71,67.78 177.99,67.5 177.99,67.34 RC20.1
