# Allegro board LAC621PR10-0924-A.brd (continued)
## Nets (continued)
+3.3V_ALW_PCH: CC209.1 CC215.1 CC223.1 CC224.1 JAPS1.1 LC1.1 PJP11.1 PJP19.2 RC12.2 RC14.2 RC15.2 RC17.2 RC23.1 RC25.2 RC26.2 RC74.1 RC133.1 RC183.1 RC184.1 RC186.1 RC187.1 RC211.1 RC222.1 RC235.1 RC236.1 RC246.2 RC283.1 RC288.2 RC289.2 RC307.1 RC308.1 RC317.2 RC330.1 RC331.1 RC341.1 RC343.2 RC344.2 RC347.2 RC348.2 RPC3.5 RPC3.6 RPC3.7 RPC3.8 UC1.AG15 UC1.AJ21 UC1.AK17 UC1.V19 UC1.Y16 UC7.5
+3.3V_ALW_PCH_UZ24: CZ64.1 PJP19.1 UZ4.8 UZ4.9
+3.3V_ALW_UE1: CE2.1 CE3.1 CE4.1 CE5.1 CE6.1 PJP14.2 UE1.A17 UE1.A43 UE1.A54 UE1.B5 UE1.B30
+3.3V_ALW_UE2: CE13.1 CE14.1 CE15.1 CE16.1 CE17.1 CE18.1 CE19.1 CE20.1 CE22.1 CE23.1 PJP15.2 UE2.A11 UE2.A22 UE2.A26 UE2.A41 UE2.A52 UE2.A58 UE2.B3 UE2.B35
+3.3V_ALWP: PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PJP102.1 PL100.2 PR108.2 PR109.1 PU100.14
+3.3V_CAM: CZ1.1 JEDP1.11 QZ1.1
+3.3V_HDD: CN15.1 CN16.1 CN46.1 CN49.1 JSATA1.9 JSATA1.10 PJP36.2 RN5.1 RN8.1 RN10.2 RN12.2 RN14.1 RN18.1 RN20.1 RN22.1 RN84.1 UN7.10 UN7.20
+3.3V_HDD_M2: CN19.1 CN20.1 CN29.1 CN30.1 CN41.1 CN42.1 CZ60.1 CZ61.1 JNGFF3.2 JNGFF3.4 JNGFF3.12 JNGFF3.14 JNGFF3.16 JNGFF3.18 JNGFF3.62 JNGFF3.64 JNGFF3.66 PJP34.1 RN25.1 RN26.1 RN27.1 RN28.1 RN37.1 RN42.1 RN43.1 RN44.1 RN49.1 RN50.1 RN51.1 RN55.1 RN56.1 RN57.1 RN58.1 RN63.1 RN64.1 RN65.1 RN69.1 RN70.1 RN71.1 UN4.12 UN4.24 UN5.12 UN5.24
+3.3V_LAN: CL15.1 CL18.1 CL19.1 CL25.1 CL26.1 CL27.1 JLOM1.9 JLOM1.12 PJP13.2 RC19.2 RC20.2 RL1.1 RL2.1 RL4.2 RL5.1 RL6.1 RL8.1 RL29.1 RL30.1 RL70.1 UL2.5 UL4.1 UL4.4 UL4.8 UL4.14 UL4.21 UL4.30 UL4.39
+3.3V_LAN_OUT: CL7.1 CL28.1 RL8.2 UL1.4 UL1.5 UL1.15 UL1.19 UL1.29
+3.3V_LAN_UZ2: CZ50.1 PJP13.1 UZ2.8 UZ2.9
+3.3V_M: PJP20.2 RC276.2 RZ72.1
+3.3V_M_TPM: CZ74.1 CZ75.1 CZ76.1 PJP11.2 QZ9.3 RZ69.1 RZ72.2 RZ88.1 UZ12.14 UZ12.22
+3.3V_M_UZ8: CZ43.1 PJP20.1 UZ8.7 UZ8.8
+3.3V_MMI_AUX: CR8.1 CR42.1 R274.1 RR16.1 RR19.1 UR2.27
+3.3V_MMI_IN: CR36.1 CR43.1 PJP26.2 R274.2 UR2.11
+3.3V_PGPPD: RC307.2 UC1.Y15
+3.3V_PGPPE: CC208.1 RC308.2 UC1.T16
+3.3V_RTC_LDO: PD1.3 PR105.2
+3.3V_RUN: CA7.1 CC30.2 CC285.2 CC287.2 CN1.1 CN2.1 CV124.1 CV125.1 CV126.1 CV127.1 CV128.1 CV600.1 CV601.1 CV602.1 CV603.1 CV604.1 CZ11.1 JEDP1.10 JLPDE1.1 JLPDE1.2 JUSH1.8 PJP10.1 PJP16.1 PJP22.2 PJP25.1 PJP26.1 PJP34.2 PJP36.1 PJP503.1 PR507.1 PR612.1 QC2.2 QC2.5 QV3.2 QV3.5 QV5.2 QV8.3 QZ1.3 RC13.1 RC21.1 RC27.2 RC47.1 RC50.1 RC51.1 RC59.1 RC137.1 RC175.2 RC176.2 RC177.2 RC178.2 RC179.1 RC181.1 RC189.1 RC190.1 RC225.1 RC237.2 RC267.1 RC270.1 RC272.1 RC279.1 RC281.1 RC282.1 RC287.2 RC291.1 RC292.1 RC318.1 RC319.1 RC322.2 RC326.2 RC335.1 RC336.1 RC346.2 RD60.1 RD62.1 RD63.1 RD64.1 RD65.1 RD69.1 RD70.1 RD71.1 RE48.1 RE51.1 RE67.1 RN2.1 RPC4.5 RPC4.6 RPC4.7 RPC4.8 RPC5.1 RPC5.2 RPC5.3 RPE8.5 RPE8.6 RPE8.7 RPE8.8 RPE13.3 RPE13.4 RV6.1 RV8.2 RV19.1 RV22.2 RV121.1 RV250.1 RV251.1 RV601.1 RV602.1 RV603.1 RV604.1 RV605.1 RV610.1 RV611.1 RV612.1 RV613.1 RV614.1 RV615.1 RV623.1 RZ89.1 RZ90.1 UC8.14 UC12.5 UN1.2 UN1.3 UN1.9 UN1.10 UV16.4 UV16.23 UV16.29 UV16.32 UV26.5 UV26.21 UV26.30 UV26.51 UV26.57 UZ5.6 UZ5.7
+3.3V_RUN_AUDIO: CA10.1 CA11.1 CA50.1 PJP10.2 PJP30.2 RA1.1 RA4.1 RA18.1 RA26.1 RA29.1 RA38.2 RA45.2 UA1.3 UA1.9
+3.3V_RUN_AUDIO_UZ5: CZ92.1 PJP30.1 UZ5.8 UZ5.9
+3.3V_RUN_CARD: CR38.2 CR39.2 JSD1.4 UR2.12
+3.3V_RUN_DIMM1: CD31.1 CD32.1 JDIMM1.255 RD65.2
+3.3V_RUN_DIMM2: CD63.1 CD64.1 JDIMM2.255 RD60.2
+3.3V_RUN_UZ3: CZ47.1 PJP22.1 UZ3.13 UZ3.14
+3.3V_RUN_VDDA: CV98.1 CV99.1 CV100.1 CV101.1 LV25.1 UV8.C10 UV8.H5 UV8.H12 UV8.J4 UV8.K6 UV8.K7
+3.3V_RUN_VDDIO: CV94.1 CV95.1 CV96.1 CV97.1 LV24.2 UV8.B5 UV8.B6 UV8.C3 UV8.C4 UV8.C11 UV8.C12 UV8.K3 UV8.K4 UV8.K11 UV8.K12
+3.3V_RUN_VMM: CV114.1 CV118.1 CV121.1 LV24.1 LV25.2 PJP25.2 RPV1.5 RPV1.6 RPV1.7 RPV1.8 RPV2.5 RPV2.6 RPV2.7 RPV2.8 RV82.2 RV83.2 RV84.2 RV85.2 RV86.1 RV87.1 RV88.1 RV90.1 RV91.1 RV516.2 RV517.1 RV518.1 RV519.1 UV9.8 UV11.14 UV12.14
+3.3V_SPI: CC9.1 CC10.1 JSPI1.6 RC30.1 RC31.1 RC41.2 UC1.AJ16 UC5.8 UC6.8
+3.3V_SPI_R: JSPI1.5 RC41.1 RC276.1 RC289.1
+3.3V_TP: CZ27.1 JKBTP1.12 PJP16.2 RZ18.1 RZ19.1 RZ20.1 RZ21.1 RZ116.1 RZ117.1
+3.3V_TSP: CZ2.1 JEDP1.1 QV8.1
+3.3V_VCCHDA: CC310.1 LC1.2 UC1.AJ19
+3.3V_WLAN: CZ15.1 CZ16.1 CZ17.1 CZ18.1 CZ19.1 CZ20.1 CZ106.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 PJP12.2
+3.3V_WLAN_UZ3: CZ36.1 PJP12.1 UZ3.8 UZ3.9
+3.3V_WWAN: CZ51.1 CZ52.1 CZ53.1 CZ54.1 CZ55.1 CZ57.1 CZ105.1 JNGFF2.2 JNGFF2.4 JNGFF2.62 JNGFF2.64 JNGFF2.66 PJP23.2 RZ43.1
+3.3V_WWAN_UZ2: CZ39.1 PJP23.1 UZ2.13 UZ2.14
+5V_ALW: CI6.1 CI7.1 CI11.1 CI12.1 CI19.1 CI31.1 JLED1.1 JUART1.1 JUSH1.9 LED3.2 PC507.1 PC1500.1 PJP103.2 PJP403.1 PJP404.1 PR9.1 PR201.2 PR205.1 PR602.2 PR937.2 PU1.5 PU502.6 PU602.9 PU602.10 PU1500.6 RI13.2 RV662.2 UI1.5 UI2.5 UI3.1 UI3.7 UI3.8 UV28.3 UZ2.4 UZ3.4 UZ4.1 UZ4.2 UZ4.4 UZ5.4 UZ8.4 UZ19.3 UZ20.3 UZ21.3 UZ23.1 UZ23.2 UZ23.4 UZ26.3
+5V_ALW2: CZ94.1 PC126.1 PU102.15 RZ86.1
+5V_ALW2_R: JUSH1.10 RZ86.2
+5V_ALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PJP103.1 PL101.2 PR115.1 PR117.2 PU102.14
+5V_HDD: CN13.1 CN14.1 JSATA1.15 JSATA1.16 JSATA1.17 PJP805.2 PJP1603.1 RN1.1
+5V_HDD_UZ2: CZ99.1 PJP805.1 UZ23.7 UZ23.8
+5V_RUN: CE32.1 CV23.1 CV144.1 CZ10.1 CZ29.1 DE1.1 JFAN1.4 JKBTP1.5 JUSH1.7 PC661.1 PC677.1 PC685.1 PJP9.1 PJP21.2 PJP1603.2 PU603.2 PU605.2 PU606.6 RPE2.1 RPE2.2 RPE2.3 RPE2.4 UV2.1 UV4.1 UV16.16 UZ5.1 UZ5.2
+5V_RUN_AUDIO: LA5.2 PJP9.2 PJP31.2 RA39.1
+5V_RUN_AUDIO_UZ5: CZ89.1 PJP31.1 UZ5.13 UZ5.14
+5V_RUN_PVDD: CA45.1 CA46.1 CA47.1 CA48.1 RA39.2 UA1.41 UA1.46
+5V_RUN_UZ4: CZ44.1 PJP21.1 UZ4.13 UZ4.14
+5V_USB_CHG_PWR: CI14.1 CI17.1 CI32.1 JUSB3.1 UI3.12
+DV33_18: CR37.1 UR2.18
+GND_CHASSIS: CL22.2 RL15.2 RL16.2 RL17.2 RL18.2
+VCC_1P8: CC222.1 RC313.2 UC1.U11 UC1.U12
+VCC_CORE: CC282.1 CC283.2 CC284.2 CC287.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1061.1 PC1062.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1097.1 PC1098.1 PC1099.1 PC1125.1 PC1126.1 PC1127.1 PC1164.1 PC1170.1 PC1171.1 PC1172.1 PC1173.1 PC1174.1 PL603.1 RC140.1 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_CORE_G0: T122.1(TP-1) UC1.K32
+VCC_CORE_G1: T123.1(TP-1) UC1.AK32
+VCC_GT: PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1055.1 PC1056.1 PC1063.1 PC1128.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1138.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PL604.1 RC161.1 UC1.A48 UC1.A53 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K48 UC1.K50 UC1.K52 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GTUS: UC1.AK42 UC1.AK43 UC1.AK45 UC1.AK46 UC1.AK48 UC1.AK50 UC1.AK52 UC1.AK53 UC1.AK55 UC1.AK56 UC1.AK58 UC1.AK60 UC1.AL43 UC1.AL46 UC1.AL50 UC1.AL53 UC1.AL56 UC1.AL60 UC1.AM48 UC1.AM50 UC1.AM52 UC1.AM53 UC1.AM56 UC1.AM58
+VCC_SA: PC633.2 PC637.2 PC644.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PH604.2 PL601.2 PR636.2 PR641.2 PR643.1 RC168.1 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VCC_SFR_OC: CC288.1 CZ114.1 RZ119.2 UC1.AL23 UZ26.6
+VDDA_AVDD1: CA8.1 CA9.1 LA5.1 UA1.27
+VDDA_PVDD: CA17.1 CA18.1 RA4.2 UA1.38
GND: C33.2 C42.2 C43.2 C263.2 C310.2 C311.2 C316.2 C317.2 C318.2 C319.2 CA5.2 CA6.2 CA7.2 CA10.2 CA11.2 CA12.2 CA13.1 CA19.2 CA22.2 CA23.2 CA24.2 CA31.2 CA33.2 CA41.2 CA45.2 CA46.2 CA47.2 CA48.2 CA49.1 CA50.2 CA53.2 CA54.2 CC3.1 CC4.1 CC5.1 CC6.1 CC7.1 CC8.1 CC9.2 CC10.2 CC21.2 CC22.2 CC23.1 CC24.2 CC25.2 CC26.1 CC27.2 CC28.2 CC29.2 CC30.1 CC32.2 CC33.2 CC174.2 CC175.2 CC176.2 CC177.2 CC178.2 CC179.2 CC181.2 CC182.2 CC185.2 CC186.2 CC194.2 CC195.2 CC199.2 CC202.2 CC203.2 CC204.2 CC206.2 CC208.2 CC209.2 CC210.2 CC211.2 CC212.2 CC213.2 CC214.2 CC215.2 CC216.2 CC217.2 CC218.2 CC219.2 CC220.2 CC221.2 CC222.2 CC223.2 CC224.2 CC225.2 CC226.2 CC248.2 CC249.2 CC250.2 CC251.2 CC252.2 CC253.2 CC254.2 CC255.2 CC256.2 CC257.2 CC264.2 CC266.2 CC269.2 CC270.2 CC271.2 CC272.2 CC273.2 CC274.2 CC279.2 CC280.2 CC281.2 CC288.2 CC294.2 CC295.2 CC296.2 CC297.2 CC300.2 CC301.2 CC302.2 CC310.2 CC311.2 CD2.2 CD3.2 CD4.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD35.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD93.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CE1.2 CE2.2 CE3.2 CE4.2 CE5.2 CE6.2 CE7.2 CE8.2 CE9.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE17.2 CE18.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE34.2 CE36.2 CE38.2 CE40.2 CE44.2 CE45.2 CE47.2 CE52.2 CE53.2 CI1.2 CI3.2 CI6.2 CI7.2 CI8.2 CI10.2 CI11.2 CI12.2 CI14.2 CI17.2 CI19.2 CI31.2 CI32.2 CI33.2 CI34.2 CI35.2 CL3.2 CL4.2 CL7.2 CL8.2 CL9.2 CL10.2 CL11.2 CL12.2 CL13.1 CL14.1 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.1 CL25.2 CL26.2 CL27.2 CL28.2 CMOS1.2 CN1.2 CN2.2 CN13.2 CN14.2 CN15.2 CN16.2 CN19.2 CN20.2 CN29.2 CN30.2 CN41.2 CN42.2 CN46.2 CN49.2 CR8.2 CR9.2 CR10.2 CR13.2 CR23.2 CR35.2 CR36.2 CR37.2 CR38.1 CR39.1 CR40.1 CR41.1 CR42.2 CR43.2 CV7.2 CV8.2 CV9.2 CV10.2 CV12.2 CV23.2 CV26.2 CV27.2 CV50.2 CV51.2 CV52.2 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV82.2 CV83.2 CV84.2 CV85.2 CV86.2 CV87.2 CV88.2 CV89.2 CV90.2 CV91.2 CV92.2 CV93.2 CV94.2 CV95.2 CV96.2 CV97.2 CV98.2 CV99.2 CV100.2 CV101.2 CV113.2 CV114.2 CV115.2 CV118.2 CV121.2 CV124.2 CV125.2 CV126.2 CV127.2 CV128.2 CV144.2 CV374.2 CV600.2 CV601.2 CV602.2 CV603.2 CV604.2 CV605.2 CV615.2 CV616.2 CV617.2 CV618.2 CV619.2 CZ1.2 CZ2.2 CZ10.2 CZ11.2 CZ12.2 CZ15.2 CZ16.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ23.2 CZ24.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ34.2 CZ36.2 CZ37.2 CZ38.2 CZ39.2 CZ42.2 CZ43.2 CZ44.2 CZ45.2 CZ46.2 CZ47.2 CZ48.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ57.2 CZ60.2 CZ61.2 CZ64.2 CZ65.2 CZ66.2 CZ67.2 CZ68.2 CZ69.2 CZ71.2 CZ72.2 CZ73.2 CZ74.2 CZ75.2 CZ76.2 CZ77.2 CZ78.2 CZ82.2 CZ84.2 CZ85.2 CZ87.2 CZ89.2 CZ90.2 CZ91.2 CZ92.2 CZ94.2 CZ95.2 CZ99.2 CZ100.2 CZ105.2 CZ106.2 CZ113.2 CZ114.2 CZ115.2 D20.1 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DE1.2 DI1.3 DI2.1 DI3.1 DI4.3 DI5.1 DI6.3 DV4.1 DV5.1 DV6.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H7.1(TP-1) H8.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H21.1(TP-1) H22.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JCRT1.5 JCRT1.6 JCRT1.7 JCRT1.8 JCRT1.10 JCRT1.16 JCRT1.17 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JDOCK1.163 JDOCK1.164 JEDP1.4 JEDP1.6 JEDP1.8 JEDP1.15 JEDP1.23 JEDP1.24 JEDP1.25 JEDP1.27 JEDP1.28 JEDP1.39 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JFAN1.1 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIR1.2 JIR1.3 JIR1.7 JIR1.8 JKBTP1.2 JKBTP1.3 JKBTP1.9 JKBTP1.15 JKBTP1.17 JKBTP1.20 JKBTP1.21 JKBTP1.22 JLED1.6 JLED1.9 JLED1.10 JLOM1.14 JLOM1.15 JLOM1.16 JLOM1.17 JLPDE1.9 JLPDE1.11 JLPDE1.12 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.19 JNGFF2.25 JNGFF2.31 JNGFF2.37 JNGFF2.43 JNGFF2.49 JNGFF2.63 JNGFF2.65 JNGFF2.68 JNGFF2.69 JNGFF3.1 JNGFF3.3 JNGFF3.9 JNGFF3.15 JNGFF3.21 JNGFF3.27 JNGFF3.33 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.63 JNGFF3.65 JNGFF3.67 JNGFF3.68 JNGFF3.69 JRTC1.2 JRTC1.3 JRTC1.4 JSATA1.1 JSATA1.4 JSATA1.7 JSATA1.12 JSATA1.14 JSATA1.18 JSATA1.21 JSATA1.22 JSATA1.23 JSATA1.24 JSD1.3 JSD1.6 JSD1.10 JSD1.13 JSD1.17 JSD1.20 JSD1.21 JSD1.22 JSD1.23 JSD1.24 JSD1.25 JSD1.26 JSIM1.5 JSIM1.10 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSPI1.1 JSPI1.2 JSPI1.3 JSPI1.21 JSPI1.22 JSPK1.5 JSPK1.6 JTAG1.2 JUART1.4 JUART1.5 JUART1.6 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSB3.4 JUSB3.7 JUSB3.10 JUSB3.11 JUSB3.12 JUSB3.13 JUSH1.2 JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.27 JUSH1.28 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC1.2 PC2.2 PC3.2 PC4.2 PC6.2 PC7.2 PC8.1 PC100.2 PC101.1 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC128.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.1 PC209.2 PC210.2 PC211.2 PC213.2 PC214.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC301.2 PC302.2 PC303.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC401.2 PC402.2 PC403.2 PC404.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC415.2 PC416.2 PC417.2 PC418.2 PC419.2 PC420.2 PC422.2 PC424.2 PC501.2 PC502.1 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC510.2 PC511.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.1 PC606.2 PC608.2 PC612.2 PC613.1 PC614.1 PC616.1 PC618.1 PC619.1 PC621.1 PC622.2 PC625.1 PC628.2 PC629.1 PC631.2 PC636.1 PC641.2 PC643.2 PC644.2 PC645.2 PC647.1 PC649.2 PC651.1 PC652.2 PC654.1 PC656.2 PC657.2 PC658.2 PC659.2 PC660.2 PC661.2 PC662.2 PC672.2 PC673.2 PC677.2 PC678.2 PC679.2 PC680.2 PC685.2 PC686.2 PC688.2 PC801.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.1 PC810.2 PC811.2 PC812.2 PC813.2 PC814.2 PC815.2 PC816.2 PC817.2 PC818.2 PC819.2 PC820.2 PC822.2 PC823.1 PC824.1 PC825.2 PC826.2 PC827.2 PC828.2 PC829.1 PC831.2 PC832.2 PC833.2 PC834.1 PC901.2 PC903.1 PC905.1 PC906.2 PC907.2 PC908.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1125.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1152.2 PC1153.2 PC1164.2 PC1170.2 PC1171.2 PC1172.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1500.2 PC1501.2 PC1503.2 PC1504.2 PD2.1 PD3.1 PD6.1 PD7.1 PH601.1 PH603.1 PJP6.2 PJPDC1.1 PJPDC1.2 PQ1.6 PQ4.3 PQ201.3 PQ201.4 PQ201.5 PQ501.5 PQ501.6 PQ501.7 PQ808.3 PQ808.4 PQ808.5 PQ809.3 PQ902.1 PQ902.4 PQ906.3 PQ907.1 PQ907.4 PQ908.3 PQ911.1 PQ911.4 PR10.1 PR12.2 PR13.2 PR15.2 PR103.2 PR110.2 PR116.2 PR118.2 PR209.2 PR302.2 PR310.2 PR311.2 PR403.2 PR407.2 PR412.2 PR415.2 PR416.2 PR419.2 PR420.2 PR424.2 PR427.1 PR428.2 PR505.2 PR506.2 PR509.2 PR510.2 PR608.2 PR611.2 PR613.1 PR629.1 PR631.1 PR647.1 PR651.2 PR662.2 PR680.2 PR813.2 PR817.2 PR822.1 PR829.2 PR831.1 PR837.2 PR908.1 PR925.2 PR929.2 PR934.2 PR1502.2 PR1503.2 PU1.2 PU100.7 PU100.8 PU100.18 PU100.21 PU101.3 PU102.7 PU102.8 PU102.18 PU102.21 PU201.1 PU201.3 PU201.14 PU201.21 PU301.9 PU401.6 PU401.15 PU401.16 PU401.17 PU402.6 PU402.15 PU402.16 PU402.17 PU501.2 PU502.1 PU602.41 PU603.3 PU603.9 PU605.3 PU605.9 PU606.4 PU606.9 PU801.22 PU801.29 PU901.5 PU901.14 PU901.23 PU901.32 PU901.37 PU902.3 PU903.3 PU1500.1 QA1.3 QA3.1 QA3.4 QE2.1 QE2.4 QN1.1 QN1.4 QV2.3 QV4.3 QV7.3 QV9.3 QV10.3 QV11.3 R268.2 R271.2 RA2.2 RA35.2 RA36.2 RA37.2 RC1.1 RC3.2 RC4.2 RC5.2 RC6.2 RC7.2 RC44.2 RC48.2 RC65.2 RC75.1 RC86.1 RC88.2 RC89.2 RC90.2 RC91.2 RC96.2 RC109.1 RC110.1 RC112.1 RC113.1 RC114.2 RC122.2 RC136.1 RC139.1 RC141.2 RC163.2 RC166.2 RC167.2 RC180.1 RC182.1 RC219.1 RC220.2 RC227.2 RC242.1 RC268.2 RC311.1 RC312.1 RC316.1 RC324.2 RC337.2 RC338.2 RC342.2 RD20.2 RD21.2 RD24.2 RD25.2 RD66.2 RD67.2 RD68.2 RD72.2 RD73.2 RD74.2 RE17.1 RE20.1 RE21.1 RE24.2 RE55.1 RE56.1 RE58.2 RE65.2 RE77.2 RE78.2 RE82.1 RE85.2 RE86.1 RE88.2 RE277.1 RE299.2 RE313.2 RH359.2 RI14.1 RL3.1 RL9.2 RL12.2 RL13.2 RN7.2 RN9.1 RN11.1 RN13.1 RN16.1 RN19.1 RN21.1 RN23.2 RN30.2 RN31.2 RN38.2 RN39.2 RN40.2 RN41.2 RN45.2 RN46.2 RN47.2 RN52.2 RN53.2 RN54.2 RN59.2 RN60.2 RN61.2 RN62.2 RN66.2 RN67.2 RN68.2 RN72.2 RN73.2 RN74.2 RN83.2 RPE10.5 RPE10.6 RPE10.7 RPE10.8 RR20.2 RV1.2 RV2.2 RV3.1 RV20.2 RV32.2 RV33.2 RV34.2 RV73.2 RV74.2 RV75.2 RV76.2 RV77.2 RV78.2 RV79.2 RV89.2 RV508.1 RV509.1 RV600.2 RV606.1 RV607.1 RV608.1 RV609.1 RV616.2 RV617.2 RV618.2 RV619.2 RV620.2 RV621.2 RV660.2 RZ10.1 RZ27.2 RZ38.1 RZ40.1 RZ62.2 RZ111.2 SW1.4 SW1.5 SW3.1 SW3.3 UA1.49 UC1.A5 UC1.A67 UC1.A70 UC1.AA2 UC1.AA4 UC1.AA65 UC1.AA68 UC1.AB8 UC1.AB15 UC1.AB16 UC1.AB18 UC1.AB21 UC1.AD8 UC1.AD13 UC1.AD16 UC1.AD19 UC1.AD20 UC1.AD21 UC1.AD62 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 UC1.AF1 UC1.AF2 UC1.AF4 UC1.AF10 UC1.AF15 UC1.AF17 UC1.AF63 UC1.AG16 UC1.AG17 UC1.AG18 UC1.AG19 UC1.AG20 UC1.AG21 UC1.AG71 UC1.AH6 UC1.AH13 UC1.AH63 UC1.AH64 UC1.AH67 UC1.AJ4 UC1.AJ15 UC1.AJ18 UC1.AJ20 UC1.AK8 UC1.AK11 UC1.AK16 UC1.AK18 UC1.AK21 UC1.AK22 UC1.AK27 UC1.AK63 UC1.AK68 UC1.AK69 UC1.AL2 UC1.AL4 UC1.AL28 UC1.AL32 UC1.AL35 UC1.AL38 UC1.AL45 UC1.AL48 UC1.AL52 UC1.AL55 UC1.AL58 UC1.AL64 UC1.AL65 UC1.AL66 UC1.AM8 UC1.AM13 UC1.AM21 UC1.AM25 UC1.AM27 UC1.AM43 UC1.AM45 UC1.AM46 UC1.AM55 UC1.AM60 UC1.AM61 UC1.AM68 UC1.AM71 UC1.AN20 UC1.AN23 UC1.AN28 UC1.AN30 UC1.AN32 UC1.AN33 UC1.AN35 UC1.AN37 UC1.AN38 UC1.AN40 UC1.AN42 UC1.AN58 UC1.AN63 UC1.AP10 UC1.AP18 UC1.AP20 UC1.AP23 UC1.AP28 UC1.AP32 UC1.AP35 UC1.AP38 UC1.AP42 UC1.AP58 UC1.AP63 UC1.AP68 UC1.AP70 UC1.AR5 UC1.AR8 UC1.AR11 UC1.AR15 UC1.AR16 UC1.AR20 UC1.AR23 UC1.AR28 UC1.AR35 UC1.AR42 UC1.AR43 UC1.AR45 UC1.AR46 UC1.AR48 UC1.AR50 UC1.AR52 UC1.AR53 UC1.AR55 UC1.AR58 UC1.AR63 UC1.AT2 UC1.AT4 UC1.AT20 UC1.AT23 UC1.AT28 UC1.AT35 UC1.AT42 UC1.AT56 UC1.AT58 UC1.AT63 UC1.AT68 UC1.AT71 UC1.AU10 UC1.AU15 UC1.AU20 UC1.AU32 UC1.AU38 UC1.AV1 UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 UC1.AW6 UC1.AW8 UC1.AW10 UC1.AW12 UC1.AW14 UC1.AW16 UC1.AW18 UC1.AW21 UC1.AW23 UC1.AW26 UC1.AW28 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51 UC1.AW53 UC1.AW55 UC1.AW57 UC1.AW60 UC1.AW62 UC1.AW64 UC1.AW66 UC1.AY3 UC1.AY66 UC1.AY71 UC1.B10 UC1.B14 UC1.B18 UC1.B22 UC1.B30 UC1.B34 UC1.B39 UC1.B44 UC1.B48 UC1.B53 UC1.B58 UC1.B62 UC1.B66 UC1.B71 UC1.BA1 UC1.BA2 UC1.BA6 UC1.BA10 UC1.BA14 UC1.BA18 UC1.BA23 UC1.BA28 UC1.BA32 UC1.BA36 UC1.BA41 UC1.BA45 UC1.BA49 UC1.BA53 UC1.BA57 UC1.BA62 UC1.BA66 UC1.BA71 UC1.BB6 UC1.BB18 UC1.BB26 UC1.BB30 UC1.BB34 UC1.BB38 UC1.BB43 UC1.BB55 UC1.BB60 UC1.BB64 UC1.BB67 UC1.BB70 UC1.C1 UC1.C5 UC1.C25 UC1.D6 UC1.D10 UC1.D11 UC1.D14 UC1.D18 UC1.D22 UC1.D25 UC1.D26 UC1.D30 UC1.D34 UC1.D39 UC1.D44 UC1.D45 UC1.D47 UC1.D48 UC1.D53 UC1.D58 UC1.D62 UC1.D66 UC1.D69 UC1.E6 UC1.E11 UC1.E15 UC1.E18 UC1.E21 UC1.E46 UC1.E50 UC1.E53 UC1.E56 UC1.E65 UC1.E71 UC1.F1 UC1.F2 UC1.F4 UC1.F8 UC1.F13 UC1.F22 UC1.F23 UC1.F27 UC1.F28 UC1.F32 UC1.F33 UC1.F35 UC1.F37 UC1.F38 UC1.F40 UC1.F42 UC1.F68 UC1.G5 UC1.G6 UC1.G10 UC1.G22 UC1.G43 UC1.G45 UC1.G48 UC1.G52 UC1.G55 UC1.G58 UC1.G60 UC1.G63 UC1.G66 UC1.H15 UC1.H18 UC1.H71 UC1.J8 UC1.J11 UC1.J13 UC1.J25 UC1.J28 UC1.J32 UC1.J35 UC1.J38 UC1.J42 UC1.K16 UC1.K18 UC1.K22 UC1.K61 UC1.K63 UC1.K64 UC1.K65 UC1.K66 UC1.K67 UC1.K68 UC1.K70 UC1.K71 UC1.L2 UC1.L4 UC1.L8 UC1.L11 UC1.L16 UC1.L17 UC1.L18 UC1.L20 UC1.N6 UC1.N10 UC1.N13 UC1.N19 UC1.N21 UC1.N65 UC1.N68 UC1.P17 UC1.P19 UC1.P20 UC1.P21 UC1.R6 UC1.R13 UC1.T2 UC1.T4 UC1.T15 UC1.T17 UC1.T18 UC1.T21 UC1.U10 UC1.U63 UC1.U64 UC1.U66 UC1.U67 UC1.U69 UC1.U70 UC1.V16 UC1.V17 UC1.V18 UC1.W6 UC1.W9 UC1.W13 UC1.Y17 UC1.Y19 UC1.Y20 UC1.Y21 UC5.4 UC6.4 UC7.3 UC8.7 UC8.15 UC12.3 UC13.3 UC14.3 UD1.3 UE1.B27 UE1.C1 UE2.B11 UE2.B18 UE2.B54 UE2.B60 UE2.B66 UE2.C1 UE3.3 UE4.3 UE5.3 UI1.2 UI2.2 UI3.14 UI3.17 UL1.49 UL2.3 UL4.43 UN1.5 UN1.6 UN1.7 UN1.8 UN4.7 UN4.25 UN5.7 UN5.25 UN7.3 UN7.21 UR2.33 UV2.2 UV4.2 UV8.C5 UV8.C13 UV8.C14 UV8.D4 UV8.D5 UV8.D6 UV8.D7 UV8.D8 UV8.D9 UV8.D10 UV8.D11 UV8.D13 UV8.D14 UV8.E4 UV8.E11 UV8.F4 UV8.F5 UV8.F6 UV8.F7 UV8.F8 UV8.F9 UV8.F10 UV8.F11 UV8.G4 UV8.G5 UV8.G6 UV8.G7 UV8.G8 UV8.G9 UV8.G10 UV8.G11 UV8.H4 UV8.H10 UV8.J5 UV8.J6 UV8.J7 UV8.J8 UV8.J9 UV8.J11 UV8.J12 UV8.K5 UV8.L6 UV8.L7 UV8.L8 UV9.4 UV11.7 UV12.7 UV16.3 UV16.11 UV16.28 UV16.31 UV16.33 UV24.2 UV26.11 UV26.19 UV26.52 UV26.61 UV28.5 UV29.11 UZ2.11 UZ2.15 UZ3.11 UZ3.15 UZ4.11 UZ4.15 UZ5.11 UZ5.15 UZ6.3 UZ8.5 UZ8.9 UZ10.3 UZ12.9 UZ12.16 UZ12.23 UZ12.32 UZ12.33 UZ19.5 UZ20.5 UZ21.5 UZ23.5 UZ23.9 UZ26.5 YL1.2 YL1.4 YV2.2 YV2.4
GNDA: CA1.2 CA2.2 CA3.2 CA4.2 CA8.2 CA9.2 CA16.2 CA17.2 CA18.2 CA25.2 CA26.2 CA35.1 CA51.2 CA52.2 JHP1.7 PJP6.1 QA2.1 QA2.4 RA35.1 RA36.1 RA37.1 RA44.2 UA1.26 UA1.37
VCC_GT_SENSE: PC617.1 PC618.2 PC620.1 PR622.1 RC161.2 UC1.J70
VCCIO_SENSE: PR422.1 RC165.2 UC1.AM23
VCCSA_B+: PC608.1 PC612.1 PJP603.1 PQ501.2 PQ501.3 PQ501.4 PQ501.10
VCCSENSE: PC639.1 PC651.2 PC653.1 PR648.1 RC140.2 UC1.E32
VCCST_PWRGD: CC301.1 RC71.2 RC78.1 RC123.1 RE308.1 UE4.4
VCCST_PWRGD_CPU: RC78.2 UC1.B65
VCCST_PWRGD_EC: RE308.2 UE2.A44
VDD_1.2V: PC209.1 PR203.1 PR205.2 PU201.11
VIN_1.8VALW: PC502.2 PJP501.2 PU501.4
VIN_1V_PRIM: PC412.1 PC413.1 PC417.1 PC418.1 PJP404.2 PU402.10 PU402.11 PU402.12
VIN_1VS_VCCIO: PC403.1 PC404.1 PC408.1 PC409.1 PJP403.2 PU401.10 PU401.11 PU401.12
VSS_GT_SENSE: PC619.2 PC620.2 PU602.6 RC163.1 UC1.J69
VSSIO_SENSE: PR412.1 RC167.1 UC1.AM22
VSSSENSE: PC653.2 PC654.2 PU602.18 RC141.1 UC1.E33
3301_ACAV_IN_NB: PR922.1 PU901.24
3301_PWRSRC: PR939.1 PU901.15
+BL_PWR_SRC: CV7.1 CV12.1 JEDP1.17 JEDP1.18 JEDP1.19 QV1.1 QV1.2 QV1.5 QV1.6
+CAP_LDO: CE7.1 UE1.B46
+COINCELL: JRTC1.1 PC8.2 PR2.1
+CRT_VCC: CV50.1 JCRT1.9 RV35.1 RV36.1 RV37.1 RV38.1 UV4.3
+DC_IN: PC5.2 PC6.1 PL1.2 PQ1.3 PQ5.1 PQ5.2 PQ5.3 PR1.1 PR13.1 PR830.1 PR921.1
+DC_IN_SS: PC7.1 PD801.2 PD905.3 PQ5.5 PQ802.5 PQ802.6 PQ802.7 PQ802.8 PR12.1 PR935.1
+DCIN: PC814.1 PR811.2 PU801.28
+DCIN_JACK: PC1.1 PJPDC1.3 PJPDC1.4 PL1.1
+DCPRTC: CC214.1 UC1.BB10
+DDR_VREF_A_CA: JDIMM1.164 RD18.2 RD19.1 RD20.1
+DDR_VREF_A_DQ: T132.1(TP-1) UC1.AY68
+DDR_VREF_B_CA: JDIMM2.164 RD22.2 RD24.1 RD75.1
+DDR_VREF_B_DQ: CD54.1 RD75.2 UC1.BA67
+DDR_VREF_CA: CD36.1 RD19.2 UC1.AY67
+DOCK_PWR_BAR: C33.1 C317.1 C318.1 D20.2 D20.3 JDOCK1.146 JDOCK1.147 JDOCK1.148 JDOCK1.149 JDOCK1.150 JDOCK1.151 PD802.2 PD903.2 PD903.3 PQ904.5 PQ904.6 PQ904.7 PQ904.8 PQ905.5 PR908.2 PR924.2
+EDP_VDD: PJP29.2 UV24.1
+LCDVDD: CV8.1 CV9.1 JEDP1.30 JEDP1.31 PJP29.1
+LOM_VCT: C316.1 JDOCK1.116 JDOCK1.118
+MIC1_VREF_OUT: DA4.2 DA5.2 UA1.30
+NBDOCK_DC_IN_SS: JDOCK1.41 PD905.2 PR927.2
+PBATT: PD803.2 PD902.2 PD902.3 PL2.2 PL3.2 PQ901.5 PQ901.6 PQ901.7 PQ901.8 PQ903.5 PQ903.6 PQ903.7 PQ903.8 PR826.2 PR933.2
+PECI_VREF: CE25.1 RE59.1 UE2.B51
+PWR_SRC: CV11.1 JIR1.5 JIR1.6 PC803.1 PC804.1 PC805.1 PC806.1 PC807.1 PC811.1 PC812.1 PJP100.1 PJP101.1 PJP202.1 PJP301.1 PJP601.2 PL602.2 PL801.1 PR102.2 PR823.4 QV1.4 RV4.1 RZ85.1
+PWR_SRC_AC: PC902.1 PD903.1 PJP801.1 PL802.2 PQ904.1 PQ904.2 PQ904.3 PR802.1 PR939.2
+PWR_SRC_R: JUSH1.26 RZ85.2
+REGCTL_PNP10: LL1.1 UL1.7
+RREF: RR20.1 UR2.9
+RSVD_VCC3P3_1: RL6.2 UL1.1
+RTC_CELL: CC213.1 CC270.1 PC2.1 PD1.1 RA21.1 RC56.2 RC57.2 RC69.2 RE31.1 RE32.1 RE62.1 RPE5.5 RPE5.6 UC1.AK19 UC1.BB14
+RTC_CELL_VBAT: CE11.1 RE32.2 UE2.B64
+SDC_IN: PC802.1 PQ802.1 PQ802.2 PQ802.3 PR802.4 PR812.2 PR928.1 PU801.3
+SDREG2: CR35.1 UR2.24
+SIM_PWR: C263.1 JNGFF2.28 JSIM1.1
+USB_LEFT_PWR: CI1.1 CI3.1 JUSB1.1 UI1.1
+USB_REAR_PWR: CI8.1 CI10.1 JUSB2.1 UI2.1
+UZ12_TPM: CZ73.1 RZ88.2 RZ89.2 UZ12.8
+V_DDR_REF: PC210.1 PU201.4
+VCHGR: PC801.1 PC825.1 PC826.1 PC827.1 PD902.1 PQ903.1 PQ903.2 PQ903.3 PR823.1
+VHDMI_VCC: CV26.1 CV27.1 JHDMI1.18 RV18.2 RV21.2 UV2.3
+VLDOIN_1.2V: PJP203.1 PU201.19
+VR_CAP: CE31.1 UE2.B12
+VREFOUT: CA26.1 RA5.2 RA6.2 UA1.23
+Z4012: PD1.2 PR2.2
/BATPRES: PR828.2 PR904.2 PU801.15
A_ON: RPE10.3 UE2.A4 UZ8.3
AC_DIS: PQ1.5 PQ809.2 PR837.1 PR916.1 RE83.2 UE1.A50
AC_PRESENT: RC243.1 UC1.AY15 UE2.A54
ACAV_DOCK_SRC#: JDOCK1.42 PR920.2 PR923.1
ACAV_IN: PQ809.1 PQ907.5 PR801.2 PR815.1 PR817.1 PR918.1 UE2.A64
ACAV_IN#: PQ907.3 PR914.2 PU903.2
ACAV_IN_NB: PR833.1 PR922.2 UE2.B20
ACAVDK_SRC: PR923.2 PU901.4
ACAVIN: PR918.2 PU901.8
ADJ: RV659.2 RV660.1 UV29.2
ALW_PWRGD_3V_5V: PR101.2 PR119.2 PR120.2 UZ6.2
ALWON: PR114.1 UE2.A60
AR_SMBUS_ALERT#: RE309.2 UE1.A58
AUD_HP_NB_SENSE: CA41.1 DA2.3 JHP1.6 QA1.2 RA2.1 UE1.A41
AUD_HP_OUT_L: CA43.2 LA2.1 RA7.2 RA24.1
AUD_HP_OUT_L1: CA3.1 DA1.3 JHP1.1 LA2.2
AUD_HP_OUT_R: CA44.2 LA3.1 RA8.2 RA25.1
AUD_HP_OUT_R1: CA2.1 DA1.2 JHP1.2 LA3.2
AUD_NB_MUTE#: CA31.1 QA2.2 RA18.2 UA1.48 UE1.A39
AUD_OUT_L: RA7.1 UA1.33
AUD_OUT_R: RA8.1 UA1.32
AUD_PC_BEEP: CA27.2 CA28.2 UA1.12
AUD_PWR_EN: RC279.2 UC1.BA7 UZ5.3 UZ5.5
AUD_SENSE_A: QA1.1 UA1.13
AUD_SENSE_B: RA27.1 RA28.1 RA38.1 UA1.14
AUX_EN_WOWL: RZ38.2 RZ70.1 UE1.B67
BAT1_LED#: RZ28.1 UE2.B1
BAT2_LED#: RZ25.1 UE2.A55
BATDRV#: PQ903.4 PR825.2
BATT_WHITE#: JLED1.5 RZ25.2
BATT_YELLOW#: JLED1.4 RZ28.2
BC_CLK_ECE1117: JKBTP1.10 UE2.A20
BC_CLK_ECE5048: UE1.A30 UE2.A43
BC_DAT_ECE1117: JKBTP1.8 RPE5.2 UE2.B21
BC_DAT_ECE5048: RE36.2 UE1.B31 UE2.B45
BC_INT#_ECE1117: JKBTP1.7 UE2.A19
BC_INT#_ECE5048: UE1.A29 UE2.A42
BCM5882_ALERT#: JUSH1.14 UE1.B62
BEEP: RA13.2 UE2.B19
BIA_PWM: DV1.1 LV1.2 RV1.1
BIA_PWM_EC: DV1.2 UE2.B25
BL_PWR_SRC_ON: CV11.2 CV374.1 QV1.3 RV4.2 RV5.1
BOARD_ID: CE40.1 RE79.2 UE2.B10
BOOT_1.2V: PR202.2 PU201.18
BQ24770_REGN: PC813.1 PR801.1 PR821.2 PR827.1 PU801.24
BREATH_LED#: JDOCK1.98 QZ7.4 RZ34.1 UE2.B57
BREATH_LED#_Q: QZ7.3 RZ32.1
BREATH_WHITE_LED#: JLED1.2 RZ34.2
BREATH_WHITE_LED_SNIFF#: LED3.1 RZ32.2
BST_3V: PR100.1 PU100.1
BST_5V: PR111.1 PU102.1
BST_+1VALWP: PC304.1 PU301.6
BST_+1VALWP_C: PC304.2 PR304.1
BT_RADIO_DIS#: DZ2.1 RE11.2 UE1.A13
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.46
CAM_MIC_CBL_DET#: JEDP1.14 RPC5.7 UC1.AB11
CD3301_DCIN: PC906.1 PR921.2 PU901.1
CD3301_SDC_IN: PR928.2 PU901.6
CD_PBATT_OFF: PR930.1 PU901.26
CFG0: JXDP1.9 RC113.2 RC126.1 UC1.E68
CFG1: JXDP1.11 RC112.2 UC1.B67
CFG2: JXDP1.15 UC1.D65
CFG3: JXDP1.17 RC110.2 RC121.2 UC1.D67
CFG4: JXDP1.27 RC109.2 UC1.E70
CFG5: JXDP1.29 UC1.C68
CFG6: JXDP1.33 UC1.D68
CFG7: JXDP1.35 UC1.C67
CFG8: JXDP1.10 UC1.F71
CFG9: JXDP1.12 UC1.G69
CFG10: JXDP1.16 UC1.F70
CFG11: JXDP1.18 UC1.G68
CFG12: JXDP1.28 UC1.H70
CFG13: JXDP1.30 UC1.G71
CFG14: JXDP1.34 UC1.H69
CFG15: JXDP1.36 UC1.G70
CFG16: JXDP1.6 UC1.E63
CFG17: JXDP1.4 UC1.F63
CFG18: JXDP1.24 UC1.E66
CFG19: JXDP1.22 UC1.F66
CFG_RCOMP: RC114.1 UC1.E60
CHAGER_SRC: PC816.1 PC817.1 PC818.1 PC819.1 PC820.1 PC822.1 PJP801.2 PL802.1 PQ808.2
CHARGER_SMBCLK: PR835.1 RPE3.1 UE2.B50
CHARGER_SMBDAT: PR836.1 RPE3.2 UE2.A47
CHG_LGATE: PQ808.6 PU801.23
CHG_SNUB: PC832.1 PR824.1
CHG_SW: PC821.1 PL801.2 PQ808.7 PR824.2 PU801.27
CHG_UGATE: PQ808.1 PU801.26
CLK_27M_IN: CV115.1 RV80.1 UV8.K1 YV2.1
CLK_27M_OUT: RV80.2 RV81.2 UV8.L1
CLK_27M_OUT_R: CV113.1 RV81.1 YV2.3
CLK_ITPXDP_N: RC297.1 UC1.F43
CLK_ITPXDP_N_R: JXDP1.42 RC297.2
CLK_ITPXDP_P: RC298.1 UC1.E43
CLK_ITPXDP_P_R: JXDP1.40 RC298.2
CLK_KBD: JDOCK1.78 RPE2.8 UE2.A38
CLK_MSE: JDOCK1.71 RPE2.6 UE2.A39
CLK_PCI_5048: CC3.2 RC16.2 RE27.1 UE1.A28
CLK_PCI_DOCK: CC6.2 JDOCK1.121 R273.1 RC24.2
CLK_PCI_LPDEBUG: CC5.2 JLPDE1.10 RC22.2
CLK_PCI_MEC: CC4.2 RC18.2 RE66.1 UE2.A29
CLK_PCIE_N0: JNGFF2.45 UC1.D42
CLK_PCIE_N1: JNGFF1.41 UC1.B42
CLK_PCIE_N2: JNGFF1.65 UC1.D41
CLK_PCIE_N3: JNGFF3.53 UC1.D40
CLK_PCIE_N4: UC1.B40 UL1.45
CLK_PCIE_N5: UC1.E40 UR2.6
CLK_PCIE_P0: JNGFF2.47 UC1.C42
CLK_PCIE_P1: JNGFF1.39 UC1.A42
CLK_PCIE_P2: JNGFF1.63 UC1.C41
CLK_PCIE_P3: JNGFF3.55 UC1.C40
CLK_PCIE_P4: UC1.A40 UL1.44
CLK_PCIE_P5: UC1.E38 UR2.5
CLK_TP_SIO: CZ31.1 RZ19.2 RZ23.2 UE2.A37
CLK_TP_SIO_R: JKBTP1.14 RZ23.1
CLKDET#: T121.1(TP-1) UC1.AY8
CLKREQ_PCIE#0: JNGFF2.44 RC189.2 UC1.AR10
CLKREQ_PCIE#1: JNGFF1.45 RC47.2 UC1.AT7
CLKREQ_PCIE#2: JNGFF1.60 RC50.2 UC1.AT8
CLKREQ_PCIE#3: JNGFF3.52 RC59.2 UC1.AT10
CLKREQ_PCIE#4: RC51.2 RL4.1 UC1.AU8 UL1.48
CLKREQ_PCIE#5: RC190.2 UC1.AU7 UR2.2
CLKRUN#: RC27.1 UC1.AW11 UE1.B20 UE2.A32
CMPIN: PC833.1 PR830.2 PR831.2 PR832.1 PU801.13
CMPOUT: PC834.2 PR832.2 PR833.2 PR834.1 PU801.14
COMP_IA: PC636.2 PR639.2 PU602.16
COMP_VSA: PC628.1 PR630.1 PU602.24
CONTACTLESS_DET#: JUSH1.4 RPC5.8 UC1.W11
CORE_SNUB: PC662.1 PR663.2
CORE_SW: PL603.4 PR663.1 PU603.4
CORE_VID0: PR408.1 UC1.AN11
CORE_VID1: PR411.1 UC1.AN13
CPU_B+: PC606.1 PC656.1 PC657.1 PC658.1 PC659.1 PC660.1 PC680.1 PC686.1 PJP601.1 PJP602.2 PJP603.2 PL602.1 PR603.2 PU603.5
CPU_DP1_AUXN: RC179.2 UC1.G50
CPU_DP1_AUXP: RC180.2 UC1.F50
CPU_DP1_CTRL_CLK: QV3.1 RC175.1 UC1.L13
CPU_DP1_CTRL_DATA: QV3.4 RC178.1 UC1.L12
CPU_DP1_HPD: QV5.3 RC312.2 RV22.1 UC1.L9
CPU_DP1_N0: CV18.2 UC1.E55
CPU_DP1_N1: CV22.2 UC1.E58
CPU_DP1_N2: CV29.2 UC1.F53
CPU_DP1_N3: CV14.2 UC1.F56
CPU_DP1_P0: CV17.2 UC1.F55
CPU_DP1_P1: CV21.2 UC1.F58
CPU_DP1_P2: CV28.2 UC1.G53
CPU_DP1_P3: CV13.2 UC1.G56
CPU_DP2_AUXN: CV80.1 RC181.2 UC1.E48
CPU_DP2_AUXN_C: CV80.2 UV26.25
CPU_DP2_AUXP: CV79.1 RC182.2 UC1.F48
CPU_DP2_AUXP_C: CV79.2 UV26.24
CPU_DP2_CTRL_CLK: RC176.1 UC1.N7 UV26.22
CPU_DP2_CTRL_DATA: RC177.1 UC1.N8 UV26.23
CPU_DP2_HPD: RC242.2 UC1.L7 UV26.3
CPU_DP2_N0: CV607.1 UC1.C50
CPU_DP2_N0_C: CV607.2 UV26.7
CPU_DP2_N1: CV609.1 UC1.C52
CPU_DP2_N1_C: CV609.2 UV26.10
CPU_DP2_N2: CV611.1 UC1.A50
CPU_DP2_N2_C: CV611.2 UV26.13
CPU_DP2_N3: CV613.1 UC1.D51
CPU_DP2_N3_C: CV613.2 UV26.16
CPU_DP2_P0: CV606.1 UC1.D50
CPU_DP2_P0_C: CV606.2 UV26.6
CPU_DP2_P1: CV608.1 UC1.D52
CPU_DP2_P1_C: CV608.2 UV26.9
CPU_DP2_P2: CV610.1 UC1.B50
CPU_DP2_P2_C: CV610.2 UV26.12
CPU_DP2_P3: CV612.1 UC1.C51
CPU_DP2_P3_C: CV612.2 UV26.15
CPU_DP3_AUXN: T1.1(TP-1) UC1.G46
CPU_DP3_AUXP: T2.1(TP-1) UC1.F46
CPU_ID: RE298.1 RE299.1 UE1.B60
CPU_POPIRCOMP: RC88.1 UC1.AT16
CPU_XDP_PRDY#: JXDP1.5 UC1.D56
CPU_XDP_PREQ#: JXDP1.3 RC138.2 UC1.D61
CPU_XDP_TCLK: JXDP1.57 RC139.2 RC328.1 UC1.B61
CPU_XDP_TDI: RC134.2 UC1.D60 UC8.6
CPU_XDP_TDO: RC135.2 UC1.A61 UC8.3
CPU_XDP_TMS: RC131.2 UC1.C60 UC8.8
CPU_XDP_TRST#: RC136.2 UC1.B59 UC1.C61 UC8.11
CS_1.2V: PR203.2 PU201.13
CSI2_COMP: RC3.1 UC1.E13
CSS_GC: PR804.1 PU901.10
CSSN_1: PQ803.3 PQ805.3 PR805.1 PR807.1 PR809.1
CSSP_1: PQ801.3 PQ804.3 PR805.2 PR806.1 PR808.1
CV2_ON: JUSH1.24 RPE10.1 UE2.A9
D_CLKRUN#: JDOCK1.111 RPE8.4 UE1.A19
D_DLDRQ1#: JDOCK1.117 RPE8.2 UE1.B24
D_LAD0: JDOCK1.97 UE1.B29
D_LAD1: JDOCK1.99 UE1.B28
D_LAD2: JDOCK1.103 UE1.A25
D_LAD3: JDOCK1.105 UE1.A24
D_LFRAME#: JDOCK1.109 UE1.B23
D_SERIRQ: JDOCK1.115 RPE8.3 UE1.A20
DAI_12MHZ#: JDOCK1.89 R41.1 RA30.1
DAI_BCLK#: JDOCK1.77 R6.1 RA31.1
DAI_DI: JDOCK1.83 UA1.24
DAI_DO#: JDOCK1.85 RA32.1
DAI_LRCK#: JDOCK1.79 UA1.18
DAT_KBD: JDOCK1.80 RPE2.7 UE2.B41
DAT_MSE: JDOCK1.73 RPE2.5 UE2.B42
DAT_TP_SIO: CZ30.1 RZ18.2 RZ22.2 UE2.B40
DAT_TP_SIO_R: JKBTP1.13 RZ22.1
DC_BLOCK_GC: PR803.2 PU901.7
DC_IN_SS: PR935.2 PU901.34
DDR_A_ACT#: JDIMM1.114 UC1.BA55
DDR_A_ALERT#: JDIMM1.116 UC1.AW50
DDR_A_BA0: JDIMM1.150 UC1.AU52
DDR_A_BA1: JDIMM1.145 UC1.AT48
DDR_A_BG0: JDIMM1.115 UC1.AY55
DDR_A_BG1: JDIMM1.113 UC1.AY54
DDR_A_CKE0: JDIMM1.109 UC1.BA56
DDR_A_CKE1: JDIMM1.110 UC1.BB56
DDR_A_CKE2: T3.1(TP-1) UC1.AW56
DDR_A_CKE3: T4.1(TP-1) UC1.AY56
DDR_A_CLK0: JDIMM1.137 UC1.AT53
DDR_A_CLK1: JDIMM1.138 UC1.AT55
DDR_A_CLK#0: JDIMM1.139 UC1.AU53
DDR_A_CLK#1: JDIMM1.140 UC1.AU55
DDR_A_CS#0: JDIMM1.149 UC1.AU45
DDR_A_CS#1: JDIMM1.157 UC1.AU43
DDR_A_D0: JDIMM1.7 UC1.AL71
DDR_A_D1: JDIMM1.3 UC1.AL68
DDR_A_D2: JDIMM1.21 UC1.AN68
DDR_A_D3: JDIMM1.16 UC1.AN69
DDR_A_D4: JDIMM1.4 UC1.AL70
DDR_A_D5: JDIMM1.8 UC1.AL69
DDR_A_D6: JDIMM1.17 UC1.AN70
DDR_A_D7: JDIMM1.20 UC1.AN71
DDR_A_D8: JDIMM1.28 UC1.AR70
DDR_A_D9: JDIMM1.24 UC1.AR68
DDR_A_D10: JDIMM1.38 UC1.AU71
DDR_A_D11: JDIMM1.42 UC1.AU68
DDR_A_D12: JDIMM1.29 UC1.AR71
DDR_A_D13: JDIMM1.25 UC1.AR69
DDR_A_D14: JDIMM1.41 UC1.AU70
DDR_A_D15: JDIMM1.37 UC1.AU69
DDR_A_D16: JDIMM1.194 UC1.AF65
DDR_A_D17: JDIMM1.195 UC1.AF64
DDR_A_D18: JDIMM1.204 UC1.AK65
DDR_A_D19: JDIMM1.203 UC1.AK64
DDR_A_D20: JDIMM1.190 UC1.AF66
DDR_A_D21: JDIMM1.191 UC1.AF67
DDR_A_D22: JDIMM1.207 UC1.AK67
DDR_A_D23: JDIMM1.208 UC1.AK66
DDR_A_D24: JDIMM1.186 UC1.AF70
DDR_A_D25: JDIMM1.174 UC1.AF68
DDR_A_D26: JDIMM1.173 UC1.AH71
DDR_A_D27: JDIMM1.183 UC1.AH68
DDR_A_D28: JDIMM1.182 UC1.AF71
DDR_A_D29: JDIMM1.187 UC1.AF69
DDR_A_D30: JDIMM1.169 UC1.AH70
DDR_A_D31: JDIMM1.170 UC1.AH69
DDR_A_D32: JDIMM1.46 UC1.BB65
DDR_A_D33: JDIMM1.62 UC1.AW65
DDR_A_D34: JDIMM1.63 UC1.AW63
DDR_A_D35: JDIMM1.45 UC1.AY63
DDR_A_D36: JDIMM1.50 UC1.BA65
DDR_A_D37: JDIMM1.49 UC1.AY65
DDR_A_D38: JDIMM1.59 UC1.BA63
DDR_A_D39: JDIMM1.58 UC1.BB63
DDR_A_D40: JDIMM1.66 UC1.BA61
DDR_A_D41: JDIMM1.70 UC1.AW61
DDR_A_D42: JDIMM1.79 UC1.BB59
DDR_A_D43: JDIMM1.84 UC1.AW59
DDR_A_D44: JDIMM1.67 UC1.BB61
DDR_A_D45: JDIMM1.71 UC1.AY61
DDR_A_D46: JDIMM1.83 UC1.BA59
DDR_A_D47: JDIMM1.80 UC1.AY59
DDR_A_D48: JDIMM1.211 UC1.AT66
DDR_A_D49: JDIMM1.215 UC1.AU66
DDR_A_D50: JDIMM1.225 UC1.AP65
DDR_A_D51: JDIMM1.229 UC1.AN65
DDR_A_D52: JDIMM1.216 UC1.AN66
DDR_A_D53: JDIMM1.212 UC1.AP66
DDR_A_D54: JDIMM1.224 UC1.AT65
DDR_A_D55: JDIMM1.228 UC1.AU65
DDR_A_D56: JDIMM1.233 UC1.AT61
DDR_A_D57: JDIMM1.237 UC1.AU61
DDR_A_D58: JDIMM1.246 UC1.AP60
DDR_A_D59: JDIMM1.250 UC1.AN60
DDR_A_D60: JDIMM1.236 UC1.AN61
DDR_A_D61: JDIMM1.232 UC1.AP61
DDR_A_D62: JDIMM1.249 UC1.AT60
DDR_A_D63: JDIMM1.245 UC1.AU60
DDR_A_DQS0: JDIMM1.13 UC1.AM69
DDR_A_DQS1: JDIMM1.34 UC1.AT70
DDR_A_DQS2: JDIMM1.200 UC1.AH65
DDR_A_DQS3: JDIMM1.179 UC1.AG70
DDR_A_DQS4: JDIMM1.55 UC1.AY64
DDR_A_DQS5: JDIMM1.76 UC1.BA60
DDR_A_DQS6: JDIMM1.221 UC1.AR65
DDR_A_DQS7: JDIMM1.242 UC1.AR60
DDR_A_DQS#0: JDIMM1.11 UC1.AM70
DDR_A_DQS#1: JDIMM1.32 UC1.AT69
DDR_A_DQS#2: JDIMM1.198 UC1.AH66
DDR_A_DQS#3: JDIMM1.177 UC1.AG69
DDR_A_DQS#4: JDIMM1.53 UC1.BA64
DDR_A_DQS#5: JDIMM1.74 UC1.AY60
DDR_A_DQS#6: JDIMM1.219 UC1.AR66
DDR_A_DQS#7: JDIMM1.240 UC1.AR61
DDR_A_MA0: JDIMM1.144 UC1.AY50
DDR_A_MA1: JDIMM1.133 UC1.BB50
DDR_A_MA2: JDIMM1.132 UC1.AY51
DDR_A_MA3: JDIMM1.131 UC1.BA50
DDR_A_MA4: JDIMM1.128 UC1.BB52
DDR_A_MA5: JDIMM1.126 UC1.BA51
DDR_A_MA6: JDIMM1.127 UC1.BA52
DDR_A_MA7: JDIMM1.122 UC1.AW52
DDR_A_MA8: JDIMM1.125 UC1.AY52
DDR_A_MA9: JDIMM1.121 UC1.BB54
DDR_A_MA10: JDIMM1.146 UC1.AT50
DDR_A_MA11: JDIMM1.120 UC1.BA54
DDR_A_MA12: JDIMM1.119 UC1.AW54
DDR_A_MA13: JDIMM1.158 UC1.AU46
DDR_A_MA14: JDIMM1.151 UC1.AT46
DDR_A_MA15: JDIMM1.156 UC1.AU48
DDR_A_MA16: JDIMM1.152 UC1.AU50
DDR_A_ODT0: JDIMM1.155 UC1.AT45
DDR_A_ODT1: JDIMM1.161 UC1.AT43
DDR_A_PARITY: JDIMM1.143 UC1.AT52
DDR_B_ACT#: JDIMM2.114 UC1.AN53
DDR_B_ALERT#: JDIMM2.116 UC1.AN43
DDR_B_BA0: JDIMM2.150 UC1.BB44
DDR_B_BA1: JDIMM2.145 UC1.BA44
DDR_B_BG0: JDIMM2.115 UC1.AP52
DDR_B_BG1: JDIMM2.113 UC1.AN52
DDR_B_CKE0: JDIMM2.109 UC1.AN56
DDR_B_CKE1: JDIMM2.110 UC1.AP55
DDR_B_CKE2: T5.1(TP-1) UC1.AN55
DDR_B_CKE3: T6.1(TP-1) UC1.AP53
DDR_B_CLK0: JDIMM2.137 UC1.AP45
DDR_B_CLK1: JDIMM2.138 UC1.AP46
DDR_B_CLK#0: JDIMM2.139 UC1.AN45
DDR_B_CLK#1: JDIMM2.140 UC1.AN46
DDR_B_CS#0: JDIMM2.149 UC1.BB42
DDR_B_CS#1: JDIMM2.157 UC1.AY42
DDR_B_D0: JDIMM2.8 UC1.AY39
DDR_B_D1: JDIMM2.3 UC1.AW39
DDR_B_D2: JDIMM2.16 UC1.AY37
DDR_B_D3: JDIMM2.20 UC1.AW37
DDR_B_D4: JDIMM2.7 UC1.BB39
DDR_B_D5: JDIMM2.4 UC1.BA39
DDR_B_D6: JDIMM2.21 UC1.BA37
DDR_B_D7: JDIMM2.17 UC1.BB37
DDR_B_D8: JDIMM2.28 UC1.AY35
DDR_B_D9: JDIMM2.24 UC1.AW35
DDR_B_D10: JDIMM2.42 UC1.AY33
DDR_B_D11: JDIMM2.38 UC1.AW33
DDR_B_D12: JDIMM2.29 UC1.BB35
DDR_B_D13: JDIMM2.25 UC1.BA35
DDR_B_D14: JDIMM2.37 UC1.BA33
DDR_B_D15: JDIMM2.41 UC1.BB33
DDR_B_D16: JDIMM2.170 UC1.AU40
DDR_B_D17: JDIMM2.174 UC1.AT40
DDR_B_D18: JDIMM2.182 UC1.AT37
DDR_B_D19: JDIMM2.186 UC1.AU37
DDR_B_D20: JDIMM2.173 UC1.AR40
DDR_B_D21: JDIMM2.169 UC1.AP40
DDR_B_D22: JDIMM2.187 UC1.AP37
DDR_B_D23: JDIMM2.183 UC1.AR37
DDR_B_D24: JDIMM2.191 UC1.AT33
DDR_B_D25: JDIMM2.195 UC1.AU33
DDR_B_D26: JDIMM2.203 UC1.AU30
DDR_B_D27: JDIMM2.207 UC1.AT30
DDR_B_D28: JDIMM2.190 UC1.AR33
DDR_B_D29: JDIMM2.194 UC1.AP33
DDR_B_D30: JDIMM2.208 UC1.AR30
DDR_B_D31: JDIMM2.204 UC1.AP30
DDR_B_D32: JDIMM2.50 UC1.AY31
DDR_B_D33: JDIMM2.45 UC1.AW31
DDR_B_D34: JDIMM2.58 UC1.AY29
DDR_B_D35: JDIMM2.62 UC1.AW29
DDR_B_D36: JDIMM2.49 UC1.BB31
DDR_B_D37: JDIMM2.46 UC1.BA31
DDR_B_D38: JDIMM2.63 UC1.BA29
DDR_B_D39: JDIMM2.59 UC1.BB29
DDR_B_D40: JDIMM2.66 UC1.AY27
DDR_B_D41: JDIMM2.70 UC1.AW27
DDR_B_D42: JDIMM2.67 UC1.AY25
DDR_B_D43: JDIMM2.71 UC1.AW25
DDR_B_D44: JDIMM2.79 UC1.BB27
DDR_B_D45: JDIMM2.83 UC1.BA27
DDR_B_D46: JDIMM2.80 UC1.BA25
DDR_B_D47: JDIMM2.84 UC1.BB25
DDR_B_D48: JDIMM2.216 UC1.AU27
DDR_B_D49: JDIMM2.215 UC1.AT27
DDR_B_D50: JDIMM2.224 UC1.AT25
DDR_B_D51: JDIMM2.228 UC1.AU25
DDR_B_D52: JDIMM2.211 UC1.AP27
DDR_B_D53: JDIMM2.212 UC1.AN27
DDR_B_D54: JDIMM2.229 UC1.AN25
DDR_B_D55: JDIMM2.225 UC1.AP25
DDR_B_D56: JDIMM2.233 UC1.AT22
DDR_B_D57: JDIMM2.237 UC1.AU22
DDR_B_D58: JDIMM2.245 UC1.AU21
DDR_B_D59: JDIMM2.249 UC1.AT21
DDR_B_D60: JDIMM2.236 UC1.AN22
DDR_B_D61: JDIMM2.232 UC1.AP22
DDR_B_D62: JDIMM2.246 UC1.AP21
DDR_B_D63: JDIMM2.250 UC1.AN21
DDR_B_DQS0: JDIMM2.13 UC1.AY38
DDR_B_DQS1: JDIMM2.34 UC1.BA34
DDR_B_DQS2: JDIMM2.179 UC1.AR38
DDR_B_DQS3: JDIMM2.200 UC1.AR32
DDR_B_DQS4: JDIMM2.55 UC1.AY30
DDR_B_DQS5: JDIMM2.76 UC1.BA26
DDR_B_DQS6: JDIMM2.221 UC1.AR27
DDR_B_DQS7: JDIMM2.242 UC1.AR21
DDR_B_DQS#0: JDIMM2.11 UC1.BA38
DDR_B_DQS#1: JDIMM2.32 UC1.AY34
DDR_B_DQS#2: JDIMM2.177 UC1.AT38
DDR_B_DQS#3: JDIMM2.198 UC1.AT32
DDR_B_DQS#4: JDIMM2.53 UC1.BA30
DDR_B_DQS#5: JDIMM2.74 UC1.AY26
DDR_B_DQS#6: JDIMM2.219 UC1.AR25
DDR_B_DQS#7: JDIMM2.240 UC1.AR22
DDR_B_MA0: JDIMM2.144 UC1.BA46
DDR_B_MA1: JDIMM2.133 UC1.AY46
DDR_B_MA2: JDIMM2.132 UC1.AY47
DDR_B_MA3: JDIMM2.131 UC1.BB46
DDR_B_MA4: JDIMM2.128 UC1.BA47
DDR_B_MA5: JDIMM2.126 UC1.AY48
DDR_B_MA6: JDIMM2.127 UC1.BA48
DDR_B_MA7: JDIMM2.122 UC1.AP48
DDR_B_MA8: JDIMM2.125 UC1.BB48
DDR_B_MA9: JDIMM2.121 UC1.AP50
DDR_B_MA10: JDIMM2.146 UC1.AW46
DDR_B_MA11: JDIMM2.120 UC1.AN48
DDR_B_MA12: JDIMM2.119 UC1.AN50
DDR_B_MA13: JDIMM2.158 UC1.BA43
DDR_B_MA14: JDIMM2.151 UC1.AY44
DDR_B_MA15: JDIMM2.156 UC1.AY43
DDR_B_MA16: JDIMM2.152 UC1.AW44
DDR_B_ODT0: JDIMM2.155 UC1.BA42
DDR_B_ODT1: JDIMM2.161 UC1.AW42
DDR_B_PARITY: JDIMM2.143 UC1.AP43
DDR_DRAMRST#: RD2.2 RD29.2 UC1.AT13
DDR_DRAMRST#_R: CD6.1 CD35.1 JDIMM1.108 JDIMM2.108 RD29.1
DDR_VTT_CTRL: UC1.AW67 UD1.2
DDR_XDP_WAN_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP1.53 QC2.1 RC319.2 UN1.1
DDR_XDP_WAN_SMBDAT: JDIMM1.254 JDIMM2.254 JXDP1.51 QC2.4 RC318.2 UN1.4
DEW1: RN20.2 RN21.2 UN7.16
DEW2: RN18.2 RN19.2 UN7.6
DH_1.2V: PQ201.1 PU201.17
DIMM1_SA0: JDIMM1.256 RD62.2 RD66.1
DIMM1_SA1: JDIMM1.260 RD63.2 RD67.1
DIMM1_SA2: JDIMM1.166 RD64.2 RD68.1
DIMM2_SA0: JDIMM2.256 RD69.2 RD72.1
DIMM2_SA1: JDIMM2.260 RD70.2 RD73.1
DIMM2_SA2: JDIMM2.166 RD71.2 RD74.1
DIMM_TYPE: RC341.2 RC342.1 UC1.P2
DIS_BAT_PROCHOT#: PR907.1 UE1.B51
DISP_ON: DV2.1 JEDP1.22 RV2.1
DK_AC_OFF: PD901.3 PU901.25
DK_AC_OFF_EN: PR938.1 PU901.22
DK_CSS_GC: PR810.1 PU901.11
DK_PWRBAR: PR924.1 PU901.33
DL_1.2V: PQ201.6 PU201.15
DMIC0: CA6.1 JEDP1.7 UA1.47
DMIC_CLK0: CA5.1 CA54.1 JEDP1.9 RA14.2
DMIC_CLK_CODEC: RA14.1 UA1.2
DOCK_AC_OFF: JDOCK1.2 PD901.1 PR925.1
DOCK_AC_OFF_EC: PR929.1 PR938.2 UE1.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ804.1
DOCK_DCIN_IS-: JDOCK1.136 PQ805.1
DOCK_DET#: D19.2 PQ907.2 PR919.1 R272.1 UE1.B41
DOCK_DET_R#: D19.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: QA3.2 RA29.2 UE1.A7
DOCK_MIC_DET: QA3.5 RA26.2 UE1.B8
DOCK_POR_RST#: JDOCK1.140 RE277.2 UE2.A21
DOCK_PSID: JDOCK1.135 PD7.2 PD7.3 PU1.1
DOCK_PWR_BTN#: CE44.1 JDOCK1.139 RE42.2
DOCK_PWR_SW#: CE45.1 RE42.1 RE62.2 UE2.A63
DOCK_SMB_ALERT#: JDOCK1.133 PQ2.3 RPE12.3 UE1.A51
DOCK_SMB_CLK: JDOCK1.127 RPE3.4 UE2.B4
DOCK_SMB_DAT: JDOCK1.129 RPE3.3 UE2.A3
DOCKED: QV11.2 UE1.A38 UL4.13 UV16.30
EC5048_TX: RE305.1 UE1.B2
EC_32KHZ_ECE5048: UE1.B35 UE2.B2
EC_FPM_EN: JUSH1.22 UE2.B62
EDP_AUXN: CV1.1 UC1.E45
EDP_AUXN_C: CV1.2 JEDP1.33
EDP_AUXP: CV2.1 UC1.F45
EDP_AUXP_C: CV2.2 JEDP1.34
EDP_BIA_PWM: DV1.3 UC1.R11
EDP_COMP: RC2.2 UC1.E52
EDP_HPD: JEDP1.26 RC1.2 UC1.L10
EDP_TXN0: CV4.1 UC1.C47
EDP_TXN0_C: CV4.2 JEDP1.36
EDP_TXN1: CV6.1 UC1.D46
EDP_TXN1_C: CV6.2 JEDP1.38
EDP_TXP0: CV3.1 UC1.C46
EDP_TXP0_C: CV3.2 JEDP1.35
EDP_TXP1: CV5.1 UC1.C45
EDP_TXP1_C: CV5.2 JEDP1.37
EDRAM_OPIO_RCOMP: RC90.1 UC1.H66
EMMC_RCOMP: RC4.1 UC1.AT1
EN_1.0V_PRIM_COREP: PC411.1 PR406.2 PR407.1 PU402.13
EN_1.8VALW: PC505.1 PR504.2 PR505.1 PU501.1
EN_1VS_VCCIO: PC402.1 PR402.2 PR403.1 PU401.13
EN_+1VALWP: PR302.1 PR312.1 PU301.1
EN_DK_PWRBAR: PR901.1 PR934.1 PU901.17
EN_DOCK_PWR_BAR: PR901.2 UE1.B37
EN_I2S_NB_CODEC#: UA1.1 UE1.B36
EN_INVPWR: QV2.2 RE55.2 UE2.A25
EN_LCDPWR: DV3.1 RV3.2 UV24.4
ENLDO_3V5V: PR102.1 PR103.1 PU100.11 PU102.11
ENVDD_PCH: DV3.3 UC1.U13 UE2.A7
EOPIO_RCOMP: RC91.1 UC1.H65
ERC1: PC908.1 PU901.3
ERC2: PC901.1 PU901.13
ERC3: PC907.1 PU901.12
FAN1_PWM: JFAN1.2 RE48.2 UE2.A24
FAN1_TACH: JFAN1.3 RE51.2 UE2.B22
FB_1.8VALW: PC503.2 PR501.2 PR506.1 PU501.6
FB_+1VALWP: PR306.2 PR308.2 PR311.1 PU301.4
FB_IA: PR645.2 PR648.2 PR650.1 PU602.17
FB_VSA: PR646.1 PR649.1 PR652.1 PU602.25
FCCM_GT: PR671.2 PU602.11
FCCM_IA: PR659.2 PU602.21
FCCM_VSA: PR679.2 PU602.29
FFS_INT2: QN1.2 RC322.1 UC1.J4 UN1.11
FFS_INT2_Q: JSATA1.19 QN1.3 RN1.2
FIVR_EN: RC217.1 RC218.2 RC219.2
FIVR_EN_R: JXDP1.45 RC126.2 RC132.2 RC217.2
FWP#: RE81.2 RE82.2 UE2.B65
GPIO_PSID_SELECT: PU1.6 UE1.A6
GPIOD4: T97.1(TP-1) UE1.B15
GPIOD5: T99.1(TP-1) UE1.A15
GPIOE2: T98.1(TP-1) UE1.A2
GPP_B23: QC3.3 RC326.1 RC327.2 UC1.AM7
GPP_B23_Q: QC3.1 RC317.1 RC327.1
GPP_C5: RC25.1 UC1.W1
GPP_E23: T120.1(TP-1) UC1.N12
GPU_B+: PC672.1 PC673.1 PC679.1 PC688.1 PJP602.1 PU605.5
GPU_SMBCLK: RPE13.6 UE2.B49
GPU_SMBDAT: RPE13.5 UE2.B48
GT1P: PL604.3 PR674.2
GT_SNUB1: PC678.1 PR676.2
GT_SW1: PL604.4 PR676.1 PU605.4
H_CATERR#: RC79.2 UC1.D63
H_CPU_SVIDALRT#: RC153.1 UC1.B63
H_CPUPWRGD: CC300.1 RC77.2 UC1.A68
H_CPUPWRGD_R: RC77.1 T9.1(TP-1)
H_PROCHOT#: PC605.2 PR678.1 PR818.1 RC83.2 RC84.1 RE288.2
H_PROCHOT#_R: RC84.2 UC1.C65
H_PROCHOT#_R1: RE288.1 UE2.A46
H_THERMTRIP#: QE4.3 RC80.2 RD4.2 RD61.2 UC1.C63
H_VCCST_PWRGD_XDP: JXDP1.39 RC123.2 RC124.2
HDA_BIT_CLK: RC93.2 UC1.AY22
HDA_BIT_CLK_R: CC27.1 RA17.1 RC93.1 UA1.6
HDA_RST#: RC95.2 UC1.AW22
HDA_RST#_R: RC95.1 UA1.11
HDA_SDIN0: RA9.1 UC1.BA21
HDA_SDIN0_R: RA9.2 UA1.8
HDA_SDOUT: RC94.2 RC187.2 RC223.2 UC1.BB22
HDA_SDOUT_R: RC94.1 UA1.5
HDA_SYNC: RC92.2 UC1.BA22
HDA_SYNC_R: RC92.1 UA1.10
HDD_A_EQ: RN12.1 RN13.2 UN7.17
HDD_A_EQ2: RN83.1 RN84.2 UN7.18
HDD_A_PRE: RN8.2 RN9.2 UN7.9
HDD_B_EQ: RN14.2 RN16.2 UN7.19
HDD_B_EQ2: RN22.2 RN23.1 UN7.13
HDD_B_PRE: RN10.1 RN11.2 UN7.8
HDD_DET#: JSATA1.13 RPC4.1 UC1.H2
HDD_DEVSLP: JSATA1.11 RN5.2 UC1.J1
HDD_EN: RC184.2 RN6.2 RN7.1 UC1.AN5 UZ23.3
HDD_FALL_INT: RPC4.4 UC1.BB11 UN1.12
HDMI_CEC: JHDMI1.13 RV8.1
HDMI_CLKN: CV14.1 RV17.1 RV658.1
HDMI_CLKP: CV13.1 RV16.1 RV656.1
HDMI_CTRL_CLK: JHDMI1.15 QV3.6 RV21.1
HDMI_CTRL_DATA: JHDMI1.16 QV3.3 RV18.1
HDMI_HPD: JHDMI1.19 QV5.1 RV20.1
HDMI_L_CLKN: JHDMI1.12 RV657.1 RV658.2
HDMI_L_CLKP: JHDMI1.10 RV656.2 RV657.2
HDMI_L_TX_N0: JHDMI1.9 RV654.1 RV655.2
HDMI_L_TX_N1: JHDMI1.6 RV651.1 RV652.2
HDMI_L_TX_N2: JHDMI1.3 RV648.1 RV649.2
HDMI_L_TX_P0: JHDMI1.7 RV653.2 RV654.2
HDMI_L_TX_P1: JHDMI1.4 RV650.2 RV651.2
HDMI_L_TX_P2: JHDMI1.1 RV647.2 RV648.2
HDMI_OB: QV4.1 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2
HDMI_TX_N0: CV29.1 RV15.1 RV655.1
HDMI_TX_N1: CV22.1 RV13.1 RV652.1
HDMI_TX_N2: CV18.1 RV11.1 RV649.1
HDMI_TX_P0: CV28.1 RV14.1 RV653.1
HDMI_TX_P1: CV21.1 RV12.1 RV650.1
HDMI_TX_P2: CV17.1 RV10.1 RV647.1
HOST_DEBUG_TX: JDEG1.8 RE73.2 UE2.B44
HOST_SD_WP#: QR1.2 RC292.2 UC1.AB3
HUB_DP0_AUXN: CV123.2 RV85.1 UV8.A11
HUB_DP0_AUXN_C: CV123.1 UV12.5
HUB_DP0_AUXP: CV122.2 RV74.1 UV8.B11
HUB_DP0_AUXP_C: CV122.1 UV12.2
HUB_DP0_CADET: JDOCK1.5 QV10.2 RV509.2 UV8.A14 UV12.1 UV12.4
HUB_DP0_CADETN: QV10.1 RV91.2 UV12.10 UV12.13
HUB_DP0_HPD: C310.1 JDOCK1.39 R268.1 UV8.A6
HUB_DP0_N0: C295.2 UV8.A7
HUB_DP0_N0_C: C295.1 R252.1
HUB_DP0_N0_R: JDOCK1.11 R252.2
HUB_DP0_N1: C299.2 UV8.A8
HUB_DP0_N1_C: C299.1 R255.1
HUB_DP0_N1_R: JDOCK1.17 R255.2
HUB_DP0_N2: C306.2 UV8.A9
HUB_DP0_N2_C: C306.1 R263.1
HUB_DP0_N2_R: JDOCK1.23 R263.2
HUB_DP0_N3: C301.2 UV8.A10
HUB_DP0_N3_C: C301.1 R266.1
HUB_DP0_N3_R: JDOCK1.29 R266.2
HUB_DP0_P0: C302.2 UV8.B7
HUB_DP0_P0_C: C302.1 R259.1
HUB_DP0_P0_R: JDOCK1.9 R259.2
HUB_DP0_P1: C297.2 UV8.B8
HUB_DP0_P1_C: C297.1 R253.1
HUB_DP0_P1_R: JDOCK1.15 R253.2
HUB_DP0_P2: C304.2 UV8.B9
HUB_DP0_P2_C: C304.1 R257.1
HUB_DP0_P2_R: JDOCK1.21 R257.2
HUB_DP0_P3: C300.2 UV8.B10
HUB_DP0_P3_C: C300.1 R265.1
HUB_DP0_P3_R: JDOCK1.27 R265.2
HUB_DP0_SCL: RPV2.4 UV8.B12 UV12.12
HUB_DP0_SDA: RPV2.3 UV8.A12 UV12.9
HUB_DP1_AUXN: CV120.2 RV82.1 UV8.J14
HUB_DP1_AUXN_C: CV120.1 UV11.5
HUB_DP1_AUXP: CV119.2 RV75.1 UV8.J13
HUB_DP1_AUXP_C: CV119.1 UV11.2
HUB_DP1_CADET: JDOCK1.6 QV9.2 RV508.2 UV8.M14 UV11.1 UV11.4
HUB_DP1_CADETN: QV9.1 RV90.2 UV11.10 UV11.13
HUB_DP1_HPD: C311.1 JDOCK1.40 R271.1 UV8.K14
HUB_DP1_N0: C296.1 UV8.E14
HUB_DP1_N0_C: C296.2 R261.2
HUB_DP1_N0_R: JDOCK1.12 R261.1
HUB_DP1_N1: C303.1 UV8.F14
HUB_DP1_N1_C: C303.2 R256.2
HUB_DP1_N1_R: JDOCK1.18 R256.1
HUB_DP1_N2: C307.1 UV8.G14
HUB_DP1_N2_C: C307.2 R264.2
HUB_DP1_N2_R: JDOCK1.24 R264.1
HUB_DP1_N3: C309.1 UV8.H14
HUB_DP1_N3_C: C309.2 R267.2
HUB_DP1_N3_R: JDOCK1.30 R267.1
HUB_DP1_P0: C294.1 UV8.E13
HUB_DP1_P0_C: C294.2 R260.2
HUB_DP1_P0_R: JDOCK1.10 R260.1
HUB_DP1_P1: C298.1 UV8.F13
HUB_DP1_P1_C: C298.2 R254.2
HUB_DP1_P1_R: JDOCK1.16 R254.1
HUB_DP1_P2: C305.1 UV8.G13
HUB_DP1_P2_C: C305.2 R262.2
HUB_DP1_P2_R: JDOCK1.22 R262.1
HUB_DP1_P3: C308.1 UV8.H13
