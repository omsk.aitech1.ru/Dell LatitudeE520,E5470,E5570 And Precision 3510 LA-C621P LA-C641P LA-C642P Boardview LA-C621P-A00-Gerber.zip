# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DAI_DI: length 208.8
  TOP w0.102: UA1.24 v2(281.8,30.43)
  IN3 w0.122: v2(156.75,102.09) 156.75,101.31 159.48,98.59 171.04,98.59 174.39,95.24 174.39,93.12 175,92.51 176.28,92.51 176.66,92.88 176.66,93.77 177.92,95.03 177.92,95.04 178.35,95.47 178.65,95.77 187.95,95.77 191.89,91.82 201.75,91.82 209.91,99.99 210.21,99.99 211.31,101.08 214.07,101.08 214.94,101.95 226.91,101.95 228.78,100.08 229.72,100.08 230.32,99.49 242.92,99.49 243.58,98.84 244.54,98.84 247.35,96.03 247.35,90.69 246.86,90.2 246.86,88.42 248.13,87.15 248.13,81.98 247.22,81.07 247.22,80.11 246.85,79.73 246.72,79.73 245.85,78.87 245.85,78.42 246.33,77.94 246.45,77.94 247.01,77.38 247.58,77.38 248.22,76.74 248.22,75.67 253.05,70.84 261.15,70.84 261.99,70.01 264.25,70.01 266.2,68.06 266.2,67.29 266.48,67.01 266.99,67.01 267.73,66.28 271.38,66.28 271.99,66.89 274.78,66.89 277.86,63.81 278.23,63.44 278.23,60.68 278.7,60.22 278.7,57.3 278.43,57.03 278.43,55.94 278.43,55.94 278.43,51.38 278.76,51.06 278.76,49.91 281.69,46.98 281.69,42.04 281.97,41.76 281.97,40.03 277.35,35.42 277.35,31.6 277.63,31.32 280.99,31.32 281.8,30.51 v2(281.8,30.43)
  BOTTOM w0.102: v2(156.75,102.09) 156.37,102.09 156,101.71 JDOCK1.83
DAI_DO#: length 211
  TOP w0.076: RA32.1 279.2,26.81 v2(279.31,26.69)
  IN3 w0.122: v2(279.31,26.69) 279.31,28.12 276.86,30.58 276.86,37.53 276.57,37.82 276.57,41.33 277.36,42.12 280.59,42.12 281.19,42.72 281.19,46.36 278.26,49.29 278.26,50.85 277.93,51.18 277.93,55.74 277.93,57.23 278.2,57.5 278.2,60.01 277.74,60.48 277.74,63.23 276.98,63.99 275.03,63.99 272.91,66.1 271.91,66.1 271.59,65.78 267.41,65.78 266.67,66.52 265.11,66.52 263.96,67.67 262.93,67.67 261.65,68.95 261.13,68.95 260.88,68.71 260.88,68.58 260.72,68.42 260.11,68.42 259.36,69.17 253.64,69.17 248.59,74.22 248.44,74.37 248.3,74.51 248.08,74.73 247.31,74.73 246.7,75.34 246.7,76.64 246.14,77.19 245.04,77.19 244.85,77.38 244.5,77.73 244.5,78.05 244.8,78.34 244.8,81.69 245.52,82.42 245.52,82.41 246.48,82.41 246.7,82.63 246.7,83.72 246.28,84.14 246.04,84.14 245.27,84.91 245.27,86.7 246.37,87.79 246.37,90.41 246.85,90.89 246.85,94.79 242.65,98.99 230.11,98.99 229.52,99.58 228.57,99.58 227.31,100.85 225.25,100.85 224.65,101.45 217.28,101.45 216.42,100.58 211.51,100.58 210.42,99.49 210.12,99.49 201.96,91.33 189.36,91.33 185.41,95.27 178.86,95.27 178.56,94.97 177.15,93.57 177.15,92.67 176.49,92.01 174.72,92.01 173.89,92.84 173.89,95.03 170.84,98.09 158.94,98.09 158.23,98.8 157.25,98.8 v2(156.73,99.32)
  BOTTOM w0.102: JDOCK1.85 156.5,99.56 v2(156.73,99.32)
DAI_LRCK#: length 208.5
  TOP w0.102: UA1.18 278.91,29.65 v2(278.73,29.47)
  IN3 w0.122: v2(278.73,29.47) 277.11,31.09 277.11,37.66 276.82,37.95 276.82,41.22 277.46,41.87 280.69,41.87 281.44,42.62 281.44,46.88 278.51,49.81 278.51,50.95 278.18,51.28 278.18,55.84 278.18,57.13 278.45,57.4 278.45,60.11 277.98,60.58 277.98,63.33 277.76,63.56 277.76,63.56 277.08,64.24 275.15,64.24 273.03,66.35 272.01,66.35 271.81,66.35 271.48,66.03 267.72,66.03 267.63,66.03 266.89,66.76 265.71,66.76 264.98,67.49 264.98,68.11 263.42,69.67 253.85,69.67 249.09,74.43 248.94,74.57 248.5,75.01 248.29,75.23 247.51,75.23 247.19,75.55 247.19,76.44 247.19,76.64 247.19,76.85 246.35,77.69 246.22,77.69 245.6,78.31 245.6,79 246.16,79.56 246.16,79.89 245.62,80.43 245.62,81.02 245.77,81.17 246.78,81.17 247.22,81.61 247.22,86.96 246.62,87.56 246.62,90.3 247.1,90.79 247.1,94.96 243.48,98.59 243.48,98.59 242.82,99.24 230.21,99.24 229.62,99.83 228.68,99.83 227.41,101.1 225.36,101.1 224.76,101.7 217.18,101.7 216.31,100.83 211.41,100.83 210.31,99.74 210.01,99.74 201.85,91.58 190.02,91.58 187.9,93.7 187.9,94.34 186.71,95.52 178.76,95.52 178.46,95.22 176.9,93.67 176.9,92.77 176.39,92.26 174.87,92.26 174.14,92.99 174.14,95.14 170.94,98.34 159.18,98.34 157.78,99.74 155.54,99.74 v2(155.27,99.47)
  BOTTOM w0.102: JDOCK1.79 155,99.72 155.25,99.47 v2(155.27,99.47)
DAT_KBD: length 173.5
  TOP w0.102: v2(262.92,62.33) 262.53,62.72 261.89,62.72 261.46,62.29 UE2.B41 ; v2(155.21,110.04) 155.1,109.94 155.1,109.8 155.33,109.58 157.64,109.58 158.2,110.14 160.08,110.14 160.84,109.38 160.84,107.95 160.64,107.75 160.64,107.2 161.04,106.8 166.7,106.8 167.8,105.7 167.8,104.44 169.04,103.2 169.37,103.2 169.96,102.61 171.47,102.61 174.44,99.63 189.14,99.63 193.17,95.61 201.02,95.61 206.52,101.1 206.52,106.08 209.59,109.15 211.24,109.15 211.66,109.58 214.86,109.58 216.06,108.38 216.06,105.79 217.59,104.26 217.59,103.01 218.7,101.91 224.57,101.91 225.41,101.07 226.51,101.07 227.89,102.45 236.4,102.45 v3(239.54,99.32) 243.27,95.59 243.27,90.12 v2(242.78,89.64) ; RPE2.7 258.41,68.29 v2(258.38,68.25)
  IN2 w0.122: v2(242.78,89.64) 242.86,89.64 243.89,88.61 245.04,88.61 246.78,86.87 246.78,86.72 246.78,86.71 246.78,85.49 247.32,84.95 247.81,84.95 248.07,84.69 248.07,84.48 248.07,83.11 248.26,82.92 248.26,82.92 248.42,82.76 248.42,81.99 248.36,81.93 248.36,75.86 249.03,75.19 249.03,74.19 249.09,74.13 249.09,73.89 250.21,72.78 v2(250.21,67.63)
  BOTTOM w0.102: v2(155.21,110.04) 155,109.83 JDOCK1.80 ; v2(262.92,62.33) 262.38,62.87 261.66,62.87 261.43,63.1 261.43,65.66 262.19,66.42 262.19,68.9 261.57,69.52 261.25,69.52 260.9,69.88 259.98,69.88 259.25,69.15 258.84,69.15 258.38,68.69 v2(258.38,68.25) 257.87,68.76 257.26,68.76 256.96,68.46 250.87,68.46 250.21,67.8 v2(250.21,67.63)
DAT_MSE: length 163.8
  TOP w0.102: v2(262.04,62.32) 262.04,62.31 262.04,62.26 261.57,61.79 UE2.B42 ; RPE2.5 256.76,69.16 256.18,68.58 255.91,68.31 255.91,68.3 255.1,67.5 255.1,66.33 254.83,66.06 252.4,66.06 251.21,64.86 249.77,64.86 248.94,64.02 248.94,60.7 249.74,59.9 v2(250.33,59.9)
  IN2 w0.122: v2(242.92,62.77) 242.8,62.77 241.93,63.64 241.93,64.14 241.93,64.14 241.93,65.17 241.93,67.58 243.23,68.88 243.99,68.88 244.34,69.24 244.34,71.79 241.94,74.19 241.94,78.88 241.06,79.76 238.26,79.76 237.17,78.67 235.21,78.67 232.64,76.1 229.86,76.1 228.78,77.18 223.9,77.18 222.93,78.15 204.13,78.15 203.6,77.62 201.23,77.62 201,77.85 190.2,77.85 189.62,78.43 189.43,78.62 187.94,80.11 187.94,81.39 184.06,85.27 183.24,85.27 180.3,88.21 178.83,88.21 178.18,88.86 178.18,89.31 177.21,90.28 170.17,90.28 168.92,91.52 167.89,91.52 161.73,97.69 161.23,97.69 160.75,98.17 160.75,99.14 v2(160.67,99.22)
  IN4 w0.089: v2(250.33,59.9) 250.82,59.9 251.13,60.21 252.1,61.18 252.98,61.18 253.29,60.86 253.9,60.86 255.15,59.6 256.89,59.6 257.39,59.11 259.03,59.11 259.49,59.11 260.78,60.4 260.78,60.86 260.78,60.86 260.78,61.68 261.44,62.34 262.02,62.34 v2(262.04,62.32)
  BOTTOM w0.102: v2(250.33,59.9) 248.83,59.9 245.81,62.92 243.07,62.92 v2(242.92,62.77) ; JDOCK1.73 153.5,99.94 154.13,99.3 154.65,98.78 160.51,98.78 160.67,98.94 v2(160.67,99.22)
DAT_TP_SIO: length 74.2
  TOP w0.102: v2(262.98,63.2) 262.75,62.97 261.61,62.97 261.43,62.79 UE2.B40 ; v2(218.92,36.18) 219.2,35.9 RZ18.2 219.56,36.59 CZ30.1 218.41,36.78 RZ22.2
  IN2 w0.122: v2(218.92,36.18) 218.92,35.91 218.36,35.34 218.36,34.87 218.65,34.58 219.27,34.58 219.67,34.97 222.53,34.97 223.33,35.77 224.03,35.77 224.94,34.86 226.18,34.86 226.68,35.37 226.68,36 227.35,36.67 234.2,36.67 235.38,35.49 235.38,34.83 236.55,33.66 240.19,33.66 246.83,40.3 247.54,40.3 248.35,41.1 250.79,41.1 253.55,43.86 253.75,43.86 255.89,46 255.89,46.47 256.09,46.67 256.4,46.98 256.4,49.63 256.05,49.98 256.05,53.89 256.71,54.54 258.15,55.99 259.16,55.99 260.52,57.34 260.52,60.99 260.73,61.2 260.73,62.17 261.53,62.97 262.75,62.97 v2(262.98,63.2)
DAT_TP_SIO_R: length 9.9
  TOP w0.102: JKBTP1.13 210.8,34.34 211.73,35.27 216.12,35.27 217,36.15 217,36.25 217.5,36.75 RZ22.1 218.42,37.71 v3(218.65,37.71)
DC_BLOCK_GC: length 19.4
  TOP w0.203: PU901.7 27.68,77.48 v2(27.72,77.44)
  TOP w0.254: PR803.2 v2(41.19,82.2)
  IN4 w0.254: v2(27.72,77.44) 29.01,77.44 29.45,76.99 29.45,75.94 30.08,75.31 33.79,75.31 40.68,82.2 v2(41.19,82.2)
DC_IN_SS: length 3.5
  TOP w0.254: v2(22.52,79.42) 22.52,79.67 23.14,80.29 PU901.34
  BOTTOM w0.508: v2(22.52,79.42) 22.97,79.86 PR935.2
DDR_A_ACT#: length 64.9
  IN1 w0.145: v2(106.74,13.77) 107.15,14.18 107.15,16.08 106.26,16.97 106.26,20.34 107.56,21.64 107.56,22.52 115.49,30.45 116.13,30.45 120.19,34.52 124.18,34.52 124.78,35.12 124.96,35.12 125.73,35.89 129.69,35.89 139.45,45.65 139.66,45.65 140.23,46.22 140.23,47.29 140.24,47.3 140.24,47.65 140.23,47.66 140.23,50.82 v2(139.83,51.21)
  BOTTOM w0.076: UC1.BA55 141.87,55.28 141.87,55.04 141.82,54.91 141.73,54.82 141.73,53.39 139.83,51.5 v2(139.83,51.21)
  BOTTOM w0.168: v2(106.74,13.77) 107.12,13.39 JDIMM1.114
DDR_A_ALERT#: length 94
  IN4 w0.076: v2(145.48,57.25) 145.55,57.25 146.08,57.78 146.08,60.54 145.98,60.64
  IN4 w0.145: v2(106.67,15.32) 106.67,18.11 104.19,20.59 104.19,44.46 106.24,46.5 108.97,46.5 109.29,46.82 109.31,46.82 113.3,50.81 113.3,56.22 121.64,64.56 136.48,64.56 139.84,61.19 145.68,61.19 145.96,60.91 145.96,60.83 145.98,60.81 145.98,60.64
  BOTTOM w0.168: JDIMM1.116 107.62,14.56 106.87,15.32 v2(106.67,15.32)
  BOTTOM w0.254: UC1.AW50 145.06,56.82 v2(145.48,57.25)
DDR_A_BA0: length 65.4
  IN1 w0.076: v2(143.73,57.32) 144.28,56.77 144.28,55.78 144.48,55.57 144.48,55.21 146.26,53.43
  IN1 w0.145: v2(115.91,19.33) 116.12,19.33 120.06,23.27 122.03,23.27 123.82,25.06 129.5,25.06 145.01,40.57 145.01,43.68 146.13,44.79 146.37,45.04 146.37,53.32 146.26,53.43
  BOTTOM w0.076: v2(143.73,57.32) 144.06,57.65 UC1.AU52
  BOTTOM w0.168: v2(115.91,19.33) 116.34,18.9 116.34,16.39 116.95,15.78 116.95,13.67 118.12,12.5 JDIMM1.150
DDR_A_BA1: length 67.4
  IN1 w0.076: 146.43,43.24 146.43,43.29 146.9,43.76 146.9,51.59 147.48,52.18 147.48,54 146.9,54.59 146.5,54.59 144.95,56.14 144.95,57.69 145.02,57.76 145.02,58.13 145.5,58.61 v2(145.55,58.61)
  IN1 w0.145: 146.43,43.24 146.43,41.03 146.43,41.03 146.43,40.15 129.99,23.72 128.88,23.72 128.73,23.57 128.73,23.02 128.62,22.91 128.33,22.91 128.21,23.02 128.21,23.57 128.07,23.72 127.74,23.72 127.59,23.57 127.59,23.05 127.45,22.91 127.16,22.91 127.01,23.05 127.01,23.57 126.87,23.72 126.58,23.72 126.43,23.57 126.43,23.08 126.29,22.93 126,22.93 125.85,23.08 125.85,23.57 125.71,23.72 125.42,23.72 125.28,23.57 125.28,23.06 125.13,22.92 124.84,22.92 124.7,23.06 124.7,23.57 124.55,23.72 124.28,23.72 124.06,23.5 124.06,23.2 123.79,22.92 123.48,22.92 122.49,21.93 121.43,21.93 118.83,19.33 118.56,19.33 118.34,19.54 118.13,19.54 117.35,18.75 117.35,18.18 117.18,18.01 v2(116.98,18.01)
  BOTTOM w0.076: UC1.AT48 145.86,58.3 v2(145.55,58.61)
  BOTTOM w0.168: JDIMM1.145 116.87,18.12 v2(116.98,18.01)
DDR_A_BG0: length 66.4
  IN1 w0.145: v2(139.8,48.11) 138.99,47.29 138.99,46.44 138.99,46.39 129.35,36.75 123.64,36.75 123.08,36.18 121.9,36.18 121.08,35.37 119.84,35.37 115.97,31.49 115.33,31.49 105.21,21.37 105.21,20.49 104.64,19.93 104.64,19.09 105.01,18.73 105.01,17.35 105.05,17.31 105.05,16.26 105.22,16.09 105.64,16.09 v2(105.75,16.2)
  BOTTOM w0.076: 140.27,48.64 140.27,51.54 142.51,53.78 142.51,54.13 142.33,54.31 142.33,54.68 142.34,54.7 142.37,54.76 142.37,54.94 142.33,55.06 142.33,55.31 142.37,55.42 142.37,55.61 142.29,55.76 142,56.05 UC1.AY55
  BOTTOM w0.168: v2(105.75,16.2) 106.39,16.83 106.39,17.99 107.37,18.97 JDIMM1.115 ; v2(139.8,48.11) 140.27,48.58 140.27,48.64
DDR_A_BG1: length 65.8
  IN1 w0.145: v2(105.75,17.73) 105.63,17.73 105.43,17.93 105.43,18.34 105.56,18.47 105.61,18.47 105.75,18.61 105.75,19.15 105.61,19.29 105.21,19.29 105.07,19.44 105.07,19.69 105.21,19.84 105.61,19.84 105.75,19.98 105.75,21.31 115.51,31.07 116.14,31.07 120.02,34.94 121.26,34.94 121.48,35.16 121.78,35.16 122,34.94 122.28,34.94 122.42,35.09 122.42,35.58 122.56,35.72 122.88,35.72 123.03,35.58 123.03,35.09 123.17,34.94 123.54,34.94 123.68,35.09 123.68,36.1 123.83,36.24 124.03,36.24 124.18,36.1 124.18,35.74 124.32,35.59 124.62,35.59 124.76,35.74 124.76,36.17 124.91,36.31 125.3,36.31 129.51,36.31 139.22,46.02 139.22,46.89 139.8,47.48 v2(139.81,47.48)
  BOTTOM w0.076: 140.6,50.74 140.6,51.64 142.67,53.71 142.67,54.2 142.5,54.38 142.5,54.64 142.53,54.72 142.53,54.97 142.5,55.1 142.5,55.28 142.56,55.47 142.56,55.73 UC1.AY54
  BOTTOM w0.102: 140.6,50.74 140.6,48.19
  BOTTOM w0.168: 140.6,48.19 139.89,47.48 v2(139.81,47.48) ; v2(105.75,17.73) 105.95,17.93 105.95,18.17 106.87,19.09 JDIMM1.113
DDR_A_CKE0: length 65.8
  IN1 w0.145: v2(139.83,49.37) 138.33,47.88 138.33,47.06 138.33,47.06 138.33,46.71 138.33,46.66 129.08,37.4 123.37,37.4 122.81,36.83 121.63,36.83 120.81,36.02 119.57,36.02 115.7,32.14 115.06,32.14 104.55,21.64 104.55,20.76 104.32,20.52 103.97,20.52 103.74,20.29 103.74,19.67 103.97,19.43 103.97,19.08 103.74,18.84 103.74,16.29 103.98,16.04 104.25,16.04 104.39,16.18 v2(104.39,17.04)
  BOTTOM w0.076: v2(139.83,49.37) 139.16,50.05 139.16,51.29 141.23,53.37 141.23,54.27 141.17,54.33 141.17,54.64 141.17,54.64 141.29,54.89 141.29,54.89 141.3,54.89 141.44,55.03 UC1.BA56
  BOTTOM w0.168: v2(104.39,17.04) 104.85,17.5 104.85,17.69 105.87,18.72 JDIMM1.109
DDR_A_CKE1: length 65.3
  IN1 w0.145: v2(105.12,14.3) 103.31,16.11 103.31,20.99 114.89,32.57 115.52,32.57 119.39,36.44 120.64,36.44 121.45,37.26 122.63,37.26 123.2,37.82 128.76,37.82 137.91,46.97 137.91,48.14 v2(139.81,50.04)
  BOTTOM w0.076: v2(139.81,50.04) 139.38,50.47 139.38,51.28 141.4,53.3 141.4,54.49 UC1.BB56
  BOTTOM w0.168: v2(105.12,14.3) 105.37,14.3 105.89,13.78 105.89,13.42 106.12,13.19 JDIMM1.110
DDR_A_CKE2: length 3.1
  TOP w0.168: v2(140.96,57.31) 140.54,57.73 140.54,59.12 T3.1
  BOTTOM w0.076: UC1.AW56 141.44,56.75 140.96,57.23 v2(140.96,57.31)
DDR_A_CKE3: length 11.9
  TOP w0.168: v2(139.66,46.23) 139.64,46.21 139.64,46.03 139.56,45.95 T4.1
  BOTTOM w0.076: 139.14,49.3 138.99,49.44 138.99,51.36 141.01,53.37 141.01,54.67 141.03,54.72 141.17,55.08 141.17,55.36 141.44,55.63 UC1.AY56
  BOTTOM w0.168: v2(139.66,46.23) 139.13,46.76 139.13,49.29 139.14,49.3
DDR_A_CLK0: length 67.7
  IN1 w0.076: 143.88,55.33 143.88,55.33 143.84,55.38 143.84,56.59 143.36,57.06 143.36,57.58 143.17,57.78 142.98,57.78 v2(142.8,57.95)
  IN1 w0.112: v2(114.07,16.95) 114.24,17.12 114.49,17.12 114.82,17.45 114.82,19.12 119.61,23.9 121.64,23.9 123.43,25.7 127.68,25.7 127.94,25.95 127.94,26.71 128.05,26.83 128.39,26.83 128.5,26.71 128.5,25.92 128.72,25.7 129.24,25.7 129.55,26.01 129.55,26.71 129.66,26.83 130.37,26.83 144.37,40.83 144.37,43.94 146.07,45.64 146.07,52.72 145.5,53.29 144.48,53.29 143.88,53.89 143.88,55.33
  BOTTOM w0.076: v2(142.8,57.95) 142.8,58.04 143.06,58.3 UC1.AT53
  BOTTOM w0.094: JDIMM1.137 112.87,18.99 113.15,18.72 113.15,17.55 113.53,17.16 113.87,17.16 114.07,16.97 v2(114.07,16.95)
DDR_A_CLK1: length 67.6
  IN1 w0.076: v2(141.85,57.94) 141.85,57.8 141.95,57.7 142.18,57.7 142.39,57.49 142.39,57.21 142.44,57.16 142.44,55.38 142.48,55.33 142.48,55.33
  IN1 w0.112: 142.48,55.33 142.48,54.55 143.01,54.03 143.01,53.62 144.69,51.94 144.69,46.37 144.02,45.7 144.02,44.7 143.61,44.29 143.61,41.15 130.05,27.59 127.7,27.59 126.57,26.46 123.12,26.46 121.32,24.67 119.29,24.67 113.39,18.77 113.39,15.32 113.63,15.08 114.02,15.08 114.22,15.28 v2(114.22,15.41)
  BOTTOM w0.076: v2(141.85,57.94) 142.21,58.3 UC1.AT55
  BOTTOM w0.094: JDIMM1.138 113.12,14.71 113.61,15.19 114.01,15.19 v2(114.22,15.41)
DDR_A_CLK#0: length 67.7
  IN1 w0.076: 143.63,55.33 143.63,55.33 143.67,55.38 143.67,56.52 143.2,56.99 143.2,57.51 143.1,57.61 142.95,57.61 142.8,57.47 v2(142.8,57.32)
  IN1 w0.112: 143.63,55.33 143.63,53.79 144.38,53.04 145.4,53.04 145.83,52.61 145.83,45.74 144.12,44.04 144.12,40.93 130.27,27.07 129.56,27.07 129.3,26.82 129.3,26.11 129.14,25.94 128.82,25.94 128.74,26.02 128.74,26.82 128.49,27.07 127.95,27.07 127.69,26.82 127.69,26.05 127.58,25.94 123.33,25.94 121.54,24.15 119.5,24.15 114.57,19.22 114.57,17.56 114.39,17.37 114.07,17.37 113.98,17.45 113.98,17.8 v2(114.07,17.89)
  BOTTOM w0.076: v2(142.8,57.32) 142.8,57.4 143.06,57.65 UC1.AU53
  BOTTOM w0.094: v2(114.07,17.89) 114.16,17.8 114.16,17.5 114.01,17.36 113.61,17.36 113.34,17.63 113.34,19.01 113.37,19.04 JDIMM1.139
DDR_A_CLK#1: length 67.6
  IN1 w0.076: 142.24,55.33 142.24,55.33 142.28,55.38 142.28,57.09 142.23,57.14 142.23,57.42 142.12,57.53 141.96,57.53 141.85,57.42 v2(141.85,57.3)
  IN1 w0.112: v2(114.22,14.64) 114.03,14.84 113.52,14.84 113.14,15.22 113.14,18.87 119.19,24.91 121.22,24.91 123.01,26.71 126.47,26.71 127.6,27.84 129.95,27.84 143.36,41.25 143.36,44.39 143.78,44.8 143.78,45.8 144.45,46.47 144.45,51.83 142.76,53.52 142.76,53.93 142.38,54.31 142.24,54.45 142.24,55.33
  BOTTOM w0.076: UC1.AU55 142.19,57.65 v2(141.85,57.3)
  BOTTOM w0.094: JDIMM1.140 113.62,12.63 113.5,12.76 113.43,12.76 113.32,12.87 113.32,14.63 113.69,15 114.05,15 114.22,14.82 v2(114.22,14.64)
DDR_A_CS#0: length 71
  IN1 w0.076: 148.78,45.7 148.78,46.08 148.65,46.21 148.65,54.9 147.38,56.17 v2(147.38,57.32)
  IN1 w0.145: 148.78,45.7 148.78,45.69 148.78,38.45 130.82,20.49 124.4,20.49 123.49,19.58 122.41,19.58 121.13,18.3 121.13,16.33 120.75,15.95 120.75,13.84 120.6,13.69 120.19,13.69 120.05,13.84 120.05,14.35 119.84,14.56 118.42,14.56 118.27,14.41 v2(118.27,13.81)
  BOTTOM w0.076: UC1.AU45 v2(147.38,57.32)
  BOTTOM w0.168: v2(118.27,13.81) 117.69,14.39 117.69,16.15 117.57,16.27 117.57,17.47 117.64,17.54 117.64,18.98 117.87,19.21 JDIMM1.149
DDR_A_CS#1: length 71.4
  IN1 w0.076: 149.2,46.48 149.2,46.72 148.81,47.1 148.81,56.23 148.29,56.75 v2(148.29,57.32)
  IN1 w0.145: v2(121.58,17.35) 122.01,17.35 122.15,17.2 122.15,16.8 122.3,16.66 124.59,16.66 124.81,16.87 124.81,17.1 124.66,17.25 124.24,17.25 124.09,17.39 124.09,17.68 124.24,17.82 124.56,17.82 124.71,17.97 124.71,18.26 124.56,18.4 124.24,18.4 124.09,18.55 124.09,18.84 124.24,18.98 124.35,18.98 124.49,19.13 124.49,19.91 124.64,20.05 124.93,20.05 125.07,19.91 125.07,19.3 125.22,19.16 125.51,19.16 125.65,19.3 125.65,19.91 125.8,20.05 126.09,20.05 126.23,19.91 126.23,19.3 126.37,19.16 126.66,19.16 126.81,19.3 126.81,19.91 126.95,20.05 127.24,20.05 127.39,19.91 127.39,18.23 127.53,18.08 127.86,18.08 128.01,18.23 128.01,19.92 128.15,20.07 128.73,20.07 128.88,19.92 128.88,19.67 129.02,19.53 129.37,19.53 129.51,19.67 129.51,19.92 129.66,20.07 131,20.07 149.2,38.27 149.2,38.62 149.2,46.48
  BOTTOM w0.076: UC1.AU43 v2(148.29,57.32)
  BOTTOM w0.168: JDIMM1.157 119.87,19.05 v2(121.58,17.35)
DDR_A_D0: length 80.8
  IN1 w0.089: v2(129.64,60.34) 127.94,62.04 122.21,62.04 117.02,56.85 115.14,54.97 115.14,53.08 100.25,38.19 99.3,38.19 96.23,35.12 95.32,35.12 82.38,22.18 81.94,22.18 79.63,19.87 79.63,19.84 79.63,19.59 79.63,19.59 79.63,16.91 79.13,16.41 v2(79.03,16.41)
  BOTTOM w0.076: v2(129.64,60.34) 130.29,60.99 130.89,60.99 131.35,61.45 132.63,61.45 132.72,61.35 UC1.AL71
  BOTTOM w0.102: JDIMM1.7 80.37,17.65 79.13,16.41 v2(79.03,16.41)
DDR_A_D1: length 82.1
  IN1 w0.089: v2(131.44,60.42) 129.52,62.34 122.08,62.34 116.9,57.15 116.9,57.15 114.84,55.09 114.84,53.21 100.12,38.49 99.18,38.49 96.11,35.42 95.68,35.42 95.68,35.42 95.14,35.42 82.2,22.48 81.79,22.48 80.19,20.89 80.07,20.89 79.98,20.97 79.88,21.07 79.73,21.07 79.63,20.97 79.63,20.82 79.73,20.72 79.81,20.63 79.81,20.51 79.69,20.38 79.56,20.38 79.48,20.47 79.26,20.68 79.14,20.68 79.01,20.56 79.01,20.43 79.23,20.22 79.31,20.13 79.31,20.01 79.31,18.06 79.21,17.96 v2(78.88,17.96)
  BOTTOM w0.076: UC1.AL68 134.68,60.7 134.47,60.5 133.96,60.5 133.8,60.42 133.62,60.42 133.46,60.48 133.31,60.48 133.1,60.41 132.98,60.41 132.9,60.45 132.87,60.46 132.36,60.46 132.12,60.22 131.65,60.22 v2(131.44,60.42)
  BOTTOM w0.102: v2(78.88,17.96) 79.37,18.46 JDIMM1.3
DDR_A_D2: length 82.7
  IN1 w0.089: v2(126.38,58.37) 125.42,57.42 121.02,57.42 117.56,53.96 117.56,52.08 101.25,35.77 100.31,35.77 100.12,35.59 100.12,35.46 100.46,35.12 100.46,35 100.34,34.87 100.21,34.87 99.87,35.21 99.75,35.21 99.62,35.08 99.62,34.96 99.82,34.76 99.82,34.63 99.69,34.51 99.57,34.51 99.37,34.71 99.24,34.71 91.61,27.07 87.9,23.36 87.9,23.24 88.24,22.89 88.24,22.77 88.12,22.64 87.99,22.64 87.65,22.99 87.52,22.99 87.4,22.86 87.4,22.73 87.74,22.39 87.74,22.26 87.61,22.14 87.49,22.14 87.14,22.48 87.02,22.48 86.89,22.36 86.89,22.23 87.24,21.89 87.24,21.76 87.11,21.64 86.99,21.64 86.64,21.98 86.52,21.98 86.39,21.85 86.39,21.73 86.73,21.38 86.73,21.26 86.61,21.13 86.48,21.13 86.14,21.48 86.01,21.48 85.89,21.35 85.89,21.23 86.23,20.88 86.23,20.76 86.11,20.63 85.98,20.63 85.64,20.97 85.51,20.97 85.34,20.8 85.34,20.68 85.45,20.57 85.45,20.44 85.32,20.32 85.2,20.32 85.09,20.42 84.96,20.42 84.83,20.3 84.83,20.17 84.94,20.06 84.94,19.94 84.82,19.81 84.69,19.81 84.58,19.92 84.46,19.92 84.11,19.57 84.11,19.22 84.02,19.13 83.84,19.13 83.76,19.04 83.76,18.84 83.84,18.75 84.02,18.75 84.11,18.66 84.11,17.52 84.02,17.43 83.84,17.43 83.76,17.52 83.76,17.8 83.67,17.89 v2(83.37,17.89)
  BOTTOM w0.076: UC1.AN68 134.68,60.13 134.1,59.84 133.6,59.84 133.37,59.6 132.43,59.6 132.39,59.55 131.43,59.55 131.43,59.56 131.16,59.56 131.16,59.55 131.01,59.55 130.5,59.05 128.09,59.05 128.07,59.02
  BOTTOM w0.102: JDIMM1.21 83.87,18.39 v2(83.37,17.89) ; v2(126.38,58.37) 126.43,58.32 127.37,58.32 128.07,59.02
DDR_A_D3: length 82.3
  IN1 w0.089: v2(82.31,13.92) 81.65,14.58 81.65,15.09 82.38,15.83 82.38,18.71 91,27.32 100.05,36.38 100.56,36.38 101,36.38 116.95,52.33 116.95,54.22 121.46,58.73 124.61,58.73 124.7,58.82 124.7,59.07 124.61,59.16 123.67,59.16 123.58,59.25 123.58,60.04 123.67,60.13 123.87,60.13 123.96,60.04 123.96,59.68 124.05,59.59 124.41,59.59 124.5,59.68 v2(124.5,60.23)
  BOTTOM w0.076: UC1.AN69 133.92,60.23 133.67,60.23 133.63,60.24 133.48,60.29 133.29,60.29 133.13,60.25 132.93,60.25 132.83,60.29 132.43,60.29 132.19,60.05 131.64,60.05 131.63,60.05 130.75,60.05 130.24,59.54 127.06,59.54 126.96,59.44 126.12,59.44
  BOTTOM w0.102: 126.12,59.44 125.28,59.44 v2(124.5,60.23) ; v2(82.31,13.92) 82.76,13.47 82.76,12.91 82.62,12.77 JDIMM1.16
DDR_A_D4: length 81.9
  IN1 w0.089: v2(80.61,14.63) 79.93,15.31 79.93,19.71 82.09,21.87 82.74,21.87 94.92,34.05 95.6,34.05 99.43,37.88 100.37,37.88 115.45,52.96 115.45,54.84 117.15,56.54 122.34,61.73 127.11,61.73 128.34,60.5 v2(128.34,60.34)
  BOTTOM w0.076: v2(128.34,60.34) 129.17,61.17 130.82,61.17 131.27,61.62 132.81,61.62 132.93,61.59 133.05,61.53 133.23,61.35 UC1.AL70
  BOTTOM w0.102: JDIMM1.4 79.62,13.65 v2(80.61,14.63)
DDR_A_D5: length 82.5
  IN1 w0.089: v2(127.69,60.34) 126.6,61.43 122.46,61.43 115.75,54.71 115.75,52.83 100.5,37.58 99.56,37.58 95.68,33.7 95.01,33.7 83.37,22.07 83.37,21.4 82.15,20.17 80.85,20.17 80.24,19.56 80.24,16.2 80.56,15.88 80.77,15.88 81.29,15.36 81.29,13.7 v2(80.62,13.03)
  BOTTOM w0.076: v2(127.69,60.34) 128.68,61.34 130.75,61.34 131.2,61.79 132.84,61.79 132.86,61.78 132.92,61.76 132.99,61.75 133.07,61.74 133.2,61.7 133.37,61.7 133.56,61.62 133.82,61.35 UC1.AL69
  BOTTOM w0.102: JDIMM1.8 v2(80.62,13.03)
DDR_A_D6: length 81.2
  IN1 w0.089: v2(83.37,16.36) 83.76,16.36 84.43,17.03 84.43,18.98 85.54,20.1 86,20.1 88.24,22.33 88.24,22.33 88.74,22.83 88.74,22.96 88.47,23.23 88.47,23.36 88.59,23.48 88.72,23.48 88.99,23.21 89.12,23.21 89.24,23.33 89.24,23.46 88.91,23.8 88.91,23.92 89.03,24.05 89.16,24.05 89.49,23.71 89.62,23.71 89.75,23.84 89.75,23.96 89.4,24.31 89.4,24.43 89.53,24.57 89.65,24.57 90,24.21 90.12,24.21 90.25,24.34 90.25,24.47 89.94,24.78 89.94,24.9 90.06,25.03 90.19,25.03 90.5,24.72 90.63,24.72 90.75,24.84 90.75,24.97 90.44,25.28 90.44,25.41 90.57,25.53 90.69,25.53 91,25.22 91.13,25.22 91.25,25.35 91.25,25.47 90.95,25.77 90.95,25.9 91.08,26.02 91.21,26.02 91.51,25.72 91.63,25.72 91.76,25.85 91.76,25.98 91.65,26.08 91.65,26.2 91.81,26.36 91.81,26.84 91.91,26.94 99.03,34.07 99.97,34.07 117.86,51.95 117.86,53.84 121.14,57.12 125.84,57.12 127.42,58.7 v2(127.42,59.01)
  BOTTOM w0.076: UC1.AN70 133.11,59.76 132.37,59.76 132.33,59.72 131.5,59.72 130.93,59.72 130.42,59.21 127.62,59.21 v2(127.42,59.01)
  BOTTOM w0.102: JDIMM1.17 82.87,16.86 v2(83.37,16.36)
DDR_A_D7: length 80.2
  IN1 w0.089: v2(125.08,58.37) 125.08,57.93 124.88,57.73 124.61,57.73 124.52,57.81 124.52,58.28 124.43,58.37 124.25,58.37 124.16,58.28 124.16,57.81 124.07,57.73 123.89,57.73 123.81,57.81 123.81,58.28 123.72,58.37 123.54,58.37 123.45,58.28 123.45,57.81 123.36,57.73 123.18,57.73 123.09,57.81 123.09,58.28 123.01,58.37 122.83,58.37 122.74,58.28 122.74,57.81 122.65,57.73 122.47,57.73 122.38,57.81 122.38,58.18 122.29,58.27 122.12,58.27 122.03,58.18 122.03,57.81 121.94,57.73 120.89,57.73 117.25,54.09 117.25,52.21 101.12,36.08 100.43,36.08 100.43,36.08 100.18,36.08 91.3,27.2 82.89,18.79 82.89,13.54 83.35,13.08 v2(83.81,13.08)
  BOTTOM w0.076: 126.5,59.26 127.01,59.26 127.13,59.38 130.33,59.38 130.84,59.89 131.02,59.89 132.26,59.89 132.4,60.03 UC1.AN71
  BOTTOM w0.102: JDIMM1.20 83.62,12.9 v2(83.81,13.08) ; 126.5,59.26 126.22,58.98 125.69,58.98 v2(125.08,58.37)
DDR_A_D8: length 75
  IN1 w0.089: v2(85.46,13.03) 85.64,12.86 85.83,12.86 85.91,12.95 85.91,14.9 85.83,14.99 85.67,14.99 85.58,15.08 85.58,15.31 85.67,15.4 85.83,15.4 85.91,15.49 85.91,15.66 85.83,15.75 85.34,15.75 85.25,15.84 85.25,18.67 85.69,19.1 86.15,19.1 118.83,51.79 118.83,53.67 121.47,56.32 126.3,56.32 127.1,57.11 127.71,57.11 128.39,57.79 v2(128.39,58.16)
  BOTTOM w0.076: v2(128.39,58.16) 128.95,58.72 130.76,58.72 131.04,59 131.05,59 131.28,59.22 132.53,59.22 132.57,59.27 132.96,59.27 133.23,59 UC1.AR70
  BOTTOM w0.102: JDIMM1.28 85.62,12.87 v2(85.46,13.03)
DDR_A_D9: length 76.2
  IN1 w0.089: v2(127.34,57.51) 127.25,57.41 126.97,57.41 126.18,56.62 121.35,56.62 118.53,53.8 118.53,51.92 86.18,19.57 85.72,19.57 84.92,18.77 84.92,15.97 84.83,15.88 84.68,15.88 84.59,15.79 84.59,15.56 84.68,15.47 84.87,15.47 84.96,15.38 84.96,14.93 85.23,14.66 v2(85.43,14.66)
  BOTTOM w0.076: 128.25,58.78 128.35,58.88 130.68,58.88 131.19,59.39 131.22,59.39 132.46,59.39 132.5,59.43 133.37,59.43 133.6,59.19 134.15,59.19 UC1.AR68
  BOTTOM w0.102: 128.25,58.78 127.34,57.87 v2(127.34,57.51) ; v2(85.43,14.66) 84.62,13.85 JDIMM1.24
DDR_A_D10: length 73.6
  IN1 w0.089: v2(129.68,56.39) 129.68,55.84 127.5,53.66 127.5,51.13 126.96,50.59 126.96,50.18 123.66,46.88 121.38,46.88 121.13,46.88 116.48,46.88 88.45,18.86 88.45,17.97 88.37,17.89 88.11,17.89 88.02,17.8 88.02,17.62 88.11,17.53 88.37,17.53 88.45,17.44 88.45,17.24 88.37,17.15 87.45,17.15 87.36,17.06 87.36,16.83 87.45,16.74 88.24,16.74 88.33,16.65 88.33,16.45 88.24,16.36 87.43,16.36 87.34,16.27 87.34,15.94 87.43,15.85 87.62,15.85 v2(87.69,15.93)
  BOTTOM w0.076: v2(129.68,56.39) 129.68,56.67 129.98,56.98 130.28,56.98 130.59,57.28 131.69,57.28 132,57.59 132.64,57.59 UC1.AU71
  BOTTOM w0.102: JDIMM1.38 88.12,15.42 87.69,15.85 v2(87.69,15.93)
DDR_A_D11: length 75.2
  IN1 w0.089: v2(131.33,58.3) 132.69,56.93 132.69,54.76 130.92,52.99 130.78,52.99 128.13,50.34 127.88,50.09 127.88,49.8 124.04,45.97 121,45.97 120.75,45.97 116.86,45.97 99.13,28.24 99.13,27.68 90.26,18.81 90.26,15.52 89.98,15.24 89.05,15.24 88.96,15.15 88.96,13.99 89.05,13.9 v2(89.55,13.9)
  BOTTOM w0.076: v2(131.33,58.3) 131.33,58.29 131.77,58.73 132.34,58.73 132.5,58.57 132.87,58.57 132.9,58.58 132.98,58.61 133.1,58.61 133.31,58.55 133.46,58.55 133.62,58.61 134.21,58.61 134.23,58.63 134.47,58.63 134.68,58.42 UC1.AU68
  BOTTOM w0.102: JDIMM1.42 89.12,13.48 v2(89.55,13.9)
DDR_A_D12: length 73.6
  IN1 w0.089: v2(128.99,58.16) 128.99,57.95 127.84,56.8 127.22,56.8 126.43,56.01 121.6,56.01 119.14,53.55 119.14,52.63 119.14,51.66 119.14,50.49 119.05,50.4 118.11,50.4 118.02,50.31 118.02,50.13 118.11,50.04 119.05,50.04 119.14,49.95 119.14,49.78 119.05,49.69 117.4,49.69 117.31,49.6 117.31,49.39 117.4,49.31 119.05,49.31 119.14,49.22 119.14,49.16 119.14,49.15 119.14,49.04 119.05,48.95 116.42,48.95 85.99,18.52 v2(85.69,18.52)
  BOTTOM w0.076: UC1.AR71 132.67,59.06 131.35,59.06 131.12,58.83 131.11,58.83 130.83,58.55 129.38,58.55 v2(128.99,58.16)
  BOTTOM w0.102: v2(85.69,18.52) 85.87,18.71 JDIMM1.29
DDR_A_D13: length 75.3
  IN1 w0.089: v2(85.69,17) 86.09,17.4 86.09,18.19 116.55,48.64 120.9,48.64 120.99,48.73 120.99,48.99 120.9,49.08 119.65,49.08 119.44,49.28 119.44,53.42 121.73,55.71 126.55,55.71 127.35,56.5 128.63,56.5 v2(130.29,58.16)
  BOTTOM w0.076: UC1.AR69 133.92,58.8 133.67,58.8 133.45,58.72 133.32,58.72 133.09,58.79 132.99,58.79 132.98,58.79 132.97,58.79 132.95,58.79 132.83,58.73 132.57,58.73 132.41,58.89 131.42,58.89 131.19,58.67 131.18,58.67 130.96,58.45 130.96,58.44 130.84,58.32 130.45,58.32 v2(130.29,58.16)
  BOTTOM w0.102: v2(85.69,17) 84.87,17.81 JDIMM1.25
DDR_A_D14: length 73.7
  IN1 w0.089: v2(88.87,18.65) 89.6,19.37 89.84,19.37 90.03,19.56 90.03,19.68 89.93,19.78 89.93,19.9 90.06,20.03 90.18,20.03 90.34,19.87 90.46,19.87 90.59,20 90.59,20.12 90.43,20.28 90.43,20.4 90.56,20.53 90.69,20.53 90.84,20.38 90.96,20.38 91.09,20.5 91.09,20.63 90.94,20.78 90.94,20.91 91.06,21.03 91.19,21.03 91.34,20.88 91.47,20.88 91.59,21.01 91.59,21.13 91.44,21.28 91.44,21.41 91.57,21.54 91.69,21.54 91.84,21.38 91.97,21.38 92.1,21.51 92.1,21.63 91.94,21.79 91.94,21.91 92.07,22.04 92.19,22.04 92.35,21.89 92.47,21.89 92.6,22.01 92.6,22.14 92.45,22.29 92.45,22.42 92.57,22.54 92.7,22.54 92.85,22.39 92.98,22.39 93.1,22.51 93.1,22.64 92.95,22.79 92.95,22.92 93.07,23.04 93.2,23.04 93.35,22.89 93.48,22.89 93.6,23.02 93.6,23.14 93.45,23.3 93.45,23.42 93.58,23.55 93.7,23.55 93.86,23.39 93.98,23.39 94.11,23.52 94.11,23.65 93.95,23.8 93.95,23.92 94.08,24.05 94.21,24.05 94.36,23.9 94.48,23.9 94.61,24.02 94.61,24.15 94.46,24.3 94.46,24.43 94.58,24.55 94.71,24.55 94.86,24.4 94.99,24.4 95.11,24.53 95.11,24.65 94.96,24.8 94.96,24.93 95.09,25.06 95.21,25.06 95.37,24.9 95.49,24.9 95.62,25.03 95.62,25.15 95.46,25.31 95.46,25.43 95.59,25.56 95.71,25.56 95.87,25.41 95.99,25.41 96.12,25.53 96.12,25.66 95.97,25.81 95.97,25.94 96.09,26.06 96.22,26.06 96.37,25.91 96.5,25.91 96.62,26.03 96.62,26.16 96.47,26.31 96.47,26.44 96.6,26.56 96.72,26.56 96.87,26.41 97,26.41 97.13,26.54 97.13,26.66 96.97,26.82 96.97,26.94 97.1,27.07 97.22,27.07 97.38,26.91 97.5,26.91 97.63,27.04 97.63,27.17 97.48,27.32 97.48,27.44 97.6,27.57 97.73,27.57 97.88,27.42 98.01,27.42 98.13,27.54 98.13,27.67 97.98,27.82 97.98,27.95 116.61,46.58 121,46.58 121.26,46.58 123.79,46.58 127.27,50.06 127.27,50.46 127.81,51 127.81,53.54 130.25,55.98 130.25,56.48 v2(130.29,56.52)
  BOTTOM w0.076: v2(130.29,56.52) 130.29,56.63 130.78,57.12 131.76,57.12 132.05,57.41 133.11,57.41 UC1.AU70
  BOTTOM w0.102: JDIMM1.41 v2(88.87,18.65)
DDR_A_D15: length 73.9
  IN1 w0.089: v2(88.86,17.12) 89.55,16.44 89.55,16.09 89.41,15.96 88.42,15.96 88.33,15.87 88.33,15.64 88.42,15.55 89.85,15.55 89.95,15.65 89.95,18.68 89.95,18.68 89.95,18.93 90.03,19.01 98.82,27.8 98.82,28.36 116.73,46.27 120.88,46.27 121.13,46.27 123.91,46.27 127.57,49.93 127.57,50.08 127.57,50.33 130.53,53.29 130.8,53.29 132.39,54.89 132.39,55.45 131.66,56.18 v2(131.66,56.75)
  BOTTOM w0.076: v2(131.66,56.75) 132.15,57.24 133.39,57.24 133.82,57.67 UC1.AU69
  BOTTOM w0.102: JDIMM1.37 87.87,18.11 v2(88.86,17.12)
DDR_A_D16: length 71.1
  IN4 w0.089: v2(128.61,13.31) 127.99,13.94 127.99,25.36 125.36,27.98 125.36,41.9 117.48,49.78 117.48,54.45 121.99,58.96 126.32,58.96 126.75,59.39 129.72,59.39 134.12,63.79 135.74,63.79 v2(136.31,63.22)
  BOTTOM w0.076: UC1.AF65 136.63,63.54 v2(136.31,63.22)
  BOTTOM w0.102: JDIMM1.194 129.12,12.8 v2(128.61,13.31)
DDR_A_D17: length 69.6
  IN4 w0.076: v2(136.97,63.22) 136.56,62.82 135.02,62.82 133.51,61.31 133.51,60.94 132.5,59.92
  IN4 w0.089: v2(129.09,18.42) 129.09,23.94 129.18,24.03 129.84,24.03 129.93,24.11 129.93,24.29 129.84,24.38 129.18,24.38 129.09,24.47 129.09,24.65 129.18,24.74 129.84,24.74 129.93,24.83 129.93,25 129.84,25.09 129.18,25.09 129.09,25.18 129.09,25.36 129.18,25.45 129.84,25.45 129.93,25.54 129.93,25.71 129.84,25.8 129.18,25.8 129.09,25.89 129.09,26.73 127.35,28.48 127.35,29.59 126.38,30.56 126.38,42.17 118.39,50.16 118.39,54.07 121.43,57.11 125.71,57.11 125.74,57.13 127.58,57.13 127.85,57.41 128.1,57.41 128.35,57.66 130.46,57.66 130.82,58.02 130.82,58.45 131.48,59.11 131.68,59.11 132.5,59.92
  BOTTOM w0.076: UC1.AF64 137.02,63.44 137.02,63.28 v2(136.97,63.22)
  BOTTOM w0.102: JDIMM1.195 129.37,18.7 v2(129.09,18.42)
DDR_A_D18: length 69.8
  IN4 w0.076: v2(136.94,61.41) 136.39,60.86 135.16,60.86 134.85,60.55
  IN4 w0.089: v2(132.17,13.49) 132.74,13.49 132.83,13.4 132.83,13.24 132.92,13.15 133.55,13.15 133.64,13.24 133.64,13.63 133.35,13.92 132.88,13.92 132.73,14.08 132.73,16.04 132.19,16.58 132.19,28.43 129.65,30.97 129.65,37.38 129.56,37.47 129.31,37.47 129.22,37.56 129.22,37.74 129.31,37.82 129.54,37.82 129.63,37.91 129.63,38.12 129.54,38.21 128.76,38.21 128.67,38.3 128.67,38.47 128.76,38.56 129.56,38.56 129.65,38.65 129.65,38.83 129.56,38.92 128.76,38.92 128.67,39.01 128.67,39.18 128.76,39.27 129.56,39.27 129.65,39.36 129.65,39.55 129.56,39.63 128.76,39.63 128.67,39.72 128.67,39.9 128.76,39.98 129.56,39.98 129.65,40.07 129.65,40.26 129.56,40.34 128.76,40.34 128.67,40.43 128.67,40.61 128.76,40.7 129.46,40.7 129.55,40.78 129.55,40.96 129.46,41.05 128.76,41.05 128.67,41.14 128.67,44.46 127.07,46.06 127.07,53.57 128.31,54.81 128.77,54.81 129.07,55.12 130.33,55.12 131.06,55.84 132.28,55.84 133.34,56.9 133.34,57.04 134.85,58.55 134.85,60.55
  BOTTOM w0.076: UC1.AK65 v2(136.94,61.41)
  BOTTOM w0.102: JDIMM1.204 131.62,12.95 v2(132.17,13.49)
DDR_A_D19: length 71.3
  IN4 w0.076: v2(137.58,61.41) 137.21,61.78 137.1,61.78 137.09,61.78 136.79,61.78 136.79,61.78 136.46,61.78 136.46,61.78 135.52,61.78 135.52,61.78 135.51,61.78 135.09,61.35 134.95,61.35 133.64,60.04 133.64,58.39 132.55,57.31 131.6,57.31 131.4,57.1 130.14,57.1 129.88,56.85 129.02,56.85 128.56,56.39 127.06,56.39 126.77,56.1
  IN4 w0.089: 126.77,56.1 126.21,55.54 121.56,55.54 119.59,53.57 119.59,50.65 127.58,42.66 127.58,31.06 128.88,29.75 128.88,29.47 128.58,29.17 128.58,29.04 128.71,28.92 128.83,28.92 129.39,29.48 129.52,29.48 129.64,29.35 129.64,29.23 129.03,28.61 129.03,28.49 129.16,28.36 129.28,28.36 129.83,28.91 129.96,28.91 130.08,28.79 130.08,28.66 129.53,28.11 129.53,27.99 129.66,27.86 129.79,27.86 130.13,28.2 130.26,28.2 130.38,28.08 130.38,27.88 130.14,27.64 130.14,27.49 130.31,27.31 130.44,27.31 130.52,27.39 130.87,27.39 131.27,26.98 131.27,18.19 131,17.91 v2(130.85,17.91)
  BOTTOM w0.076: UC1.AK64 v2(137.58,61.41)
  BOTTOM w0.102: JDIMM1.203 131.37,18.44 v2(130.85,17.91)
DDR_A_D20: length 70.6
  IN4 w0.089: v2(135.7,63.22) 135.31,63.62 134.91,63.62 132.98,61.69 132.98,61.2 131.69,59.91 131.22,59.91 130.3,58.99 127.93,58.99 126.68,57.74 121.21,57.74 117.78,54.32 117.78,49.9 125.67,42.02 125.67,28.11 126.06,27.72 126.71,27.72 128.29,26.13 128.29,15.07 128.52,14.84 v2(128.69,14.84)
  BOTTOM w0.076: v2(135.7,63.22) 135.7,63.42 UC1.AF66
  BOTTOM w0.102: JDIMM1.190 128.12,14.27 v2(128.69,14.84)
DDR_A_D21: length 70.3
  IN4 w0.076: v2(135.06,63.24) 133.33,61.51 133.33,61.14
  IN4 w0.089: 133.33,61.14 131.83,59.65 131.36,59.65 130.4,58.69 127.99,58.69 126.71,57.41 121.31,57.41 118.09,54.19 118.09,50.03 126.08,42.04 126.08,29.55 126.17,29.46 126.87,29.46 126.96,29.37 126.96,29.19 126.87,29.11 126.17,29.11 126.08,29.02 126.08,28.84 126.17,28.75 126.87,28.75 126.96,28.66 126.96,28.48 126.87,28.39 126.17,28.39 126.08,28.31 126.08,28.13 126.17,28.04 126.81,28.04 128.6,26.25 128.6,17.43 129.04,16.98 v2(129.04,16.89)
  BOTTOM w0.076: v2(135.06,63.24) 135.06,63.29 135.33,63.55 UC1.AF67
  BOTTOM w0.102: JDIMM1.191 128.37,19.06 128.26,18.94 128.26,17.68 v2(129.04,16.89)
DDR_A_D22: length 68.8
  IN4 w0.076: v2(135.67,61.41) 135.45,61.19 135.02,61.19 134.52,60.69 134.52,60.55 133.8,59.84 133.8,58.05 133.01,57.25 133.01,57.04 132.2,56.23 131.81,56.23
  IN4 w0.089: 131.81,56.23 130.81,56.23 130.18,55.6 128.87,55.6 128.7,55.43 128.07,55.43 126.46,53.82 126.46,45.54 126.78,45.22 127.93,44.07 127.93,34.54 128.01,34.45 128.5,34.45 128.59,34.36 128.59,34.18 128.5,34.09 128.01,34.09 127.93,34 127.93,33.83 128.01,33.74 128.95,33.74 129.04,33.65 129.04,33.46 128.95,33.38 128.01,33.38 127.93,33.29 127.93,33.11 128.01,33.03 128.88,33.03 128.97,32.94 128.97,32.76 128.88,32.67 128.01,32.67 127.93,32.58 127.93,32.4 128.01,32.31 128.93,32.31 129.02,32.22 129.02,32.05 128.93,31.96 128.04,31.96 127.95,31.87 127.95,31.72 128.04,31.63 128.9,31.63 128.99,31.54 128.99,31.33 128.9,31.25 128.27,31.25 128.18,31.16 128.18,30.98 128.27,30.89 128.82,30.89 128.92,30.79 128.92,30.24 129.01,30.15 129.32,30.15 130.52,28.96 130.52,28.77 130.4,28.65 130.4,28.52 130.52,28.4 130.65,28.4 130.8,28.55 130.93,28.55 131.05,28.42 131.05,28.3 130.72,27.97 130.72,27.84 130.85,27.71 130.97,27.71 131.3,28.05 131.43,28.05 131.58,27.89 131.58,17.05 v2(130.92,16.39)
  BOTTOM w0.076: UC1.AK67 v2(135.67,61.41)
  BOTTOM w0.102: JDIMM1.207 132.37,17.84 v2(130.92,16.39)
DDR_A_D23: length 69.5
  IN4 w0.076: v2(136.31,61.41) 135.92,61.02 135.09,61.02 134.68,60.62 134.68,60.48 133.97,59.77 133.97,57.97 133.17,57.17 133.17,56.97 132.24,56.04 132.03,56.04
  IN4 w0.089: v2(132.19,15.04) 131.29,15.04 131.2,15.13 131.2,15.43 131.29,15.52 132.22,15.52 132.31,15.61 132.31,15.82 132.22,15.9 131.44,15.9 131.36,15.99 131.36,16.25 131.44,16.34 131.8,16.34 131.89,16.42 131.89,28.3 129.34,30.84 129.34,34.05 129.25,34.14 128.98,34.14 128.89,34.23 128.89,34.45 128.98,34.54 129.26,34.54 129.34,34.62 129.34,34.81 129.26,34.89 128.42,34.89 128.33,34.98 128.33,35.16 128.42,35.25 129.21,35.25 129.3,35.34 129.3,35.51 129.21,35.6 128.42,35.6 128.33,35.69 128.33,35.87 128.42,35.96 129.26,35.96 129.34,36.04 129.34,36.23 129.26,36.31 128.42,36.31 128.33,36.4 128.33,36.58 128.42,36.67 129.23,36.67 129.32,36.76 129.32,36.94 129.23,37.03 128.42,37.03 128.33,37.11 128.33,37.29 128.42,37.38 128.83,37.38 128.92,37.47 128.92,37.65 128.83,37.74 128.42,37.74 128.33,37.83 128.33,44.35 126.77,45.92 126.77,53.7 128.21,55.14 128.81,55.14 129.1,55.42 130.31,55.42 130.92,56.04 132.03,56.04
  BOTTOM w0.076: UC1.AK66 v2(136.31,61.41)
  BOTTOM w0.102: v2(132.19,15.04) 132.62,14.61 JDIMM1.208
DDR_A_D24: length 73.4
  IN4 w0.084: 130.74,62.95 130.46,63.23 129.47,63.23 v2(128.81,63.88)
  IN4 w0.089: v2(126.68,13.39) 126.1,13.97 126.1,17.93 125.92,18.11 125.92,25.07 123.86,27.13 123.86,35.82 122.95,36.73 122.95,41.38 116.04,48.29 116.04,55.08 122.12,61.16 129.14,61.16 130.74,62.77 130.74,62.95
  BOTTOM w0.076: UC1.AF70 133.27,64.11 133.06,64.11 132.89,64.28 132.73,64.28 132.43,64.58 131.04,64.58
  BOTTOM w0.102: 131.04,64.58 129.51,64.58 v2(128.81,63.88) ; JDIMM1.186 127.12,12.95 v2(126.68,13.39)
DDR_A_D25: length 75.5
  IN4 w0.084: v2(127.59,63.93) 126.96,63.31 123.88,63.31
  IN4 w0.089: 123.88,63.31 121.27,63.31 115.31,57.35 113.93,55.96 113.93,48.35 113.93,48.34 113.93,48.17 113.93,47.41 120.83,40.5 120.83,35.75 121.68,34.91 121.68,18.8 120.71,17.83 120.71,15.22 121.33,14.6 121.6,14.6 121.78,14.42 121.95,14.42 122.57,13.8 122.87,13.8 123.02,13.95 123.15,13.95 123.27,13.82 123.27,13.7 123.03,13.46 123.03,13.33 123.2,13.16 v2(124.04,13.16)
  BOTTOM w0.076: 131.36,64.9 132.36,64.9 132.81,64.46 132.94,64.46 133.13,64.27 133.53,64.27 133.6,64.2 134.07,64.2 134.14,64.18 134.65,63.92 UC1.AF68
  BOTTOM w0.102: 131.36,64.9 128.56,64.9 v2(127.59,63.93) ; JDIMM1.174 124.12,13.08 v2(124.04,13.16)
DDR_A_D26: length 72.7
  IN4 w0.089: v2(127.67,62.74) 127.25,62.32 126.33,62.32 126.2,62.19 124.65,62.19 124.52,62.32 124.49,62.32 124.45,62.36 121.62,62.36 114.84,55.58 114.84,47.79 121.75,40.88 121.75,36.13 122.66,35.22 122.66,26.63 124.5,24.8 124.5,23.64 124.41,23.55 123.93,23.55 123.84,23.46 123.84,23.28 123.93,23.19 124.43,23.19 124.52,23.1 124.52,22.93 124.43,22.84 123.21,22.84 123.13,22.75 123.13,22.57 123.21,22.48 123.58,22.48 123.67,22.39 123.67,22.22 123.58,22.13 123.21,22.13 123.13,22.04 123.13,21.86 123.21,21.77 123.58,21.77 123.67,21.68 123.67,21.5 123.58,21.41 123.21,21.41 123.13,21.33 123.13,21.15 123.21,21.06 123.58,21.06 123.67,20.97 123.67,20.79 123.58,20.7 123.21,20.7 123.13,20.61 123.13,20.44 123.21,20.35 123.58,20.35 123.67,20.26 123.67,20.08 123.58,19.99 123.21,19.99 123.13,19.9 123.13,19.73 123.21,19.64 123.58,19.64 123.67,19.55 123.67,19.37 123.58,19.28 123.21,19.28 123.13,19.19 123.13,18.34 v2(123.53,17.94)
  BOTTOM w0.076: 128.66,62.31 128.76,62.31 129.09,61.98 130.63,61.98 131.33,62.68 UC1.AH71
  BOTTOM w0.102: v2(127.67,62.74) 128.1,62.31 128.66,62.31 ; JDIMM1.173 123.87,18.91 124.09,18.7 124.09,18.14 123.89,17.94 v2(123.53,17.94)
DDR_A_D27: length 75.1
  IN4 w0.089: v2(126.91,16.36) 126.91,15.33 127,15.24 127.41,15.24 127.49,15.33 127.49,19.04 127.41,19.13 127.02,19.13 126.94,19.22 126.94,19.4 127.02,19.49 127.41,19.49 127.49,19.58 127.49,19.76 127.41,19.84 127,19.84 126.91,19.93 126.91,20.11 127,20.2 127.41,20.2 127.49,20.29 127.49,25.12 124.87,27.75 124.87,41.69 116.95,49.6 116.95,54.7 121.7,59.45 126.11,59.45 126.23,59.57 129.65,59.57 131.38,61.3 v2(131.38,63.83)
  BOTTOM w0.076: v2(131.38,63.83) 131.53,63.98 132.1,63.98 132.5,63.57 132.86,63.57 132.86,63.57 132.95,63.61 133.15,63.61 133.24,63.57 133.24,63.57 133.24,63.57 133.25,63.57 133.48,63.57 133.6,63.61 133.92,63.61 134.02,63.54 134.47,63.54 134.68,63.33 UC1.AH68
  BOTTOM w0.102: JDIMM1.183 126.37,16.9 v2(126.91,16.36)
DDR_A_D28: length 72.6
  IN4 w0.084: 129.86,63.46 v2(129.44,63.88)
  IN4 w0.089: 129.86,63.46 130.48,63.46 130.92,63.02 130.92,62.69 129.21,60.98 124.14,60.98 123.66,60.51 121.9,60.51 116.34,54.96 116.34,48.42 123.25,41.51 123.25,37.52 123.46,37.31 124.17,37.31 124.26,37.23 124.26,37.01 124.17,36.92 123.77,36.92 123.68,36.83 123.68,36.66 123.77,36.57 124.17,36.57 124.26,36.48 124.26,27.5 126.22,25.53 126.22,18.24 126.43,18.04 126.43,15.16 v2(126.66,14.93)
  BOTTOM w0.076: 130.82,64.27 130.92,64.37 132.36,64.37 UC1.AF71
  BOTTOM w0.102: v2(129.44,63.88) 129.82,64.27 130.82,64.27 ; v2(126.66,14.93) 126.12,14.4 JDIMM1.182
DDR_A_D29: length 74.4
  IN4 w0.089: v2(130.72,63.86) 130.72,63.47 131.1,63.1 131.1,61.27 129.7,59.87 126.1,59.87 125.99,59.76 121.58,59.76 116.65,54.83 116.65,48.54 123.61,41.58 123.61,41.37 123.7,41.28 124,41.28 124.09,41.19 124.09,40.96 124,40.87 123.7,40.87 123.61,40.78 123.61,40.59 123.71,40.49 124.38,40.49 124.47,40.4 124.47,40.19 124.38,40.1 123.67,40.1 123.58,40.01 123.58,39.84 123.67,39.75 124.38,39.75 124.47,39.66 124.47,39.48 124.38,39.39 123.67,39.39 123.58,39.3 123.58,39.12 123.67,39.04 124.38,39.04 124.47,38.95 124.47,38.77 124.38,38.68 123.67,38.68 123.58,38.59 123.58,38.41 123.67,38.32 124.38,38.32 124.47,38.24 124.47,38.06 124.38,37.97 123.67,37.97 123.58,37.88 123.58,37.7 123.67,37.61 124.38,37.61 124.56,37.44 124.56,27.63 126.53,25.66 126.53,18.37 126.95,17.95 v2(126.95,17.89)
  BOTTOM w0.076: UC1.AF69 133.92,63.81 133.66,63.81 133.56,63.77 133.56,63.77 133.48,63.74 133.27,63.74 133.18,63.77 132.92,63.77 132.83,63.74 132.57,63.74 132.11,64.2 131.19,64.2 130.85,63.86 v2(130.72,63.86)
  BOTTOM w0.102: JDIMM1.187 127.37,18.31 v2(126.95,17.89)
DDR_A_D30: length 73.8
  IN4 w0.089: v2(123.56,17.17) 122.82,17.17 122.29,17.71 122.29,18.27 122.36,18.34 122.36,23.14 122.45,23.22 123.37,23.22 123.46,23.31 123.46,23.49 123.37,23.58 122.68,23.58 122.59,23.67 122.59,23.85 122.68,23.94 124,23.94 124.09,24.02 124.09,24.2 124,24.29 123.14,24.29 123.05,24.38 123.05,24.56 123.14,24.65 123.67,24.65 123.76,24.74 123.76,25.11 122.36,26.51 122.36,35.09 121.44,36.01 121.44,40.76 114.54,47.67 114.54,47.92 114.54,55.71 121.5,62.67 124.61,62.67 124.78,62.49 126.07,62.49 v2(126.4,62.82)
  BOTTOM w0.076: UC1.AH70 133.23,62.68 133.08,62.53 132.88,62.44 132.83,62.41 131.3,62.41 130.7,61.81 128.72,61.81 128.6,61.94
  BOTTOM w0.102: JDIMM1.169 122.87,18.95 123.09,18.74 123.09,17.64 v2(123.56,17.17) ; 128.6,61.94 127.28,61.94 v2(126.4,62.82)
DDR_A_D31: length 74.8
  IN4 w0.089: v2(124.83,14.76) 124.83,15.78 124.7,15.9 124.03,15.9 123.94,15.99 123.94,16.2 124.03,16.29 124.05,16.29 124.14,16.37 124.14,16.63 124.05,16.72 122.77,16.72 121.98,17.5 121.98,35.04 121.14,35.88 121.14,40.63 114.23,47.54 114.23,48.05 114.23,48.05 114.23,48.47 114.23,48.47 114.23,55.83 115.49,57.09 121.37,62.97 125.01,62.97 v2(125.11,62.87)
  BOTTOM w0.076: 128.15,61.5 128.16,61.5 130.62,61.5 131.37,62.25 132.87,62.25 132.94,62.28 133.43,62.28 133.82,62.68 UC1.AH69
  BOTTOM w0.102: v2(124.83,14.76) 124.12,14.76 123.12,13.77 JDIMM1.170 ; 128.15,61.5 126.48,61.5 v2(125.11,62.87)
DDR_A_D32: length 69
  IN1 w0.089: v2(91.63,14.96) 91.86,14.74 92.19,14.74 92.37,14.91 92.37,18.39 92.9,18.93 92.9,19.45 95.61,22.16 97.08,23.63 97.08,23.63 107.6,34.15 107.6,34.71 114.02,41.13 114.58,41.13 118,44.56 120.42,44.56 124.62,44.56 130.39,50.32 v2(130.69,50.32)
  BOTTOM w0.076: 130.81,50.5 130.82,50.5 131.17,50.5 131.94,51.27 131.94,52.1 132.62,52.78 135.24,52.78 136.28,53.81 136.28,53.89 136.38,54 136.38,54.43 UC1.BB65
  BOTTOM w0.102: JDIMM1.46 90.12,13.65 90.13,13.66 90.13,13.82 91.27,14.96 v2(91.63,14.96) ; v2(130.69,50.32) 130.69,50.38 130.81,50.5
DDR_A_D33: length 71.3
  IN1 w0.089: v2(93.66,15.32) 93.66,15.29 94.12,15.75 94.12,18.98 96.14,21 97.58,22.43 108.8,33.66 108.8,34.22 114.52,39.93 115.07,39.93 118.5,43.36 118.5,43.36 119.67,43.36 119.67,43.36 119.92,43.36 125.59,43.36 126.73,44.5 126.73,44.62 126.62,44.73 126.62,44.86 126.75,44.98 126.87,44.98 126.98,44.87 127.1,44.87 128.82,46.59 129.83,46.59 v2(130.54,47.3)
  BOTTOM w0.076: 132.32,49.99 132.32,50.11 132.63,50.42 132.63,51.94 132.96,52.28 135.46,52.28 136.7,53.52 137.25,53.52 137.52,53.79 137.52,54.12 137.38,54.26 137.38,54.67 137.41,54.76 137.41,54.94 137.38,55.06 137.38,55.31 137.41,55.42 137.41,56.13 137.34,56.28 137.13,56.48 UC1.AW65
  BOTTOM w0.102: JDIMM1.62 94.12,14.86 v2(93.66,15.32) ; 132.32,49.99 132.32,49.66 131.99,49.33 131.99,48.72 130.57,47.3 v2(130.54,47.3)
DDR_A_D34: length 71.8
  IN1 w0.089: v2(132.5,49.1) 132.01,49.1 131.51,48.59 131.51,48.33 131.6,48.24 131.98,48.24 132.07,48.15 132.07,47.97 131.98,47.88 131.6,47.88 131.51,47.79 131.51,47.22 129.88,45.6 129.76,45.6 129.37,45.98 129.2,45.98 129.11,45.89 129.11,45.74 129.5,45.35 129.5,45.22 129.38,45.09 129.25,45.09 128.78,45.56 128.66,45.56 128.53,45.44 128.53,45.31 129,44.84 129,44.72 128.87,44.59 128.75,44.59 128.29,45.05 128.17,45.05 128.04,44.92 128.04,44.8 128.5,44.34 128.5,44.21 128.37,44.09 128.25,44.09 127.83,44.5 127.62,44.5 126.54,43.43 126.54,43.3 126.72,43.13 126.72,43.12 126.85,42.99 126.85,42.87 126.73,42.75 126.59,42.75 126.29,43.05 126.17,43.05 125.86,42.75 119.67,42.75 119.42,42.75 118.75,42.75 115.12,39.12 114.56,39.12 109.41,33.96 109.41,33.4 97.83,21.82 96.39,20.39 95.29,19.28 95.29,18.39 v2(94.86,17.96)
  BOTTOM w0.076: 134.89,50.93 134.91,50.96 134.91,51.31 135.21,51.6 135.79,51.6 137.03,52.85 137.51,52.85 138.24,53.58 138.24,55.19 138.02,55.41 138.02,55.95 137.71,56.26 UC1.AW63
  BOTTOM w0.102: 134.89,50.93 133.06,49.1 132.5,49.1 132.5,49.1 v2(132.5,49.1) ; JDIMM1.63 94.37,18.44 v2(94.86,17.96)
DDR_A_D35: length 71.3
  IN1 w0.089: v2(133.11,51.9) 132.7,52.31 130.8,52.31 130.23,51.74 130.23,51.74 128.37,49.88 128.37,49.6 124.24,45.47 120.8,45.47 120.55,45.47 117.06,45.47 106.69,35.09 106.69,34.53 96.7,24.55 90.77,18.61 90.77,16.56 v2(91.1,16.23)
  BOTTOM w0.076: UC1.AY63 137.61,55.73 137.61,55.47 137.54,55.28 137.54,55.1 137.58,54.97 137.58,54.72 137.54,54.64 137.54,54.38 137.68,54.24 137.68,53.72 137.3,53.34 136.76,53.34 135.51,52.1 133.3,52.1 v2(133.11,51.9)
  BOTTOM w0.102: JDIMM1.45 89.87,17.46 v2(91.1,16.23)
DDR_A_D36: length 69.7
  IN1 w0.089: v2(130.69,50.91) 130.54,50.91 124.5,44.86 120.55,44.86 120.29,44.86 120.29,44.86 117.88,44.86 117.88,44.86 114.45,41.44 113.89,41.44 107.3,34.84 107.3,34.28 96.95,23.94 95.3,22.29 92.59,19.58 92.59,19.05 92.06,18.52 92.06,16.26 90.87,15.07 90.87,14.72 90.96,14.63 91.08,14.63 91.17,14.54 91.17,14.36 91.08,14.27 90.91,14.27 90.82,14.18 90.82,13.53 90.91,13.44 v2(91.6,13.44)
  BOTTOM w0.076: 130.81,50.91 131.02,50.91 131.53,51.41 131.53,51.62 131.69,51.77 131.69,52.08 132.56,52.95 135.17,52.95 136.11,53.88 136.11,53.96 136.22,54.07 136.22,54.64 136.33,54.88 136.48,55.03 UC1.BA65
  BOTTOM w0.102: 130.81,50.91 v2(130.69,50.91) ; v2(91.6,13.44) 91.12,12.96 JDIMM1.50
DDR_A_D37: length 70.6
  IN1 w0.089: v2(91.22,17.76) 91.22,17.47 91.31,17.38 91.67,17.38 91.76,17.47 91.76,17.95 91.6,18.1 91.6,18.31 91.76,18.46 91.76,18.65 91.76,18.72 91.59,18.88 91.59,19.01 91.74,19.16 91.87,19.16 92,19.04 92.12,19.04 92.25,19.16 92.25,19.29 92.12,19.41 92.12,19.54 95,22.42 96.83,24.24 106.99,34.41 106.99,34.97 114.15,42.12 114.27,42.12 114.42,41.97 114.55,41.97 114.68,42.09 114.68,42.22 114.52,42.37 114.52,42.5 114.65,42.62 114.77,42.62 114.93,42.47 115.05,42.47 115.18,42.6 115.18,42.72 115.03,42.88 115.03,43 115.15,43.13 115.28,43.13 115.43,42.97 115.56,42.97 115.68,43.1 115.68,43.22 115.53,43.38 115.53,43.5 115.65,43.63 115.78,43.63 115.93,43.48 116.06,43.48 116.19,43.6 116.19,43.73 116.03,43.88 116.03,44.01 116.16,44.13 116.28,44.13 116.44,43.98 116.56,43.98 116.69,44.11 116.69,44.23 116.53,44.38 116.53,44.51 116.66,44.64 116.79,44.64 116.94,44.48 117.07,44.48 117.19,44.61 117.19,44.73 117.04,44.89 117.04,45.01 117.19,45.17 120.42,45.17 120.42,45.17 120.67,45.17 124.37,45.17 128.68,49.47 128.68,49.75 130.54,51.61 130.54,51.61 130.83,51.91 v2(131.3,51.91)
  BOTTOM w0.076: UC1.AY65 136.48,55.63 136.22,55.36 136.22,55.08 136.16,54.95 136.16,54.91 136.13,54.84 136.05,54.67 136.05,54.13 135.95,54.03 135.95,53.95 135.11,53.11 132.29,53.11 132.22,53.04 132.19,53.04 131.48,52.32 131.48,52.32 131.3,52.14 v2(131.3,51.91)
  BOTTOM w0.102: v2(91.22,17.76) 90.72,18.27 90.72,18.75 90.87,18.91 JDIMM1.49
DDR_A_D38: length 70.6
  IN1 w0.089: v2(94.88,16.44) 95.59,17.15 95.59,19.16 95.88,19.45 96.52,20.08 97.96,21.52 109.71,33.28 109.71,33.84 112.1,36.22 112.22,36.22 112.38,36.07 112.5,36.07 112.63,36.19 112.63,36.32 112.47,36.47 112.47,36.6 112.6,36.72 112.73,36.72 112.88,36.57 113,36.57 118.88,42.44 119.29,42.44 119.29,42.44 119.54,42.44 127.16,42.44 127.43,42.71 127.43,42.84 127.02,43.25 127.02,43.37 127.15,43.5 127.27,43.5 127.68,43.09 127.81,43.09 127.93,43.22 127.93,43.34 127.49,43.79 127.49,43.91 127.61,44.04 127.74,44.04 128.18,43.59 128.31,43.59 133.18,48.47 133.18,50 v2(133.05,50.13)
  BOTTOM w0.076: 134.56,51.26 135.06,51.77 135.7,51.77 136.94,53.01 137.44,53.01 138.07,53.65 138.07,54.7 137.81,54.97 UC1.BA63
  BOTTOM w0.102: v2(133.05,50.13) 133.42,50.13 134.56,51.26 ; v2(94.88,16.44) 94.73,16.44 93.37,17.79 JDIMM1.59
DDR_A_D39: length 69.1
  IN1 w0.089: v2(93.64,13.76) 94.03,13.36 94.22,13.36 94.42,13.57 94.42,18.85 96.26,20.69 96.27,20.69 97.06,21.48 109.1,33.53 109.1,34.09 114.59,39.58 115.15,39.58 118.62,43.05 118.63,43.05 119.54,43.05 119.8,43.05 125.71,43.05 128.94,46.28 130.14,46.28 131.2,47.35 131.2,49.94 131.99,50.73 v2(133.13,50.73)
  BOTTOM w0.076: 134.26,51.55 134.64,51.93 135.63,51.93 136.87,53.18 137.37,53.18 137.89,53.69 137.89,54.45 UC1.BB63
  BOTTOM w0.102: JDIMM1.58 93.12,13.25 v2(93.64,13.76) ; v2(133.13,50.73) 133.18,50.73 134.01,51.55 134.26,51.55
