# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D40: length 68.7
  IN1 w0.089: v2(135.36,49.93) 135.07,50.22 134.78,50.22 133.98,49.43 133.98,48.14 127.49,41.64 126.83,41.64 119.21,41.64 96.39,18.82 96.39,16.34 96.51,16.22 97.04,16.22 97.13,16.13 97.13,15.91 97.04,15.82 96.49,15.82 96.18,15.51 96.18,14 v2(95.62,13.44)
  BOTTOM w0.076: v2(135.36,49.93) 135.8,50.37 135.8,51.15 137.14,52.49 137.62,52.49 138.57,53.44 138.57,54.69 138.84,54.96 UC1.BA61
  BOTTOM w0.102: JDIMM1.66 95.12,12.95 v2(95.62,13.44)
DDR_A_D41: length 70.1
  IN1 w0.089: v2(135.36,51.23) 133.68,49.55 133.68,48.26 127.36,41.95 126.95,41.95 126.95,41.95 119.34,41.95 119.34,41.95 119.08,41.95 96.09,18.95 96.09,16.91 95.57,16.39 95.57,16.27 95.66,16.19 96.03,16.19 96.12,16.1 96.12,15.91 96.03,15.82 95.37,15.82 95.28,15.73 95.28,15.53 95.37,15.44 95.78,15.44 95.87,15.35 95.87,15.06 95.78,14.97 95.57,14.97 v2(95.57,14.96)
  BOTTOM w0.076: v2(135.36,51.23) 135.65,51.23 137.1,52.68 137.58,52.68 138.4,53.51 138.4,55.21 138.61,55.42 138.61,55.97 138.94,56.29 UC1.AW61
  BOTTOM w0.102: v2(95.57,14.96) 96.13,14.41 96.13,13.5 96.12,13.5 JDIMM1.70
DDR_A_D42: length 69.3
  IN1 w0.089: v2(99.91,16.36) 99.45,16.82 99.45,18.89 118.43,37.88 119.44,37.88 119.53,37.97 119.53,38.98 119.66,39.1 119.87,39.1 119.96,39.01 119.96,37.89 120.05,37.8 120.23,37.8 120.32,37.89 120.32,39.01 120.4,39.1 120.58,39.1 120.67,39.01 120.67,38.57 120.76,38.48 120.93,38.48 120.94,38.49 120.95,38.49 121.03,38.57 121.03,39.01 121.12,39.1 121.29,39.1 121.38,39.01 121.38,38.66 121.47,38.57 121.65,38.57 121.74,38.66 121.74,39.01 121.83,39.1 128.03,39.1 v2(137.22,48.28)
  BOTTOM w0.076: UC1.BB59 140.26,54.43 140.26,53.54 138.11,51.39 138.11,50.22 137.72,49.83
  BOTTOM w0.102: JDIMM1.79 98.37,19.05 98.49,18.94 98.49,17.78 v2(99.91,16.36) ; 137.72,49.83 137.6,49.71 137.6,48.67 v2(137.22,48.28)
DDR_A_D43: length 70.8
  IN1 w0.089: v2(137.19,48.87) 136.33,48.01 136.33,47.93 127.81,39.4 122.77,39.4 119.53,39.4 99.15,19.02 99.15,14.6 99.24,14.51 99.83,14.51 99.92,14.42 99.92,14.14 99.83,14.05 99.1,14.05 99.01,13.96 99.01,13.71 99.45,13.26 v2(100.49,13.26)
  BOTTOM w0.076: 136.69,50.05 136.69,51.32 137.36,52 137.83,52 139.07,53.24 139.07,54.1 139.27,54.31 139.27,54.66 139.23,54.76 139.23,54.96 139.27,55.04 139.27,55.31 139.23,55.41 139.23,56.18 139.31,56.28 139.51,56.48 UC1.AW59
  BOTTOM w0.102: 136.69,50.05 136.69,49.37 v2(137.19,48.87) ; v2(100.49,13.26) 100.34,13.26 99.62,12.55 JDIMM1.84
DDR_A_D44: length 68.5
  IN1 w0.089: v2(97.55,16.41) 97.4,16.56 96.79,16.56 96.7,16.65 96.7,17.24 96.79,17.33 97.05,17.33 97.14,17.41 97.14,17.59 97.05,17.68 96.79,17.68 96.7,17.77 96.7,17.95 96.79,18.04 97.01,18.04 97.1,18.13 97.1,18.3 97.01,18.39 96.79,18.39 96.7,18.48 96.7,18.7 119.2,41.2 119.39,41.2 119.47,41.13 119.47,40.99 119.56,40.91 119.73,40.91 119.82,40.99 119.82,41.25 119.91,41.34 120.12,41.34 120.21,41.25 120.21,41.01 120.3,40.92 120.48,40.92 120.57,41.01 120.57,41.25 120.65,41.34 126.7,41.34 127.62,41.34 134.29,48.01 134.29,48.49 135.06,49.26 v2(135.36,49.26)
  BOTTOM w0.076: 135.97,50.02 135.97,51.08 137.21,52.33 137.69,52.33 138.74,53.37 138.74,54.43 UC1.BB61
  BOTTOM w0.102: 135.97,50.02 135.97,49.87 v2(135.36,49.26) ; JDIMM1.67 95.37,18.36 97.32,16.41 v2(97.55,16.41)
DDR_A_D45: length 69.9
  IN1 w0.089: v2(134.76,48.11) 134.76,48.05 127.74,41.03 127.47,41.03 127.38,40.94 127.38,40.71 127.3,40.62 127.12,40.62 127.03,40.71 127.03,40.94 126.94,41.03 126.76,41.03 126.67,40.94 126.67,40.68 126.59,40.6 126.4,40.6 126.32,40.68 126.32,40.94 126.23,41.03 126.05,41.03 125.96,40.94 125.96,40.68 125.88,40.6 125.69,40.6 125.61,40.68 125.61,40.94 125.52,41.03 125.34,41.03 125.25,40.94 125.25,40.71 125.16,40.62 124.98,40.62 124.9,40.71 124.9,40.94 124.81,41.03 124.63,41.03 124.54,40.94 124.54,40.71 124.45,40.62 124.27,40.62 124.18,40.71 124.18,40.94 124.1,41.03 123.88,41.03 123.79,40.94 123.79,40.69 123.7,40.6 123.52,40.6 123.44,40.69 123.44,40.94 123.35,41.03 123.17,41.03 123.08,40.94 123.08,40.69 122.99,40.6 122.81,40.6 122.72,40.69 122.72,40.95 122.64,41.03 122.45,41.03 122.37,40.95 122.37,40.69 122.28,40.6 122.09,40.6 122,40.69 122,40.95 121.91,41.03 121.71,41.03 121.63,40.95 121.63,40.69 121.54,40.6 121.37,40.6 121.28,40.69 121.28,40.94 121.19,41.03 121,41.03 120.91,40.94 120.91,40.69 120.82,40.6 119.61,40.6 119.03,40.6 97.69,19.26 97.69,19.02 97.94,18.78 97.94,17.91 97.77,17.75 97.59,17.75 97.5,17.83 v2(97.5,17.94)
  BOTTOM w0.076: UC1.AY61 139.04,55.73 139.04,55.47 139.07,55.37 139.07,55.37 139.1,55.28 139.1,55.08 139.07,54.99 139.07,54.72 139.1,54.63 139.1,54.38 138.9,54.17 138.9,53.3 137.76,52.16 137.29,52.16 136.36,51.23 136.36,49.83
  BOTTOM w0.102: JDIMM1.71 96.37,18.6 97.04,17.94 v2(97.5,17.94) ; 136.36,49.83 136.36,49.42 135.05,48.11 v2(134.76,48.11)
DDR_A_D46: length 70
  IN1 w0.089: v2(137.21,47.09) 136.59,47.09 128.25,38.75 122.81,38.75 122.24,38.19 121.07,38.19 120.3,37.42 119.05,37.42 116.91,35.27 116.79,35.27 116.59,35.47 116.47,35.47 116.34,35.34 116.34,35.21 116.53,35.02 116.53,34.9 116.41,34.77 116.28,34.77 116.09,34.96 115.97,34.96 115.84,34.84 115.84,34.71 116.03,34.52 116.03,34.39 115.91,34.27 115.78,34.27 115.59,34.46 115.46,34.46 115.34,34.33 115.34,34.21 115.53,34.02 115.53,33.89 115.4,33.77 115.28,33.77 115.09,33.96 114.96,33.96 101.93,20.93 101.93,20.33 101.84,20.24 101.52,20.24 101.43,20.15 101.43,19.97 101.52,19.88 101.95,19.88 102.04,19.79 102.04,19.62 101.95,19.53 100.56,19.53 100.47,19.44 100.47,19.26 100.56,19.17 101.91,19.17 102,19.08 102,18.91 101.91,18.82 101.39,18.82 101.3,18.73 101.3,18.55 101.39,18.46 101.84,18.46 101.93,18.37 101.93,18.06 101.76,17.89 v2(99.86,17.89)
  BOTTOM w0.076: 138.2,49.83 138.27,49.9 138.27,51.27 140.43,53.43 140.43,54.63 140.37,54.78 UC1.BA59
  BOTTOM w0.102: 138.2,49.83 137.94,49.57 137.94,47.82 v2(137.21,47.09) ; JDIMM1.83 99.37,18.37 v2(99.86,17.89)
DDR_A_D47: length 70.9
  IN1 w0.089: v2(100.54,14.91) 101.85,14.91 101.93,15 101.93,16.26 101.85,16.35 101.5,16.35 101.41,16.44 101.41,16.62 101.5,16.71 102.35,16.71 102.44,16.79 102.44,16.97 102.35,17.06 101.52,17.06 101.43,17.15 101.43,17.33 101.52,17.42 102.35,17.42 102.44,17.51 102.44,21.01 114.63,33.19 115.26,33.19 119.14,37.07 120.38,37.07 121.19,37.88 122.37,37.88 122.94,38.45 128.42,38.45 136.19,46.22 v2(136.38,46.22)
  BOTTOM w0.076: UC1.AY59 140.16,55.63 140.43,55.36 140.43,55.17 140.56,54.74 140.59,54.66 140.59,53.34 138.52,51.26 138.52,49.83
  BOTTOM w0.102: 138.52,49.83 138.52,49.59 138.49,49.56 138.49,47.71 136.98,46.21 136.4,46.21 v2(136.38,46.22) ; v2(100.54,14.91) 100.44,14.91 98.73,13.2 98.73,12.88 98.62,12.78 JDIMM1.80
DDR_A_D48: length 53.8
  IN4 w0.076: 134.07,57.02 135,57.95
  IN4 w0.089: 135,57.95 v2(135.49,57.95) ; v2(133.54,18.55) 133.54,19.62 133.31,19.85 133.31,19.97 133.46,20.12 133.57,20.12 133.66,20.2 133.66,20.38 133.57,20.47 133.4,20.47 133.31,20.56 133.31,20.74 133.4,20.83 133.57,20.83 133.66,20.92 133.66,21.09 133.57,21.18 133.4,21.18 133.31,21.27 133.31,21.45 133.4,21.54 133.57,21.54 133.66,21.63 133.66,21.8 133.57,21.89 133.4,21.89 133.31,21.98 133.31,22.16 133.4,22.25 133.57,22.25 133.66,22.34 133.66,22.62 133.57,22.71 133.4,22.71 133.31,22.8 133.31,22.98 133.4,23.07 133.57,23.07 133.66,23.16 133.66,23.33 133.57,23.42 133.4,23.42 133.31,23.51 133.31,23.69 133.4,23.78 133.57,23.78 133.66,23.87 133.66,24.05 133.57,24.14 133.4,24.14 133.31,24.22 133.31,24.4 133.4,24.49 133.57,24.49 133.66,24.58 133.66,24.8 133.57,24.88 133.39,24.88 133.3,24.97 133.3,25.15 133.39,25.24 133.57,25.24 133.66,25.33 133.66,25.51 133.57,25.6 133.39,25.6 133.3,25.68 133.3,25.86 133.39,25.95 133.57,25.95 133.66,26.04 133.66,26.22 133.57,26.31 133.39,26.31 133.3,26.4 133.3,26.57 133.39,26.66 133.57,26.66 133.66,26.75 133.66,26.93 133.57,27.02 133.39,27.02 133.3,27.11 133.3,27.28 133.39,27.37 133.57,27.37 133.66,27.46 133.66,27.64 133.57,27.73 133.39,27.73 133.3,27.82 133.3,28 133.39,28.08 133.57,28.08 133.66,28.17 133.66,28.52 130.75,31.43 130.75,41.4 129.78,42.38 129.78,44.92 128.26,46.44 128.26,52.1 129.84,53.68 131.54,53.68 134.07,56.21 134.07,57.02
  BOTTOM w0.076: UC1.AT66 135.84,58.3 v2(135.49,57.95)
  BOTTOM w0.102: JDIMM1.211 133.37,18.71 v2(133.54,18.55)
DDR_A_D49: length 54.2
  IN4 w0.089: v2(135.49,57.32) 132.26,54.09 131.62,53.45 130.09,53.45 128.56,51.92 128.56,46.57 130.08,45.05 130.08,42.5 131.06,41.53 131.06,31.56 133.96,28.65 133.96,17.06 134.05,16.97 134.31,16.97 134.4,16.89 134.4,16.71 134.31,16.62 134.24,16.62 134.15,16.53 134.15,16.17 134.75,15.57 v2(135.22,15.57)
  BOTTOM w0.076: UC1.AU66 v2(135.49,57.32)
  BOTTOM w0.102: JDIMM1.215 134.37,18.93 134.47,18.83 134.47,16.32 v2(135.22,15.57)
DDR_A_D50: length 57.1
  IN4 w0.076: 136.08,55.3 136.94,56.17 136.94,58.13 136.78,58.28 136.78,59.47 v2(136.4,59.86)
  IN4 w0.089: 136.08,55.3 135.82,55.3 134.97,54.46 134.02,54.46 131.81,52.25 131.81,50.42 131.28,49.89 131.28,47.43 131.89,46.81 131.89,43.25 132.87,42.28 132.87,32.31 136.65,28.52 136.65,24.69 136.55,24.59 135.97,24.59 135.88,24.5 135.88,24.32 135.97,24.23 136.24,24.23 136.33,24.15 136.33,23.97 136.24,23.88 136.08,23.88 135.88,23.68 135.88,20.32 136.89,19.31 136.89,19.09 136.8,19 136.7,19 136.61,18.91 136.61,18.74 136.7,18.65 137.08,18.65 137.17,18.56 137.17,18.38 137.08,18.29 136.7,18.29 136.61,18.2 136.61,18.03 136.7,17.94 137.06,17.94 137.15,17.85 137.15,17.67 137.06,17.58 136.7,17.58 136.61,17.49 136.61,17.28 136.89,17 137.5,17 v2(137.68,16.82)
  BOTTOM w0.076: v2(136.4,59.86) 136.66,59.6 UC1.AP65
  BOTTOM w0.102: JDIMM1.225 136.87,17.45 137.5,16.82 v2(137.68,16.82)
DDR_A_D51: length 57.2
  IN4 w0.076: v2(136.4,60.49) 136.95,59.94 136.95,58.43 137.1,58.28 137.1,55.91 136.35,55.16
  IN4 w0.089: 136.35,55.16 135.34,54.15 134.14,54.15 132.14,52.15 132.14,50.32 131.58,49.76 131.58,47.6 132.19,46.99 132.19,43.38 133.18,42.4 133.18,32.43 136.96,28.65 136.96,24.26 136.87,24.17 136.73,24.17 136.64,24.09 136.64,23.91 136.73,23.82 136.87,23.82 136.96,23.73 136.96,23.55 136.87,23.46 136.27,23.46 136.18,23.37 136.18,23.2 136.27,23.11 136.73,23.11 136.82,23.02 136.82,22.84 136.73,22.75 136.27,22.75 136.18,22.66 136.18,22.5 136.27,22.41 136.75,22.41 136.84,22.32 136.84,22.14 136.75,22.05 136.27,22.05 136.18,21.96 136.18,21.76 136.27,21.67 136.73,21.67 136.82,21.58 136.82,21.38 136.73,21.29 136.27,21.29 136.18,21.2 136.18,20.63 136.33,20.48 136.46,20.48 136.7,20.72 136.85,20.72 136.96,20.62 136.96,20.47 136.71,20.22 136.71,20.1 136.84,19.97 136.96,19.97 137.14,20.15 137.27,20.15 137.39,20.03 137.39,19.9 137.19,19.69 137.19,19.55 137.29,19.44 137.44,19.44 137.64,19.65 137.77,19.65 137.9,19.52 137.9,19.4 137.55,19.05 137.55,18.67 137.73,18.49 v2(137.73,18.37)
  BOTTOM w0.076: v2(136.4,60.49) 136.65,60.25 UC1.AN65
  BOTTOM w0.102: v2(137.73,18.37) 137.87,18.51 JDIMM1.229
DDR_A_D52: length 56.3
  IN4 w0.076: v2(135.49,59.86) 135.09,59.46 135.09,58.54 133.65,57.1 133.65,56.96 132.32,55.63 131.28,55.63 130.59,54.94 129.4,54.94 128.72,54.27 128.61,54.27
  IN4 w0.089: 128.61,54.27 128.54,54.27 127.57,53.3 127.57,46.27 129.17,44.67 129.17,42.12 130.14,41.15 130.14,40.47 130.14,40.46 130.14,31.18 132.69,28.63 132.69,16.78 133.27,16.2 133.27,14.7 134.15,13.82 v2(134.15,13.62)
  BOTTOM w0.076: v2(135.49,59.86) 135.88,60.25 UC1.AN66
  BOTTOM w0.102: v2(134.15,13.62) 134.62,13.14 JDIMM1.216
DDR_A_D53: length 55.8
  IN4 w0.089: v2(133.92,15.14) 133.79,15.14 133.64,15.29 133.64,15.54 133.73,15.62 133.86,15.62 133.95,15.71 133.95,15.94 133.86,16.03 133.73,16.03 133.64,16.12 133.64,16.69 133.54,16.79 133.11,16.79 132.99,16.91 132.99,28.76 130.45,31.3 130.45,41.27 129.47,42.25 129.47,44.8 127.87,46.39 127.87,52.15 129.65,53.93 131.41,53.93 133.82,56.34 133.82,57.03 135.32,58.53 135.32,59.05 v2(135.49,59.22)
  BOTTOM w0.076: UC1.AP66 v2(135.49,59.22)
  BOTTOM w0.102: v2(133.92,15.14) 133.74,15.14 133.51,14.91 133.51,13.08 133.62,12.97 JDIMM1.212
DDR_A_D54: length 55.4
  IN4 w0.076: v2(136.4,57.95) 136.77,57.58 136.77,56.25 136.08,55.56 ; 130.87,52.07 131.13,52.33 131.49,52.33 132.23,53.06 132.37,53.06 133.94,54.63 134.89,54.63
  IN4 w0.089: 136.08,55.56 135.82,55.56 134.89,54.63 ; 130.87,52.07 130.87,52.07 130.07,51.27 130.07,47.19 131.58,45.67 131.58,43.13 132.56,42.15 132.56,32.18 136.35,28.39 136.35,25.16 136.26,25.07 135.77,25.07 135.57,24.87 135.57,20.22 135.57,20.22 135.57,19.64 136.23,18.98 136.23,15.51 136.32,15.42 v2(137.25,15.42)
  BOTTOM w0.076: v2(136.4,57.95) 136.75,58.3 UC1.AT65
  BOTTOM w0.102: JDIMM1.224 136.62,14.8 v2(137.25,15.42)
DDR_A_D55: length 54.5
  IN4 w0.076: 135.87,55.77 136.4,56.31 v2(136.4,57.32) ; 130.64,52.3 130.66,52.3 130.71,52.35 130.91,52.35 131.06,52.49 131.42,52.49 132.16,53.23 132.21,53.23 133.13,54.15
  IN4 w0.089: 130.64,52.3 129.76,51.42 129.76,47.06 131.28,45.55 131.28,43 132.26,42.02 132.26,32.05 136.04,28.27 136.04,25.8 135.16,24.92 135.16,19.61 135.93,18.85 135.93,14.58 136.61,13.9 v2(137.25,13.9) ; 135.87,55.77 135.23,55.77 134.9,55.44 134.38,55.44 133.13,54.18 133.13,54.15
  BOTTOM w0.076: UC1.AU65 136.74,57.65 v2(136.4,57.32)
  BOTTOM w0.102: JDIMM1.228 137.62,12.88 137.76,13.01 137.76,13.59 137.45,13.9 v2(137.25,13.9)
DDR_A_D56: length 54.4
  IN4 w0.076: 137.81,57.52 v2(138.23,57.95)
  IN4 w0.089: 137.81,57.52 137.68,57.4 137.68,55.59 136.52,54.44 136.52,54.2 135.07,52.75 134.14,52.75 133.84,52.45 133.84,49.78 133.52,49.45 133.52,48.97 133.3,48.76 133.3,43.84 134.2,42.94 134.28,42.86 134.28,33.81 136.01,32.08 136.01,31.95 135.84,31.79 135.84,31.66 135.97,31.53 136.09,31.53 136.26,31.7 136.39,31.7 136.51,31.57 136.51,31.45 136.26,31.19 136.26,31.07 136.38,30.94 136.51,30.94 136.76,31.2 136.89,31.2 137.02,31.07 137.02,30.95 136.76,30.69 136.76,30.57 136.89,30.44 137.01,30.44 137.27,30.7 137.39,30.7 137.52,30.57 137.52,30.44 137.26,30.19 137.26,30.06 137.39,29.94 137.51,29.94 137.77,30.19 137.9,30.19 138.06,30.03 138.06,29.16 138.06,20.96 139.15,19.87 139.15,18.01 139.48,17.68 139.48,17.4 139.36,17.28 139.29,17.28 139.2,17.19 139.2,16.96 139.29,16.87 v2(139.94,16.87)
  BOTTOM w0.076: UC1.AT61 138.58,58.3 v2(138.23,57.95)
  BOTTOM w0.102: v2(139.94,16.87) 138.87,17.93 JDIMM1.233
DDR_A_D57: length 53.6
  IN4 w0.076: 136.83,54.31 137.85,55.33 137.85,56.94 v2(138.23,57.32)
  IN4 w0.089: v2(139.94,18.39) 139.46,18.87 139.46,19.23 139.55,19.32 139.6,19.32 139.69,19.41 139.69,19.59 139.6,19.67 139.55,19.67 139.46,19.76 139.46,19.99 138.37,21.08 138.37,28.12 138.37,28.12 138.37,29.29 138.37,31.17 138.18,31.35 138.06,31.35 137.7,30.99 137.58,30.99 137.45,31.12 137.45,31.25 137.81,31.6 137.81,31.73 137.68,31.85 137.55,31.85 137.21,31.51 137.09,31.51 136.96,31.64 136.96,31.76 137.3,32.1 137.3,32.23 137.3,32.24 137.18,32.36 137.05,32.36 136.67,31.97 136.55,31.97 136.42,32.1 136.42,32.23 136.8,32.61 136.8,32.73 136.67,32.86 136.55,32.86 136.23,32.54 136.11,32.54 135.98,32.67 135.98,32.79 136.3,33.11 136.3,33.23 136.17,33.36 136.05,33.36 135.72,33.03 135.59,33.03 135.46,33.16 135.46,33.28 135.79,33.61 135.79,33.74 135.67,33.86 135.54,33.86 135.21,33.53 135.09,33.53 134.96,33.66 134.96,33.79 135.29,34.12 135.29,34.24 135.14,34.39 135.01,34.39 134.85,34.23 134.72,34.23 134.6,34.36 134.6,34.48 134.76,34.65 134.76,34.77 134.59,34.95 134.59,42.98 134.52,43.05 133.6,43.96 133.6,48.63 133.82,48.84 133.82,49.33 134.14,49.65 134.14,52.04 134.55,52.45 135.25,52.45 136.77,53.98 136.77,54.25 136.83,54.31
  BOTTOM w0.076: UC1.AU61 138.57,57.65 v2(138.23,57.32)
  BOTTOM w0.102: JDIMM1.237 139.87,18.46 v2(139.94,18.39)
DDR_A_D58: length 56.9
  IN4 w0.076: 140.04,55.66 140.04,57.76 139.53,58.28 139.53,59.47 v2(139.15,59.86)
  IN4 w0.084: 140.04,55.66 138.66,54.28 138.66,53.81 137.71,52.86 137.71,52.85
  IN4 w0.089: v2(142.76,15.4) 142.4,15.75 141.85,15.75 141.69,15.9 141.69,16.09 141.78,16.18 143.41,16.18 143.5,16.27 143.5,18.9 141.53,20.86 141.53,23.07 140.83,23.77 140.83,27.49 140.26,28.05 140.26,31.83 138.1,33.99 137.47,34.62 136.39,35.7 136.39,44.88 135.55,45.72 135.55,47.02 135.88,47.35 135.88,47.86 136.46,48.44 136.46,51.61 137.71,52.85
  BOTTOM w0.076: UC1.AP60 139.4,59.6 v2(139.15,59.86)
  BOTTOM w0.102: v2(142.76,15.4) 142.12,14.76 JDIMM1.246
DDR_A_D59: length 57.2
  IN4 w0.076: v2(139.15,60.51) 139.43,60.22 140.21,60.22 140.43,60.01 140.43,55.62 140.35,55.54 ; 136.77,50.99 136.77,51.67 137.89,52.79
  IN4 w0.089: 140.35,55.54 138.96,54.16 138.96,53.87 137.89,52.79 ; v2(143.55,14.1) 142.96,14.69 142.96,14.87 143.8,15.71 143.8,19.03 143.65,19.18 143.65,19.31 143.92,19.58 143.92,19.7 143.79,19.83 143.66,19.83 143.4,19.56 143.27,19.56 141.84,20.99 141.84,23.19 141.13,23.9 141.13,27.61 140.58,28.17 140.58,31.95 138.23,34.29 137.6,34.92 136.7,35.82 136.7,45 135.85,45.85 135.85,46.89 136.77,47.81 136.77,50.99
  BOTTOM w0.076: UC1.AN60 139.4,60.25 v2(139.15,60.51)
  BOTTOM w0.102: v2(143.55,14.1) 143.42,14.1 143.12,13.81 JDIMM1.250
DDR_A_D60: length 56.5
  IN4 w0.076: 135.92,54.46 137.32,55.87 137.32,58.02 137.72,58.42 137.72,59.34 v2(138.23,59.86) ; 132.75,52.18 133.87,53.29 135.12,53.29
  IN4 w0.089: v2(139.94,13.82) 139.19,13.82 139.1,13.91 139.1,14.32 139.19,14.41 139.34,14.41 139.43,14.49 139.43,14.67 139.34,14.76 138.85,14.76 138.54,15.07 138.54,19.61 137.45,20.7 137.45,28.85 135.22,31.09 135.22,31.98 133.67,33.53 133.67,42.6 133.59,42.68 132.69,43.58 132.69,47.34 132.08,47.95 132.08,49.56 132.65,50.13 132.65,52.07 132.75,52.18 ; 135.12,53.29 135.92,54.09 135.92,54.46
  BOTTOM w0.076: v2(138.23,59.86) 138.63,60.25 UC1.AN61
  BOTTOM w0.102: JDIMM1.236 139.62,13.5 v2(139.94,13.82)
DDR_A_D61: length 55.9
  IN4 w0.076: v2(138.23,59.22) 138.23,58.52 137.5,57.79 137.5,55.72 136.22,54.43
  IN4 w0.089: 136.22,54.43 136.22,54.15 135.13,53.05 134.11,53.05 133.53,52.47 133.53,49.9 133.21,49.58 133.21,49.1 132.99,48.88 132.99,48.42 132.91,48.33 132.61,48.33 132.52,48.24 132.52,48.06 132.61,47.97 132.91,47.97 132.99,47.88 132.99,43.71 133.17,43.53 133.9,42.81 133.9,42.81 133.98,42.73 133.98,33.65 135.52,32.11 135.52,31.21 137.76,28.98 137.76,28.73 137.76,20.83 138.85,19.74 138.85,16.3 138.94,16.21 139.34,16.21 139.43,16.12 139.43,15.94 139.34,15.85 139.24,15.85 139.15,15.76 139.15,15.43 139.24,15.34 v2(139.94,15.34)
  BOTTOM w0.076: v2(138.23,59.22) 138.61,59.6 UC1.AP61
  BOTTOM w0.102: JDIMM1.232 138.62,14.03 v2(139.94,15.34)
DDR_A_D62: length 56.2
  IN4 w0.076: 139.74,55.79 139.74,57.33 v2(139.15,57.92)
  IN4 w0.089: 139.74,55.79 138.36,54.4 138.36,53.76 136.16,51.56 136.16,48.57 135.57,47.98 135.57,47.48 135.24,47.15 135.24,45.6 136.09,44.75 136.09,35.57 137.35,34.31 137.98,33.68 139.96,31.7 139.96,27.92 140.52,27.36 140.52,22.8 140.61,22.71 141.14,22.71 141.23,22.62 141.23,22.42 141.12,22.31 140.77,22.31 140.68,22.22 140.68,22.04 140.77,21.95 141.12,21.95 141.21,21.86 141.21,21.69 141.12,21.6 140.77,21.6 140.68,21.51 140.68,21.33 140.77,21.24 141.1,21.24 141.18,21.15 141.18,20.78 141.58,20.39 141.58,20.26 141.24,19.92 141.24,19.77 141.35,19.65 141.47,19.65 141.83,20.01 141.96,20.01 142.08,19.88 142.08,19.76 141.66,19.34 141.66,19.21 141.79,19.09 141.91,19.09 142.33,19.51 142.46,19.51 143.19,18.77 143.19,16.65 143.1,16.56 142.86,16.56 142.76,16.67 142.76,17.96 142.58,18.14 v2(142.35,18.14)
  BOTTOM w0.076: v2(139.15,57.92) 139.52,58.3 UC1.AT60
  BOTTOM w0.102: v2(142.35,18.14) 142.53,18.14 142.87,18.48 JDIMM1.249
DDR_A_D63: length 55.9
  IN4 w0.076: v2(139.15,57.32) 139.15,55.62 138.05,54.53
  IN4 w0.089: v2(142.3,16.59) 141.92,16.97 141.92,18.5 140.93,19.49 140.93,20.32 140.35,20.91 140.35,21.98 140.23,22.1 139.74,22.1 139.65,22.18 139.65,22.42 139.74,22.51 139.98,22.51 140.07,22.6 140.07,22.83 139.98,22.91 139.74,22.91 139.65,23 139.65,23.23 139.74,23.32 140.13,23.32 140.22,23.41 140.22,23.6 140.13,23.69 139.74,23.69 139.65,23.78 139.65,23.95 139.74,24.04 140.13,24.04 140.22,24.13 140.22,24.31 140.13,24.4 139.74,24.4 139.65,24.49 139.65,24.67 139.74,24.75 140.13,24.75 140.22,24.84 140.22,25.02 140.13,25.11 139.74,25.11 139.65,25.2 139.65,25.38 139.74,25.47 140.13,25.47 140.22,25.55 140.22,25.73 140.13,25.82 139.74,25.82 139.65,25.91 139.65,26.09 139.74,26.18 140.13,26.18 140.22,26.27 140.22,26.44 140.13,26.53 139.74,26.53 139.65,26.62 139.65,26.8 139.74,26.89 140.05,26.89 140.14,26.98 140.14,27.16 140.05,27.24 139.74,27.24 139.65,27.33 139.65,31.57 137.85,33.38 137.85,33.38 137.22,34.01 135.78,35.44 135.78,44.13 134.94,44.97 134.94,47.27 135.27,47.6 135.27,48.11 135.85,48.69 135.85,51.58 138.05,53.78 138.05,54.53
  BOTTOM w0.076: v2(139.15,57.32) 139.48,57.65 UC1.AU60
  BOTTOM w0.102: v2(142.3,16.59) 141.87,17.02 JDIMM1.245
DDR_A_DQS0: length 82.4
  IN1 w0.102: v2(126.39,60.26) 126.25,60.4 126.25,60.74 126.06,60.93 122.67,60.93 122.27,60.52 122.27,60.22 122.74,59.74 122.74,59.59 122.58,59.43 122.34,59.43 121.91,59.86 121.6,59.86 116.25,54.51 116.25,52.62 100.71,37.08 99.76,37.08 82.29,19.6 81.24,19.6 80.74,19.11 80.74,17.24 81.03,16.95 81.31,16.95 v2(81.52,16.74)
  BOTTOM w0.076: v2(126.39,60.26) 126.16,60.03 126.16,59.94 126.3,59.8 126.84,59.8 126.92,59.87 128.09,59.87 128.16,59.87 129.79,59.87 130.53,60.61 130.84,60.61 131.47,61.24 132.35,61.24 132.56,61.11 132.59,61.09 132.82,61.09 132.96,61.13 133.16,61.13 133.28,61.08 133.46,61.08 133.63,61.15 133.79,61.15 134.02,61.04 134.13,60.93 134.13,60.84 134.17,60.79 UC1.AM69
  BOTTOM w0.102: JDIMM1.13 81.87,18.91 82.28,18.5 82.28,17.35 82.01,17.08 81.68,17.08 81.52,16.92 v2(81.52,16.74)
DDR_A_DQS1: length 75
  IN1 w0.102: v2(87.67,13.72) 87.46,13.92 87.11,13.92 86.61,14.43 86.61,17.99 116.19,47.58 121.42,47.58 121.67,47.58 123.25,47.58 126.26,50.59 126.26,53.46 127.95,55.14 v2(127.95,55.88)
  BOTTOM w0.076: UC1.AT70 133.91,58.34 133.96,58.28 133.96,58.16 133.92,58.12 133.76,58.05 133.66,58.05 133.49,58.11 133.25,58.11 133.13,58.06 132.99,58.06 132.85,58.11 132.48,58.11 132.42,58.07 132.26,57.96 131.71,57.96 131.5,57.76 130.48,57.76 130.22,57.5 129.88,57.5
  BOTTOM w0.102: 129.88,57.5 129.08,57.5 128.1,56.52 128.1,56.04 v2(127.95,55.88) ; v2(87.67,13.72) 87.67,13.85 87.46,14.05 87.29,14.05 86.83,13.59 86.83,12.75 86.93,12.65 86.97,12.65 87.12,12.5 JDIMM1.34
DDR_A_DQS2: length 69.8
  IN4 w0.076: 126.4,56.47 126.41,56.48 126.41,56.51 126.62,56.71 128.22,56.71 128.79,57.28 131.33,57.28 131.58,57.53 132.02,57.53 132.99,58.51 132.99,59.78 134.91,61.7 135.2,61.7 135.44,61.94 135.45,61.94 135.45,61.95 135.92,61.95 v2(136.31,62.34)
  IN4 w0.102: v2(130.72,13.9) 130.72,14.94 129.95,15.71 129.95,22.42 130.77,23.25 130.77,26.04 128.05,28.77 128.05,29.88 127.08,30.85 127.08,42.46 119.09,50.45 119.09,53.78 121.55,56.24 126.17,56.24 126.4,56.47
  BOTTOM w0.076: v2(136.31,62.34) 136.63,62.65 UC1.AH65
  BOTTOM w0.102: v2(130.72,13.9) 130.49,13.67 130.49,12.65 130.62,12.52 JDIMM1.200
DDR_A_DQS3: length 73.7
  IN4 w0.076: v2(129.64,62.82) 129.48,62.65 129.48,62.13 129.02,61.68 123.91,61.68 123.89,61.66 123.88,61.66
  IN4 w0.102: v2(125.39,17.94) 125.51,17.81 125.51,17.58 125.41,17.48 124.55,17.48 124.36,17.66 124.36,18.89 124.46,18.99 125.05,18.99 125.27,19.21 125.27,19.67 125.05,19.89 124.46,19.89 124.36,19.99 124.36,20.3 124.46,20.4 125.05,20.4 125.27,20.61 125.27,21.08 125.05,21.3 124.71,21.3 124.6,21.41 124.6,21.69 124.71,21.81 125.01,21.81 125.27,22.06 125.27,25.01 123.36,26.92 123.36,35.51 122.45,36.42 122.45,41.17 115.54,48.08 115.54,55.29 121.91,61.66 123.88,61.66
  BOTTOM w0.076: UC1.AG70 133.91,63.34 133.96,63.29 133.96,63.17 133.92,63.13 133.76,63.05 133.66,63.05 133.49,63.12 133.25,63.12 133.13,63.07 132.99,63.07 132.85,63.11 132.54,63.11 132.47,63.06 132.45,63.05 131.12,63.05 130.37,62.31 129.42,62.31 129.29,62.45 129.29,62.56 129.54,62.82 v2(129.64,62.82)
  BOTTOM w0.102: v2(125.39,17.94) 125.46,17.86 125.46,17.61 125.31,17.45 125.2,17.45 125.17,17.43 125.03,17.43 124.9,17.56 124.9,18.75 125.37,19.22 JDIMM1.179
DDR_A_DQS4: length 70.5
  IN1 w0.102: v2(130.54,49.12) 130.31,48.89 129.67,48.89 129.31,48.53 129.31,48.2 129.77,47.73 129.77,47.59 129.55,47.37 129.41,47.37 128.96,47.82 128.6,47.82 128.33,47.56 128.33,47.12 128.11,46.9 127.68,46.9 127.34,46.56 127.34,46.12 127.12,45.9 126.68,45.9 125.77,44.99 125.77,44.52 125.3,44.05 120.21,44.05 119.96,44.05 118.21,44.05 114.78,40.63 114.23,40.63 108.1,34.51 108.1,33.95 97.34,23.19 97.29,23.13 97.29,23.13 96.11,21.96 93.42,19.27 93.42,17.47 93.25,17.29 93.11,17.29 92.9,17.5 v2(92.9,17.56)
  BOTTOM w0.076: UC1.AY64 137.05,55.98 137,55.93 136.9,55.93 136.8,55.83 136.69,55.6 136.69,55.43 136.75,55.27 136.75,55.09 136.7,54.97 136.7,54.77 136.75,54.63 136.75,54.4 136.73,54.36 136.59,54.15 136.59,53.9 135.3,52.61 132.7,52.61 132.24,52.15 132.24,51.33 131.22,50.31 131.22,50.03 131.2,50.01 131.2,49.99
  BOTTOM w0.102: JDIMM1.55 92.37,18.86 92.29,18.78 92.18,18.78 92.08,18.67 92.08,17.57 92.47,17.17 92.67,17.17 92.9,17.4 v2(92.9,17.56) ; 131.2,49.99 131.2,49.05 131,48.85 130.72,48.85 130.54,49.02 v2(130.54,49.12)
DDR_A_DQS5: length 69.9
  IN1 w0.102: v2(137.19,50.73) 137.09,50.63 136.56,50.63 136.24,50.3 136.24,48.82 127.52,40.1 123.06,40.1 123.05,40.1 119.24,40.1 98.44,19.3 98.44,15.17 97.6,14.33 97.24,14.33 96.99,14.58 v2(96.99,14.69)
  BOTTOM w0.076: v2(137.19,50.73) 137.19,50.61 137.44,50.36 137.58,50.36 137.69,50.47 137.69,51.49 139.83,53.63 139.83,54.09 139.79,54.13 139.79,54.26 139.73,54.35 139.73,54.65 139.78,54.79 139.78,54.94 139.72,55.05 139.72,55.3 139.79,55.47 139.79,55.56 139.71,55.73 139.67,55.77 139.58,55.77 139.5,55.69 UC1.BA60
  BOTTOM w0.102: JDIMM1.76 97.62,12.5 97.47,12.65 97.47,12.85 97.82,13.2 97.82,14.21 97.58,14.45 97.22,14.45 v2(96.99,14.69)
DDR_A_DQS6: length 55.7
  IN4 w0.076: 130.11,52.76 130.13,52.77 130.15,52.77 130.5,53.13 131.57,53.13 134.64,56.2 135.6,56.2 135.87,56.47 135.87,58.09 135.74,58.22 135.74,58.84 135.98,59.08 136.27,59.08 v2(136.4,59.22)
  IN4 w0.102: 130.11,52.76 129.06,51.71 129.06,46.78 130.58,45.26 130.58,42.71 131.56,41.73 131.56,31.76 134.47,28.86 134.47,28.46 134.79,28.14 135.1,28.14 135.19,28.05 135.19,27.72 135.1,27.63 134.68,27.63 134.47,27.41 134.47,26.95 134.68,26.73 134.84,26.73 135.23,26.73 135.32,26.64 135.32,26.31 135.23,26.22 134.68,26.22 134.47,26.01 134.47,17.6 134.71,17.36 135.01,17.36 v2(135.22,17.15)
  BOTTOM w0.076: v2(136.4,59.22) 136.68,58.95 UC1.AR65
  BOTTOM w0.102: v2(135.22,17.15) 135.4,17.33 135.68,17.33 135.92,17.57 135.92,18.57 135.72,18.77 135.72,19.08 135.87,19.23 JDIMM1.221
DDR_A_DQS7: length 55.6
  IN4 w0.076: v2(139.15,59.22) 138.95,59.02 138.78,59.02 138.61,58.85 138.61,57.09 138.72,56.98 138.72,55.77 138.67,55.72 138.65,55.72
  IN4 w0.102: v2(141.62,13.79) 141.51,13.9 140.99,13.9 140.84,14.04 140.84,14.05 140.61,14.28 140.61,18.43 140.19,18.85 140.19,19.97 138.96,21.2 138.96,31.29 137.56,32.68 137.5,32.74 135.09,35.15 135.09,43.19 135.02,43.26 134.11,44.17 134.11,48.42 134.32,48.64 134.32,49.12 134.64,49.44 134.64,51.07 134.65,51.07 134.65,51.49 135.46,52.3 136.04,52.3 137.63,53.88 137.63,54.7 138.65,55.72
  BOTTOM w0.076: UC1.AR60 139.42,58.95 v2(139.15,59.22)
  BOTTOM w0.102: v2(141.62,13.79) 141.62,14.05 141.41,14.26 141.17,14.26 140.88,13.97 140.88,12.69 141.12,12.44 JDIMM1.242
DDR_A_DQS#0: length 82.4
  IN1 w0.102: v2(81.55,17.73) 81.62,17.73 81.8,17.56 81.8,17.25 81.7,17.15 81.11,17.15 80.94,17.32 80.94,19.03 81.32,19.41 82.37,19.41 99.85,36.88 100.79,36.88 116.45,52.54 116.45,54.42 121.68,59.66 121.83,59.66 122.26,59.23 122.66,59.23 122.93,59.51 122.93,59.83 122.46,60.3 122.46,60.44 122.75,60.73 125.98,60.73 126.05,60.65 126.05,60.51 125.81,60.26 v2(125.74,60.26)
  BOTTOM w0.076: v2(125.74,60.26) 125.99,60.01 125.99,59.87 126.23,59.63 126.91,59.63 126.99,59.71 128.09,59.71 128.16,59.71 129.86,59.71 130.6,60.45 130.91,60.45 131.54,61.08 131.74,61.08 132.3,61.08 132.47,60.97 132.54,60.92 132.85,60.92 132.99,60.97 133.13,60.97 133.25,60.92 133.49,60.92 133.66,60.98 133.76,60.98 133.92,60.9 133.96,60.87 133.96,60.74 133.91,60.69 UC1.AM70
  BOTTOM w0.102: v2(81.55,17.73) 81.55,17.43 81.7,17.28 81.92,17.28 82.08,17.43 82.08,18.42 81.37,19.12 JDIMM1.11
DDR_A_DQS#1: length 75
  IN1 w0.102: v2(128.6,55.88) 128.53,55.88 128.14,55.49 128.14,55.06 126.46,53.38 126.46,50.51 123.34,47.38 121.59,47.38 121.34,47.38 116.27,47.38 86.8,17.91 86.8,14.51 87.19,14.12 87.43,14.12 87.69,14.38 v2(87.69,14.41)
  BOTTOM w0.076: 129.88,57.3 129.9,57.3 129.9,57.32 129.96,57.32 129.97,57.33 130.29,57.33 130.55,57.59 131.57,57.59 131.77,57.8 132.31,57.8 132.53,57.94 132.82,57.94 132.96,57.89 133.16,57.89 133.28,57.95 133.46,57.95 133.63,57.88 133.79,57.88 134.02,57.99 134.13,58.09 134.13,58.23 134.24,58.34 UC1.AT69
  BOTTOM w0.102: v2(87.69,14.41) 87.54,14.25 87.21,14.25 86.62,13.67 JDIMM1.32 ; v2(128.6,55.88) 128.54,55.88 128.3,56.11 128.3,56.44 129.16,57.3 129.88,57.3
DDR_A_DQS#2: length 69.8
  IN4 w0.076: 126.26,56.61 126.27,56.62 126.29,56.62 126.55,56.87 128.15,56.87 128.72,57.45 131.26,57.45 131.52,57.7 131.95,57.7 132.83,58.58 132.83,59.85 134.84,61.87 135.13,61.87 135.37,62.11 135.38,62.11 135.38,62.11 135.63,62.11 135.7,62.18 v2(135.7,62.36)
  IN4 w0.102: 126.26,56.61 126.09,56.43 121.47,56.43 118.89,53.86 118.89,50.37 126.89,42.37 126.89,30.77 127.85,29.8 127.85,28.68 130.58,25.96 130.58,23.33 129.75,22.51 129.75,15.62 130.52,14.86 130.52,14.29 130.14,13.9 v2(130.03,13.9)
  BOTTOM w0.076: UC1.AH66 135.98,62.64 v2(135.7,62.36)
  BOTTOM w0.102: JDIMM1.198 130.12,12.54 130.29,12.71 130.29,13.69 130.09,13.9 v2(130.03,13.9)
DDR_A_DQS#3: length 73.7
  IN4 w0.076: 123.88,61.86 123.89,61.86 123.91,61.84 128.95,61.84 129.31,62.2 129.31,62.63 129.12,62.82 v2(128.99,62.82)
  IN4 w0.102: v2(125.36,17.07) 125.23,17.21 125.22,17.21 125.15,17.28 124.47,17.28 124.17,17.58 124.17,18.97 124.38,19.19 124.97,19.19 125.08,19.29 125.08,19.59 124.97,19.69 124.38,19.69 124.17,19.91 124.17,20.38 124.38,20.59 124.97,20.59 125.08,20.7 125.08,21 124.97,21.1 124.63,21.1 124.4,21.33 124.4,21.77 124.63,22 124.93,22 125.08,22.14 125.08,24.93 123.16,26.84 123.16,35.43 122.25,36.34 122.25,41.09 115.34,48 115.34,55.37 121.83,61.86 123.88,61.86
  BOTTOM w0.076: UC1.AG69 134.17,63.24 134.13,63.2 134.13,63.1 134.02,62.99 133.79,62.89 133.63,62.89 133.46,62.95 133.28,62.95 133.16,62.9 132.96,62.9 132.82,62.95 132.59,62.95 132.56,62.92 132.5,62.89 131.19,62.89 130.44,62.14 129.36,62.14 129.12,62.38 129.12,62.68 v2(128.99,62.82)
  BOTTOM w0.102: JDIMM1.177 124.87,19 124.7,18.83 124.7,17.47 124.95,17.23 125.21,17.23 v2(125.36,17.07)
DDR_A_DQS#4: length 70.6
  IN1 w0.102: v2(130.54,48.47) 130.32,48.7 129.75,48.7 129.5,48.45 129.5,48.28 129.96,47.81 129.96,47.51 129.63,47.18 129.33,47.18 128.88,47.63 128.68,47.63 128.53,47.48 128.53,47.04 128.19,46.7 127.76,46.7 127.53,46.48 127.53,46.04 127.2,45.71 126.76,45.71 125.96,44.91 125.96,44.44 125.38,43.86 120.13,43.86 119.88,43.86 119.88,43.86 118.29,43.86 118.29,43.86 114.87,40.43 114.31,40.43 108.3,34.42 108.3,33.87 97.43,22.99 97.37,22.94 93.62,19.18 93.62,17.39 93.33,17.1 93.13,17.1 v2(92.87,16.84)
  BOTTOM w0.076: UC1.BA64 137.15,55.71 137.09,55.77 136.97,55.77 136.93,55.73 136.86,55.56 136.86,55.47 136.92,55.3 136.92,55.05 136.87,54.93 136.87,54.79 136.91,54.65 136.91,54.35 136.87,54.27 136.76,54.1 136.76,53.83 135.37,52.44 132.77,52.44 132.41,52.08 132.41,51.26 131.39,50.24 131.39,50.03 131.4,50.01 131.4,49.99
  BOTTOM w0.102: JDIMM1.53 91.87,17.49 92.39,16.97 92.75,16.97 v2(92.87,16.84) ; v2(130.54,48.47) 130.72,48.65 131.08,48.65 131.4,48.97 131.4,49.99
DDR_A_DQS#5: length 69.9
  IN1 w0.102: v2(97.01,13.92) 97.23,14.13 97.68,14.13 98.63,15.09 98.63,19.22 119.32,39.9 122.97,39.9 127.6,39.9 136.44,48.74 136.44,50.22 136.65,50.43 136.91,50.43 137.19,50.15 v2(137.19,50.08)
  BOTTOM w0.076: UC1.AY60 139.6,55.98 139.65,55.93 139.74,55.93 139.85,55.83 139.95,55.6 139.95,55.44 139.89,55.27 139.89,55.09 139.94,54.97 139.94,54.77 139.9,54.63 139.9,54.4 139.92,54.36 139.95,54.31 139.95,54.2 139.99,54.16 139.99,53.56 137.85,51.42 137.85,50.4 137.65,50.19 137.3,50.19 v2(137.19,50.08)
  BOTTOM w0.102: v2(97.01,13.92) 97.01,14.05 97.22,14.25 97.5,14.25 97.62,14.13 97.62,13.29 97.27,12.94 97.27,12.65 97.12,12.5 JDIMM1.74
DDR_A_DQS#6: length 55.7
  IN4 w0.076: 130.25,52.62 130.26,52.63 130.26,52.66 130.57,52.96 131.63,52.96 134.71,56.04 135.67,56.04 136.04,56.4 136.04,58.16 135.9,58.29 135.9,58.77 136.05,58.92 136.18,58.92 136.4,58.7 v2(136.4,58.59)
  IN4 w0.102: v2(135.22,17.99) 135.34,17.86 135.34,17.63 135.27,17.56 134.79,17.56 134.66,17.68 134.66,25.93 134.76,26.03 135.31,26.03 135.51,26.23 135.51,26.72 135.31,26.93 134.76,26.93 134.66,27.03 134.66,27.33 134.76,27.43 135.18,27.43 135.39,27.64 135.39,28.13 135.18,28.33 134.87,28.33 134.66,28.55 134.66,28.94 131.75,31.84 131.75,41.82 130.78,42.79 130.78,45.34 129.26,46.86 129.26,51.63 130.25,52.62
  BOTTOM w0.076: v2(136.4,58.59) 136.04,58.95 UC1.AR66
  BOTTOM w0.102: v2(135.22,17.99) 135.22,17.66 135.34,17.53 135.6,17.53 135.72,17.66 135.72,18.49 135.52,18.69 135.52,19.05 135.37,19.2 JDIMM1.219
DDR_A_DQS#7: length 55.6
  IN4 w0.076: 138.79,55.58 138.79,55.59 138.88,55.68 138.88,57.05 138.78,57.16 138.78,58.79 138.85,58.86 139.05,58.86 139.15,58.75 v2(139.15,58.59)
  IN4 w0.102: v2(141.64,14.58) 141.72,14.51 141.72,14.3 141.62,14.2 141.45,14.2 141.34,14.09 141.07,14.09 141.04,14.13 140.98,14.18 140.8,14.36 140.8,18.51 140.38,18.94 140.38,20.05 139.15,21.28 139.15,31.37 137.64,32.88 137.64,32.88 137.01,33.51 135.28,35.24 135.28,43.27 134.3,44.25 134.3,48.34 134.52,48.56 134.52,49.04 134.84,49.36 134.84,51.41 135.53,52.11 136.12,52.11 137.82,53.81 137.82,54.62 138.79,55.58
  BOTTOM w0.076: UC1.AR61 138.78,58.95 v2(139.15,58.59)
  BOTTOM w0.102: v2(141.64,14.58) 141.52,14.46 141.08,14.46 140.68,14.05 140.68,12.58 140.62,12.52 JDIMM1.240
DDR_A_MA0: length 64.3
  IN1 w0.076: 142.72,43.24 142.72,44.01 143.39,44.68 143.39,46.09 144.03,46.72 144.03,49.61 v2(143.17,50.47)
  IN1 w0.145: v2(114.26,13.08) 112.51,14.84 112.51,19.18 114.47,21.15 114.47,21.59 116.2,23.32 116.69,23.32 118.92,25.55 120.96,25.55 122.75,27.34 126.2,27.34 127.36,28.5 129.72,28.5 142.72,41.51 142.72,43.24
  BOTTOM w0.076: 143.81,51.16 143.81,51.21 144.38,51.78 144.38,52.76 145.1,53.47 145.1,54.1 144.84,54.36 144.84,54.61 144.89,54.72 144.89,54.99 144.85,55.08 144.85,55.28 144.89,55.37 144.89,55.37 144.89,55.38 144.89,55.39 144.89,55.61 UC1.AY50
  BOTTOM w0.168: 143.81,51.16 143.81,51.12 v2(143.17,50.47) ; JDIMM1.144 114.62,12.72 v2(114.26,13.08)
DDR_A_MA1: length 65
  IN1 w0.076: v2(143.17,49.82) 143.86,49.12 143.86,46.79 143.23,46.16 143.23,44.77 142.3,43.84 142.3,43.24
  IN1 w0.145: 142.3,43.24 142.3,41.69 130.24,29.62 129.62,29.62 129.48,29.48 129.48,29.07 129.33,28.93 129.06,28.93 128.92,29.07 128.92,29.19 128.77,29.34 128.48,29.34 128.33,29.19 128.33,29.07 128.19,28.93 125.84,28.93 125.7,28.78 125.7,28.5 125.84,28.36 125.98,28.36 126.12,28.21 126.12,27.94 125.98,27.79 125.26,27.79 125.12,27.94 125.12,28.78 124.97,28.93 124.65,28.93 124.51,28.78 124.51,27.93 124.36,27.79 124.04,27.79 123.9,27.93 123.9,28.56 123.75,28.7 123.51,28.7 123.29,28.48 123.29,27.91 123.14,27.77 122.57,27.77 120.78,25.97 119.1,25.97 118.75,25.97 116.52,23.75 116.02,23.75 114.04,21.77 114.04,21.42 114.04,21.32 111.55,18.82 111.55,17.98 v2(112.03,17.5)
  BOTTOM w0.076: UC1.BB50 145.3,54.35 145.3,53.42 144.62,52.74 144.62,51.58 144.27,51.22 144.27,51.16
  BOTTOM w0.168: v2(143.17,49.82) 144.27,50.92 144.27,51.16 ; v2(112.03,17.5) 112.51,17.98 112.51,18.46 111.87,19.09 JDIMM1.133
DDR_A_MA2: length 66.5
  IN1 w0.076: v2(143.65,51.6) 143.13,51.6 142.68,51.16 142.68,50.02 142.7,50.01 142.7,45.02 141.4,43.72 141.29,43.72 141.03,43.46 141.03,43.24
  IN1 w0.145: 141.03,43.24 141.03,42.21 129.88,31.07 129.7,31.07 129.55,31.21 129.55,31.46 129.41,31.6 129.09,31.6 128.94,31.46 128.94,31.21 128.8,31.07 125.89,31.07 125.74,30.92 125.74,30.39 125.6,30.25 123.22,30.25 121.58,28.6 119.08,28.6 112.69,22.21 112.69,22.19 112.69,21.84 110.04,19.2 110.04,18.79 110.26,18.58 110.26,17.89 110.04,17.67 110.04,17.12 v2(110.2,16.97)
  BOTTOM w0.076: v2(143.65,51.6) 143.65,51.86 144.19,52.41 144.19,52.88 144.88,53.57 144.88,54.08 144.67,54.28 144.67,54.65 144.72,54.75 144.72,54.96 144.69,55.05 144.69,55.07 144.69,55.31 144.72,55.4 144.72,55.61 144.69,55.69 144.66,55.79 144.66,55.99 UC1.AY51
  BOTTOM w0.168: JDIMM1.132 111.62,14.6 111.25,14.98 111.25,14.99 110.96,15.28 110.96,16.83 110.81,16.97 v2(110.2,16.97)
DDR_A_MA3: length 65.3
  IN1 w0.076: 141.88,43.24 141.88,43.67 143.06,44.86 143.06,46.23 143.7,46.86 143.7,47.99 v2(143.17,48.52)
  IN1 w0.145: 141.88,43.24 141.88,41.86 130.2,30.19 128.27,30.19 127.44,29.35 126.45,29.35 126.45,29.35 126.09,29.35 126.09,29.35 123.56,29.35 120.6,26.4 119.27,26.4 118.57,26.4 116.34,24.17 115.84,24.17 113.62,21.94 113.62,21.5 111.12,19 111.12,17.42 111.27,17.28 111.46,17.28 111.6,17.13 111.6,16.75 111.46,16.61 111.27,16.61 111.12,16.46 111.12,15.7 111.27,15.56 111.61,15.56 v2(112.03,15.98)
  BOTTOM w0.076: 144.8,51.15 144.81,51.17 144.81,52.7 145.6,53.49 145.6,54.7 UC1.BA50
  BOTTOM w0.168: 144.8,51.15 144.69,51.05 144.69,50.04 v2(143.17,48.52) ; v2(112.03,15.98) 111.5,16.5 111.5,17.55 111.37,17.68 JDIMM1.131
DDR_A_MA4: length 65.6
  IN1 w0.076: v2(141.95,50.52) 142.53,49.94 142.53,45.08 141.33,43.88 140.99,43.88 140.6,43.49 140.6,43.24
  IN1 w0.145: v2(110.2,15.45) 110.2,15.08 110.05,14.94 109.77,14.94 109.62,15.08 109.62,19.37 112.26,22.01 112.26,22.04 112.26,22.39 118.9,29.03 121.4,29.03 123.05,30.67 123.88,30.67 124.04,30.83 124.04,31.2 124.18,31.35 124.47,31.35 124.62,31.2 124.62,30.83 124.76,30.69 125.05,30.69 125.2,30.83 125.2,31.35 125.34,31.49 128.34,31.49 128.97,32.12 130.34,32.12 140.6,42.39 140.6,43.24
  BOTTOM w0.076: v2(141.95,50.52) 141.95,51.11 142.5,51.66 142.5,51.98 143.69,53.18 143.69,54.43 UC1.BB52
  BOTTOM w0.168: v2(110.2,15.45) 110.83,14.81 110.83,13.03 110.62,12.83 JDIMM1.128
DDR_A_MA5: length 66.2
  IN1 w0.076: v2(143.17,47.87) 143.53,47.5 143.53,46.93 142.9,46.3 142.9,44.92 141.45,43.48 141.45,43.24
  IN1 w0.145: 141.45,43.24 141.45,42.04 130.02,30.61 127.99,30.61 127.2,29.82 126.91,29.82 126.77,29.97 126.77,30.47 126.62,30.61 126.34,30.61 126.19,30.47 126.19,29.97 126.05,29.82 123.4,29.82 121.23,27.65 120.61,27.65 120.22,28.04 120.02,28.04 119.81,27.84 119.81,27.63 120.23,27.21 120.23,27 120.05,26.82 119.45,26.82 117.9,26.82 113.14,22.07 113.14,21.7 110.68,19.23 110.68,13.7 v2(110.32,13.34)
  BOTTOM w0.076: 142.76,50.77 142.76,51.27 144.03,52.54 144.03,54.11 144.22,54.31 144.22,54.66 144.22,54.67 144.19,54.76 144.19,54.96 144.22,55.04 144.22,55.05 144.23,55.05 144.23,55.06 144.23,55.28 UC1.BA51
  BOTTOM w0.102: 142.76,50.77 142.76,48.28 v2(143.17,47.87)
  BOTTOM w0.168: JDIMM1.126 110.12,13.14 v2(110.32,13.34)
DDR_A_MA6: length 65.2
  IN1 w0.076: v2(141.97,49.33) 142.37,48.94 142.37,45.15 141.26,44.05 140.8,44.05 140.18,43.42 140.18,43.42 140.18,43.24
  IN1 w0.145: 140.18,43.24 140.18,42.57 130.16,32.55 128.8,32.55 128.16,31.92 124.15,31.92 123.97,31.74 123.7,31.74 123.56,31.59 123.56,31.24 123.41,31.1 122.87,31.1 121.23,29.45 118.73,29.45 111.84,22.56 111.84,22.19 109.2,19.55 109.2,15.85 109.05,15.7 v2(108.8,15.7)
  BOTTOM w0.076: v2(141.97,49.33) 141.95,49.33 141.58,49.7 141.58,50.99 142.33,51.74 142.33,52.09 143.53,53.28 143.53,54.69 143.79,54.96 UC1.BA52
  BOTTOM w0.168: JDIMM1.127 110.37,19 109.69,18.32 109.69,16.34 109.05,15.7 v2(108.8,15.7)
DDR_A_MA7: length 67.3
  IN1 w0.076: v2(142,48.7) 141.22,47.93 141.22,46.61 139.93,45.32
  IN1 w0.145: v2(109.38,13.01) 108.95,13.01 107.85,14.11 107.85,16.09 106.77,17.17 106.77,20.25 107.98,21.47 107.98,22.34 115.67,30.03 116.3,30.03 120.37,34.09 124.36,34.09 124.96,34.69 125.13,34.69 125.9,35.46 129.86,35.46 139.72,45.32 139.93,45.32
  BOTTOM w0.076: v2(142,48.7) 141.41,49.28 141.41,51.06 142.15,51.8 142.15,52.18 143.36,53.39 143.36,55.21 143.57,55.42 143.57,55.97 143.89,56.29 UC1.AW52
  BOTTOM w0.168: v2(109.38,13.01) 109.12,12.75 JDIMM1.122
DDR_A_MA8: length 65.7
  IN1 w0.076: v2(142,45.58) 141.41,45.58 139.09,43.26 139.09,43.24
  IN1 w0.145: v2(108.67,17.23) 108.21,17.69 108.21,19.88 109.81,21.49 109.81,22.22 116.17,28.58 116.65,28.58 118.37,30.3 118.91,30.3 119.05,30.44 119.05,30.87 119.2,31.02 119.46,31.02 119.61,30.87 119.61,30.44 119.75,30.3 120.61,30.3 120.8,30.49 120.8,30.69 120.23,31.25 120.23,31.46 120.44,31.66 120.64,31.66 121.05,31.26 121.26,31.25 121.46,31.46 121.46,32.49 121.79,32.82 124.88,32.82 125.48,33.41 129.61,33.41 139.09,42.89 139.09,43.24
  BOTTOM w0.076: UC1.AY52 143.99,55.73 143.99,55.47 144.03,55.37 144.03,55.37 144.06,55.28 144.06,55.08 144.02,54.99 144.02,54.72 144.06,54.63 144.06,54.38 143.86,54.18 143.86,52.86 v1(143.18,52.19) 142.75,51.76 142.75,51.5 142.59,51.34
  BOTTOM w0.102: 142.59,51.34 142.45,51.2 142.45,47.48
  BOTTOM w0.168: JDIMM1.125 109.87,19.05 109.41,18.59 109.41,17.96 v2(108.67,17.23) ; v2(142,45.58) 142.45,46.04 142.45,47.48
DDR_A_MA9: length 63.4
  IN1 w0.076: v2(141.06,44.58) 140.83,44.58 139.75,43.51 139.75,43.42 139.75,43.42 139.75,43.24
  IN1 w0.145: 139.75,43.24 139.75,42.74 129.99,32.97 128.24,32.97 128.1,32.83 128.1,32.49 127.95,32.34 127.66,32.34 127.52,32.49 127.52,32.83 127.37,32.97 127.08,32.97 126.94,32.83 126.94,32.49 126.8,32.34 126.51,32.34 126.36,32.49 126.36,32.83 126.22,32.97 125.93,32.97 125.78,32.83 125.78,32.49 125.64,32.34 123.98,32.34 123.8,32.16 123.61,32.16 123.43,32.34 123.19,32.34 123.04,32.2 123.04,31.64 122.92,31.52 122.7,31.52 122.69,31.52 122.59,31.52 122.46,31.64 122.46,32.2 122.32,32.34 122.03,32.34 121.88,32.2 121.88,30.71 121.05,29.88 118.55,29.88 116.65,27.97 116.44,27.97 116.4,28.01 116.2,28.01 115.99,27.8 115.99,27.6 116.03,27.56 116.03,27.36 115.83,27.15 115.62,27.15 115.58,27.19 115.38,27.19 115.17,26.98 115.17,26.78 115.21,26.74 115.21,26.54 115.01,26.33 114.8,26.33 114.77,26.37 114.56,26.37 114.36,26.16 114.36,25.96 114.39,25.92 114.39,25.72 114.19,25.51 113.98,25.51 113.95,25.55 113.74,25.55 113.54,25.34 113.54,25.14 113.57,25.1 113.57,24.9 113.37,24.69 113.16,24.69 113.13,24.73 112.92,24.73 112.72,24.53 112.72,24.32 112.75,24.28 112.75,24.08 112.55,23.87 112.34,23.87 112.31,23.91 112.1,23.91 111.9,23.71 111.9,23.5 111.93,23.46 111.93,23.26 111.67,22.99 111.18,22.99 110.24,22.04 110.24,21.79 110.43,21.59 110.43,21.38 108.67,19.62 v2(108.67,18.75)
  BOTTOM w0.076: 140.91,48.48 140.81,48.58 140.81,51.61 142.87,53.67 142.87,54.43 UC1.BB54
  BOTTOM w0.168: v2(141.06,44.58) 140.91,44.73 140.91,48.48 ; JDIMM1.121 108.87,18.95 v2(108.67,18.75)
DDR_A_MA10: length 66.8
  IN1 w0.076: v2(144.63,57.95) 144.77,57.82 144.77,56.09 146.42,54.44 146.42,53.93 146.75,53.6 146.75,51.74 146.73,51.73 146.73,44.17 146.14,43.58
  IN1 w0.145: 146.14,43.58 146,43.44 146,42.02 146,42.02 146,40.86 146,40.86 146,40.33 129.81,24.14 124.1,24.14 122.38,22.42 122.15,22.42 120.8,22.42 120.65,22.27 120.65,21.75 119.01,20.1 118.76,20.1 118.6,20.27 118.26,20.27 116.46,18.47 116.46,15.78 116.32,15.64 115.96,15.64 115.81,15.78 v2(115.81,15.98)
  BOTTOM w0.076: UC1.AT50 v2(144.63,57.95)
  BOTTOM w0.168: JDIMM1.146 117.12,12.41 116.5,13.03 116.5,15.29 v2(115.81,15.98)
DDR_A_MA11: length 65.2
  IN1 w0.076: 138.67,43.24 138.67,43.37 139.58,44.28 139.82,44.28 141.62,46.08 141.62,46.44 v2(142,46.81)
  IN1 w0.145: 138.67,43.24 138.67,43.07 129.44,33.84 125.3,33.84 124.71,33.24 121.61,33.24 120.45,32.09 120.26,32.09 119.62,31.45 118.92,31.45 116.51,29.04 115.93,29.04 108.83,21.94 108.83,21.12 107.78,20.07 107.78,17.1 108.16,16.72 108.16,16.38 108.27,16.27 108.27,14.71 v2(108.8,14.18)
  BOTTOM w0.076: 141.34,47.48 141.34,48.67 140.98,49.03 140.98,51.53 143.03,53.58 143.03,54.7 142.76,54.97 UC1.BA54
  BOTTOM w0.168: 141.34,47.48 141.46,47.35 141.46,47.35 v2(142,46.81) ; JDIMM1.120 108.62,12.55 108.04,13.14 108.04,13.42 v2(108.8,14.18)
DDR_A_MA12: length 66.6
  IN1 w0.076: 138.24,43.24 139.89,44.89 140.1,44.89 141.39,46.18 141.39,46.86 v2(142,47.46)
  IN1 w0.145: 138.24,43.24 129.27,34.27 129,34.27 128.85,34.41 128.85,34.89 128.71,35.04 128.42,35.04 128.27,34.89 128.27,34.41 128.13,34.27 127.84,34.27 127.69,34.41 127.69,34.89 127.55,35.04 127.26,35.04 127.11,34.89 127.11,34.41 126.97,34.27 126.68,34.27 126.53,34.41 126.53,34.89 126.39,35.04 126.1,35.04 125.96,34.89 125.96,34.41 125.81,34.27 125.13,34.27 124.53,33.67 120.54,33.67 120.35,33.48 120.35,33.27 120.52,33.1 120.52,32.9 120.32,32.69 120.11,32.69 119.93,32.87 119.74,32.87 119.5,32.63 119.5,32.43 119.66,32.27 119.66,32.09 119.5,31.92 119.31,31.92 119.14,32.09 118.97,32.09 116.48,29.6 116.39,29.6 116.39,29.52 115.76,29.52 108.41,22.17 108.41,21.29 107.28,20.16 v2(107.28,18.24)
  BOTTOM w0.076: v2(142,47.46) 141.58,47.88 141.58,48.73 141.17,49.15 141.17,51.26 v1(141.81,51.91) 141.81,52.07 143.2,53.46 143.2,55.19 142.97,55.41 142.97,55.95 142.66,56.26 UC1.AW54
  BOTTOM w0.168: JDIMM1.119 108.37,19.21 108.03,18.86 107.9,18.86 v2(107.28,18.24)
DDR_A_MA13: length 69.1
  IN1 w0.076: v2(146.46,57.32) 146.46,56.21 148.28,54.39 148.28,45.48 147.7,44.9
  IN1 w0.145: 147.7,44.9 147.7,39.63 142.81,34.74 142.81,34.01 137.02,28.21 136.81,28.21 136.65,28.37 136.44,28.37 136.24,28.17 136.24,27.96 136.4,27.8 136.4,27.6 136.2,27.39 135.99,27.39 135.83,27.55 135.62,27.55 135.42,27.35 135.42,27.14 135.58,26.98 135.58,26.78 135.38,26.57 135.17,26.57 135.01,26.73 134.8,26.73 134.6,26.53 134.6,26.32 134.76,26.16 134.76,25.96 134.56,25.75 134.35,25.75 134.19,25.91 133.99,25.91 133.78,25.71 133.78,25.5 133.94,25.34 133.94,25.14 133.74,24.93 133.53,24.93 133.37,25.1 133.17,25.1 132.96,24.89 132.96,24.69 133.12,24.52 133.12,24.32 132.92,24.11 132.71,24.11 132.55,24.28 132.35,24.28 132.14,24.07 132.14,23.87 132.3,23.7 132.3,23.5 132.1,23.29 131.89,23.29 131.73,23.46 131.53,23.46 131.32,23.25 131.32,23.05 131.48,22.88 131.48,22.68 131.28,22.47 131.07,22.47 130.91,22.64 130.71,22.64 129.71,21.64 124,21.64 123.02,20.66 121.96,20.66 120.05,18.75 120.05,17.48 119.9,17.33 v2(119.52,17.33)
  BOTTOM w0.076: UC1.AU46 v2(146.46,57.32)
  BOTTOM w0.168: JDIMM1.158 120.12,12.93 120.61,13.42 120.61,15.7 120.1,16.21 120.1,16.74 v2(119.52,17.33)
DDR_A_MA14: length 65.5
  IN1 w0.076: 147.27,44.9 147.49,45.11 147.49,50.99 147.92,51.41 147.92,54.16 146.19,55.88 146.19,56.54 146.04,56.69 146.04,58.16 v2(146.46,58.59)
  IN1 w0.145: 147.27,44.9 147.27,39.8 142.14,34.67 142.14,34.47 142.31,34.31 142.31,34.1 142.1,33.9 141.9,33.9 141.73,34.06 141.53,34.06 141.33,33.85 141.33,33.65 141.49,33.49 141.49,33.28 141.28,33.08 141.08,33.08 140.92,33.24 140.71,33.24 140.51,33.03 140.51,32.83 140.67,32.67 140.67,32.46 140.46,32.26 140.26,32.26 140.1,32.42 139.89,32.42 139.69,32.22 139.69,32.01 139.85,31.85 139.85,31.64 139.64,31.44 139.44,31.44 139.28,31.6 139.07,31.6 138.87,31.4 138.87,31.19 139.03,31.03 139.03,30.82 138.82,30.62 138.62,30.62 138.46,30.78 138.25,30.78 138.05,30.58 138.05,30.37 138.21,30.21 138.21,30.01 138,29.8 137.8,29.8 137.64,29.96 137.43,29.96 137.23,29.76 137.23,29.55 137.39,29.39 137.39,29.19 137.19,28.98 136.98,28.98 136.82,29.14 136.61,29.14 130.16,22.69 129.84,22.69 129.21,22.06 123.82,22.06 122.84,21.08 121.78,21.08 119.03,18.32 119.03,18.21 118.83,18.01 118.42,18.01 118.22,18.21 v2(118.22,18.39)
  BOTTOM w0.076: UC1.AT46 v2(146.46,58.59)
  BOTTOM w0.168: JDIMM1.151 118.37,18.54 v2(118.22,18.39)
DDR_A_MA15: length 66.4
  IN1 w0.076: 148.12,44.63 148.45,44.96 148.45,54.54 146.83,56.16 146.83,57.58 v2(146.46,57.95)
  IN1 w0.145: 148.12,44.63 148.12,39.37 145.9,37.15 145.9,36.95 146.02,36.82 146.02,36.62 145.82,36.41 145.61,36.41 145.49,36.54 145.29,36.54 145.08,36.33 145.08,36.13 145.2,36 145.2,35.8 145,35.59 144.79,35.59 144.67,35.72 144.47,35.72 144.26,35.51 144.26,35.31 144.38,35.18 144.38,34.98 144.18,34.77 143.97,34.77 143.85,34.9 143.65,34.9 143.44,34.69 143.44,34.49 143.56,34.36 143.56,34.16 130.55,21.14 124.11,21.14 123.2,20.23 122.14,20.23 120.48,18.57 120.48,17.07 120.03,16.62 120.03,16.08 119.74,15.8 v2(119.53,15.8)
  BOTTOM w0.076: UC1.AU48 v2(146.46,57.95)
  BOTTOM w0.168: JDIMM1.156 119.62,13.17 120.15,13.69 120.15,15.17 v2(119.53,15.8)
DDR_A_MA16: length 65.8
  IN1 w0.076: 146.85,43.24 146.85,43.34 147.07,43.55 147.07,44.97 147.06,44.97 147.06,45.19 147.32,45.44 147.32,51.15 147.66,51.49 147.66,54 147.65,54.02 147.65,54.07 146.97,54.75 146.91,54.75 146.65,55.02 146.37,55.02 145.11,56.28 145.11,57.53 145.55,57.96 v2(145.55,58.03)
  IN1 w0.145: 146.85,43.24 146.85,39.98 130.16,23.29 129.85,23.29 129.04,22.48 123.65,22.48 122.67,21.5 121.61,21.5 119.01,18.9 118.1,18.9 117.77,18.57 117.77,17.34 v2(118.24,16.87)
  BOTTOM w0.076: UC1.AU50 145.17,57.65 v2(145.55,58.03)
  BOTTOM w0.168: JDIMM1.152 118.62,12.62 118.96,12.96 118.96,16.15 v2(118.24,16.87)
DDR_A_ODT0: length 70.9
  IN1 w0.076: v2(147.38,57.99) 147.66,57.71 148.41,57.71 148.67,57.46 148.67,56.61 149.83,55.45 149.83,46.92 149.68,46.77
  IN1 w0.145: 149.68,46.77 149.68,38.15 130.63,19.1 129.15,19.1 128.61,18.57 128.61,17.52 128.46,17.37 127.58,17.37 127.44,17.23 127.44,16.88 127.58,16.74 128.37,16.74 128.51,16.59 128.51,16.07 128.37,15.93 126.72,15.93 126.48,16.17 126.48,17.53 126.33,17.68 126.01,17.68 125.86,17.53 125.86,16.17 125.34,15.64 121.71,15.64 v2(121.58,15.78)
  BOTTOM w0.076: UC1.AT45 147.72,58.3 147.38,57.96 v2(147.38,57.99)
  BOTTOM w0.168: JDIMM1.155 119.37,18.89 121.09,17.17 121.09,16.26 v2(121.58,15.78)
DDR_A_ODT1: length 72.4
  IN1 w0.076: 150.1,46.82 150.1,55.5 149.49,56.12 149.49,57.3 149.19,57.6 148.89,57.6 148.41,58.08 v2(148.3,58.08)
  IN1 w0.145: 150.1,46.82 150.1,37.96 134.42,22.27 134.42,22.07 134.96,21.53 134.96,21.33 134.75,21.12 134.55,21.12 134.01,21.66 133.8,21.66 133.6,21.45 133.6,21.25 134.14,20.71 134.14,20.51 133.93,20.3 133.73,20.3 133.19,20.84 132.98,20.84 132.78,20.63 132.78,20.43 133.32,19.89 133.32,19.69 133.11,19.48 132.91,19.48 132.37,20.02 132.16,20.02 131.55,19.41 131.55,16.38 130.62,15.45 126.4,15.45 126.17,15.22 123,15.22 v2(122.36,14.58)
  BOTTOM w0.076: UC1.AT43 148.52,58.3 v2(148.3,58.08)
  BOTTOM w0.168: v2(122.36,14.58) 122.03,14.91 122.03,18.39 121.68,18.75 121.25,18.75 120.87,19.12 JDIMM1.161
DDR_A_PARITY: length 64.1
  IN1 w0.076: 146.14,44.18 146.44,44.48 146.57,44.61 146.57,53.55 145.88,54.23 145.88,54.51 144.54,55.86 144.54,57.13 v2(143.72,57.95)
  IN1 w0.145: 146.14,44.18 145.53,43.57 145.53,40.46 129.64,24.57 123.93,24.57 122.21,22.84 120.26,22.84 119.37,21.95 119.37,21.57 119.52,21.42 119.52,21.21 119.12,20.81 118.87,20.81 118.64,21.04 118.44,21.04 116.04,18.65 116.04,17.32 115.89,17.18 115.66,17.18 115.56,17.28 v2(115.56,17.58)
  BOTTOM w0.076: UC1.AT52 v2(143.72,57.95)
  BOTTOM w0.168: v2(115.56,17.58) 115.01,18.13 115.01,18.56 114.37,19.19 JDIMM1.143
