# Allegro board LAC621PR10-0924-A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.2V_MEN_P on TOP (solid shape): 73.19,51.54 73.19,51.18 73.19,51.18 73.19,50.83 73.19,50.8 73.19,50.27 73.19,50.22 73.19,49.66 73.19,49.61 73.19,49.05 73.19,49 73.19,48.47 73.19,48.42 73.19,47.83 73.19,47.55 73.41,47.32 74.13,47.32 74.33,47.12 74.33,46.08 74.29,46.03 73.52,46.03 73.42,45.93 73.42,45.55 73.35,45.47 73.01,45.47 72.99,45.5 72.99,46 72.94,46.05 72.27,46.05 72.22,46 72.22,45.5 72.2,45.47 71.84,45.47 71.79,45.52 71.79,45.95 71.75,46 69.36,46 68.9,46.46 68.9,50.56 70.01,51.66 73.07,51.66
+1.2V_MEN_P on BOTTOM (solid shape): 89.22,57.76 89.22,57.03 89.14,56.95 88.75,56.95 88.75,56.39 88.52,56.39 88.52,56.95 88.15,56.95 88.07,57.03 88.07,57.71 88.23,57.87 89.11,57.87
+1.2V_MEN_P on BOTTOM (solid shape): 74.84,56.8 74.84,52.56 74.28,52 73.65,52 73.19,51.54 73.19,50.81 73.19,50.27 73.19,49.61 73.19,47.83 73.19,47.55 73.34,47.4 74.15,47.4 74.33,47.22 74.33,46.07 74.26,46 73.58,46 73.58,45.45 73.08,45.45 73.08,46 72.38,46 72.38,45.45 71.88,45.45 71.88,46 69.36,46 68.94,46.42 68.94,47.67 68.76,47.85 68.76,49.12 68.54,49.33 68.54,50.6 68.16,50.98 68.16,51.49 67.95,51.71 67.95,52.94 67.94,52.95 67.94,54.05 67.16,54.83 67.16,54.83 66.93,55.06 66.93,56.18 68.11,57.36 74.28,57.36
+1.5V_RUN on BOTTOM (solid shape): 212.84,98.75 212.84,98.21 214.01,98.21 214.39,97.83 214.39,97.83 215,97.22 215,97.13 214.99,97.12 214.92,96.99 214.91,96.85 214.88,96.77 214.81,96.74 214.09,96.74 213.88,96.95 213.87,96.96 213.79,97.07 213.68,97.15 213.67,97.16 213.59,97.24 213.59,97.27 213.42,97.68 212.97,97.64 212.96,97.63 212.85,97.63 212.83,97.64 212.58,97.73 212.32,97.63 212.28,97.63 212.24,97.67 212.24,98.2 212.26,98.21 212.61,98.21 212.64,98.24 212.64,98.77 212.82,98.77
+1.5V_RUN on IN3 (solid shape): 215.05,97.22 215.05,97.17 214.91,96.92 214.99,96.64 214.99,96.08 214.76,95.85 213.93,95.85 213.81,95.96 213.81,96.56 213.91,96.8 213.81,97.05 213.81,97.23 214.04,97.46 214.8,97.46
+1.5V_RUN on IN3 (solid shape): outline of 768 points within 219.85,92.85 242.07,97.5
+1.5V_RUN on IN3 (solid shape): outline of 2061 points within 237.4,40.72 256.86,86.49
+1.5V_VIN on BOTTOM (solid shape): 216.96,104.87 216.96,103.05 217.15,102.85 223.67,102.85 224.02,102.51 224.02,101.62 224.04,101.59 224.53,101.59 224.55,101.57 224.55,101.44 224.53,101.41 224.04,101.41 224.02,101.39 224.02,101.01 223.61,100.6 220.51,100.6 220.13,100.22 216.83,100.22 216.25,100.8 216.25,104.92 216.4,105.07 216.75,105.07
+1.8V_PRIM on TOP (solid shape): 229.52,98.05 229.52,96.64 229.44,96.56 228.64,96.56 228.55,96.65 227.59,96.65 227.5,96.56 226.88,96.56 226.69,96.76 226.69,98.08 226.69,98.08 226.69,98.21 226.83,98.35 229.22,98.35
+1.8V_PRIM on TOP (solid shape): outline of 655 points within 163.97,62.44 179.08,66.51
+1.8V_PRIM on BOTTOM (solid shape): 177.63,65.74 178.37,65.74 178.57,65.54 178.57,64.3 178.48,64.2 176.47,64.2 174.45,66.22 174.13,66.22 174.01,66.11 172.86,66.11 172.76,66.21 172.76,66.37 172.83,66.45 176.92,66.45
+1.8V_PRIM on BOTTOM (solid shape): 211.42,101.64 211.42,101.16 211.45,101.13 211.95,101.13 211.98,101.16 211.98,101.67 212,101.69 212.21,101.69 212.23,101.67 212.23,101.16 212.26,101.13 212.77,101.13 212.79,101.16 212.79,101.64 212.84,101.69 213.12,101.69 213.25,101.57 213.25,100.98 211.78,99.51 211.78,99.38 211.73,99.34 211.73,97.21 211.62,97.1 211.62,96.31 211.78,96.15 211.78,94.53 211.47,94.22 210.53,94.22 210.02,94.73 210.02,96.21 209.74,96.49 209.74,99.38 211.09,100.73 211.09,101.67 211.12,101.69 211.37,101.69
+1.8V_PRIM on BOTTOM (solid shape): 190.96,64.19 190.96,62.82 190.8,62.66 190.36,62.66 189.98,63.12 189.61,62.66 189.45,62.66 189.1,62.31 188.34,62.31 188.21,62.44 188.2,62.46 188.2,62.48 188.15,62.75 187.94,62.91 187.92,62.92 187.9,62.95 187.9,64 188.08,64.18 188.32,64.18 188.39,64.11 188.74,63.67 189.14,64.06 189.15,64.11 189.18,64.14 189.26,64.23 190.92,64.23
+1.8V_PRIM on IN1 (solid shape): outline of 272 points within 176,62.95 189.65,66.72
+1.8V_PRIM on IN3 (solid shape): 213.44,93.09 213.44,92.92 213.06,92.55 212.47,92.55 212.29,92.73 212.29,92.82 212.11,93 212.02,93.16 211.85,93.26 211.73,93.38 211.59,93.38 211.59,93.37 211.31,93.37 210.37,94.31 210.37,94.62 210.68,94.92 211.6,94.92
+1.8V_PRIM on IN3 (solid shape): 189.9,64.8 189.9,63.66 189.37,63.12 188.1,63.12 187.66,63.56 187.66,64.04 188.38,64.04 188.39,63.98 188.4,63.93 188.42,63.87 188.45,63.83 188.49,63.78 188.53,63.75 188.58,63.72 188.63,63.69 188.68,63.68 188.74,63.67 188.79,63.67 188.85,63.68 188.9,63.69 188.95,63.72 189,63.75 189.04,63.78 189.07,63.83 189.1,63.87 189.12,63.93 189.14,63.98 189.15,64.04 189.14,64.09 189.13,64.15 189.11,64.2 189.09,64.25 189.06,64.29 189.02,64.33 188.97,64.37 188.93,64.4 188.87,64.42 188.82,64.43 188.76,64.43 188.71,64.43 188.65,64.42 188.6,64.4 188.55,64.37 188.51,64.33 188.47,64.29 188.44,64.25 188.41,64.2 188.39,64.15 188.38,64.09 188.38,64.04 187.66,64.04 187.66,65.15 187.85,65.33 189.37,65.33
+1.8V_PRIM on IN3 (solid shape): outline of 177 points within 210.27,96.91 227.86,99.81
+1.8V_RUN_CARD on TOP (solid shape): 303.4,22.83 303.4,21.02 302.71,20.33 301.6,20.33 301.41,20.51 301.41,22.75 301.72,23.06 303.17,23.06
+1.8V_RUN_CARD on TOP (solid shape): 260.9,41.51 260.9,41.41 260.84,41.36 259.85,41.36 259.4,40.9 258.61,40.9 258.48,41.02 258.48,41.23 258.6,41.34 259.22,41.34 259.32,41.33 259.42,41.34 259.54,41.34 259.57,41.38 259.6,41.38 259.78,41.56 260.84,41.56
+1.8V_RUN_CARD on BOTTOM (solid shape): 303.31,21.52 303.31,21.17 303.06,20.91 303.06,20.56 302.85,20.35 300.46,20.35 300.35,20.47 300.35,21.54 300.53,21.72 303.11,21.72
+1.8V_RUN_CARD on IN1 (solid shape): 303.27,22.14 303.27,20.82 303.22,20.77 302.09,20.77 301.86,21.01 301.86,22.41 301.94,22.5 302.92,22.5
+1.8V_RUN_CARD on IN1 (solid shape): outline of 89 points within 258.08,40.72 260.82,42.98
+1.8VALWP on TOP (solid shape): 214.26,104.27 214.26,103.31 214.13,103.18 212.89,103.18 212.71,103.36 212.71,104.27 212.81,104.37 214.16,104.37
+1.8VALWP on BOTTOM (solid shape): 214.65,105.6 214.65,104.83 214.63,104.81 214.63,103.35 214.65,103.33 214.65,102.38 214.11,101.84 212.64,101.84 212.61,101.82 212.61,101.34 212.59,101.31 212.41,101.31 212.39,101.34 212.39,101.82 212.36,101.84 211.85,101.84 211.83,101.82 211.83,101.34 211.8,101.31 211.62,101.31 211.57,101.36 211.57,101.82 211.55,101.84 211.09,101.84 211.04,101.9 211.04,103.17 212.03,104.16 212.03,105.68 212.11,105.76 214.49,105.76
+1VALWP on TOP (solid shape): 213.92,52.89 213.92,50.84 213.65,50.57 213.22,50.57 213.21,50.57 213.07,50.6 212.93,50.57 212.92,50.57 212.61,50.57 212.6,50.57 212.46,50.6 212.32,50.57 212.31,50.57 211.8,50.57 211.79,50.57 211.64,50.6 211.5,50.57 211.49,50.57 211.21,50.57 211.2,50.57 211.06,50.6 210.92,50.57 210.91,50.57 210.41,50.57 210.08,50.9 210.08,52.86 210.21,52.99 213.82,52.99
+1VALWP on BOTTOM (solid shape): 210.91,53.19 211.61,53.19 211.61,53.67 212.11,53.67 212.11,53.19 212.89,53.19 212.89,53.67 216.9,53.67 217.16,53.42 217.16,50.4 216.9,50.14 214.77,50.14 214.31,50.6 213.09,50.6 213.04,50.6 212.48,50.6 212.43,50.6 211.67,50.6 211.62,50.6 211.44,50.6 211.39,50.6 211.08,50.6 211.04,50.6 210.86,50.6 210.81,50.6 209.61,50.6 209.13,51.08 209.13,52.68 209.64,53.19 210.41,53.19 210.41,53.67 210.91,53.67
+1VALWP_B+ on TOP (solid shape): outline of 97 points within 225.3,55.02 229.78,59.49
+1VALWP_B+ on BOTTOM (solid shape): 227.35,57.04 227.35,56.08 226.98,54.38 227.32,52.67 227.31,52.58 227.23,52.53 225,52.53 224.95,52.58 224.95,54.59 225.34,54.97 225.34,57.64 225.51,57.81 226.58,57.81
+1VS_VCCIOP on TOP (solid shape): 198.44,57.99 198.44,57.15 198.54,57.05 198.7,57.05 198.71,57.05 198.84,57.03 198.97,57.05 198.98,57.05 199.29,57.05 199.3,57.05 199.43,57.03 199.56,57.05 199.57,57.05 199.9,57.05 199.91,57.05 200.04,57.03 200.17,57.05 200.18,57.05 200.48,57.05 200.49,57.05 200.62,57.03 200.75,57.05 200.8,57.05 201.36,56.49 201.36,54.87 201.22,54.73 199.46,54.73 199.16,55.03 198.41,55.03 197.42,56.02 197.42,56.47 196.87,56.47 196.87,56.76 197.42,56.76 197.42,57.27 196.87,57.27 196.87,57.56 197.42,57.56 197.42,58.02 197.5,58.09 198.33,58.09
+1VS_VCCIOP on BOTTOM (solid shape): 201.69,56.9 201.69,54.69 201.15,54.16 198.55,54.16 197.37,55.34 197.37,56.96 197.44,57.03 201.56,57.03
+2.5V_MEM on TOP (solid shape): 221.44,39.32 222.49,39.32 222.57,39.25 222.57,38.64 222.46,38.54 220.89,38.54 220.81,38.61 220.81,39.27 220.86,39.32 221.26,39.32 221.26,39.88 221.44,39.88
+2.5V_MEM on TOP (solid shape): 234.02,21.04 234.02,20.65 231.99,18.62 229.84,18.62 229.41,18.78 229.14,18.4 229.17,18.27 229.24,18.16 229.15,18.06 228.99,18.06 228.92,17.99 227.8,17.99 226.93,17.99 226.78,18.13 226.78,19.83 227.16,20.21 231.57,20.21 231.61,20.17 231.97,20.17 232.22,20.42 232.22,20.5 233.01,21.29 233.77,21.29
+2.5V_MEM on TOP (solid shape): outline of 134 points within 144.03,14.47 147.84,19.78
+2.5V_MEM on BOTTOM (solid shape): 228.56,20.78 228.56,18.5 228.05,17.99 227.16,17.99 226.66,18.5 226.66,20.78 226.78,20.91 226.81,20.91 228.43,20.91
+2.5V_MEM on IN2 (solid shape): 146.82,19.69 146.82,17.99 146.6,17.76 145.07,17.76 144.99,17.85 144.92,17.91 144.92,18.88 145.86,19.82 146.7,19.82
+2.5V_MEM on IN2 (solid shape): 228.13,20.2 228.13,18.09 228,17.96 227.94,17.96 227.93,17.96 227.8,17.99 227.67,17.96 227.66,17.96 227.34,17.96 226.94,18.37 226.94,20.32 227.07,20.46 227.86,20.46
+2.5V_VIN on TOP (solid shape): 227.65,45.22 227.65,42.37 227.9,42.12 231.13,42.12 231.3,41.94 231.3,39.91 231,39.6 230.4,39.6 230.4,39.04 230.22,39.04 230.22,39.6 229.86,39.6 228.99,39.6 228.81,39.65 228.64,39.6 226.61,39.6 225.02,41.2 225.02,45.09 225.34,45.42 227.44,45.42
+3.3V_1.8V_PGPPA on TOP (solid shape): 188.71,56.6 188.71,55.48 188.42,55.19 188.08,55.19 187.01,56.26 187.01,56.51 187.18,56.68 188.62,56.68
+3.3V_1.8V_PGPPA on BOTTOM (solid shape): 189.06,61.93 189.06,55.58 188.56,55.07 188.25,55.07 186.93,56.39 186.93,58.41 187.44,58.91 187.44,61.57 187.66,61.79 187.91,61.85 188.06,62.06 188.94,62.06
+3.3V_1.8V_PGPPA on IN3 (solid shape): 188.78,57.13 188.78,55.6 188.38,55.2 186.14,55.2 185.18,56.16 185.18,57.41 185.25,57.48 188.43,57.48
+3.3V_1.8V_PGPPA on IN3 (solid shape): outline of 733 points within 165.47,53.7 175.58,61.75
+3.3V_1.8V_PGPPG on TOP (solid shape): 175.16,64.72 179.92,64.72 179.97,64.67 179.97,64.19 179.92,64.14 179.92,63.83 179.63,63.54 178.53,63.54 178.5,63.57 178.5,63.59 178.12,63.97 177.74,63.59 177.74,63.57 177.71,63.54 177.34,63.54 177.34,63.54 176.83,63.54 176.52,63.85 175.97,63.85 175.95,63.85 175.93,63.87 175.61,64.05 175.28,63.87 175.26,63.85 175.24,63.85 174.2,63.85 173.95,64.1 173.95,64.73 174.07,64.85 175.03,64.85
+3.3V_1.8V_PGPPG on IN2 (solid shape): outline of 519 points within 164.58,64.22 175.02,67.24
+3.3V_ALW on TOP (solid shape): 249.36,40.47 249.36,38.97 249.29,38.89 248,38.89 247.7,39.19 247.7,40.33 248.17,40.8 249.03,40.8
+3.3V_ALW on TOP (solid shape): 263.49,74.76 264.12,74.76 264.25,74.63 264.25,74.12 264.12,73.99 260.82,73.99 260.69,74.12 260.69,74.88 260.95,75.14 263.1,75.14
+3.3V_ALW on TOP (solid shape): 92.85,81.59 92.85,81.31 92.39,80.85 91.25,80.85 91.12,80.98 90.94,80.98 90.82,81.11 90.82,81.44 90.89,81.51 92.21,81.51 92.42,81.72 92.72,81.72
+3.3V_ALW on TOP (solid shape): 295.77,47.64 295.77,40.19 295.62,40.03 295.11,40.03 295.01,40.14 295.01,47.68 295.07,47.74 295.67,47.74
+3.3V_ALW on TOP (solid shape): 266.19,34.89 266.19,34.14 266,33.94 265.93,33.91 265.79,33.91 265.64,33.76 265.29,33.76 265.26,33.79 265.06,33.79 264.91,33.94 264.91,34.78 265.11,34.98 266.1,34.98
+3.3V_ALW on TOP (solid shape): 280.26,58.61 280.26,56.37 279.95,56.06 279.36,56.06 279.23,56.19 279.23,57.05 279.52,57.34 279.52,57.34 279.52,58.23 279.15,58.6 278.5,58.6 278.42,58.68 278.42,58.8 278.55,58.93 279.39,58.93 279.46,59.01 279.87,59.01
+3.3V_ALW on TOP (solid shape): 188.72,33.69 188.72,31.93 188.59,31.8 188.01,31.8 187.93,31.89 187.93,32.71 187.68,32.96 187.14,32.96 186.93,33.18 181.72,33.18 181.45,32.91 181.45,32.55 181.35,32.46 181.12,32.46 181.11,32.45 181.04,32.45 180.34,32.45 180.16,32.64 180.16,33.61 180.39,33.84 188.56,33.84
+3.3V_ALW on TOP (solid shape): 208.2,104.3 208.2,102.03 209.15,101.08 210.14,101.08 210.14,101.63 210.39,101.63 210.39,101.09 210.94,101.09 210.94,101.63 211.19,101.63 211.19,101.08 211.67,101.08 211.67,100.74 211.24,100.31 209.73,100.31 209.35,99.93 207.72,99.93 207.35,100.3 207.35,100.64 207.43,100.73 207.43,104.28 207.56,104.41 208.09,104.41
+3.3V_ALW on TOP (solid shape): 219.18,29.38 219.18,29.05 219.03,28.9 218.52,28.9 218.44,28.83 218.44,28.74 218.53,28.65 219.5,28.65 219.69,28.84 220.99,28.84 221.26,29.11 222.06,29.11 222.15,29.03 222.15,28.32 221.88,28.05 221.22,28.05 221.13,27.95 218.01,27.95 217.53,28.44 217.53,28.86 217.59,28.92 218.01,28.92 218.2,29.11 218.2,29.26 218.41,29.47 219.08,29.47
+3.3V_ALW on TOP (solid shape): 267.12,14.89 267.12,11.93 266.88,11.77 266.82,11.49 266.82,10.75 266.58,10.52 266.58,9.68 266.13,9.22 266.13,8.31 266,8.18 264.83,8.18 264.78,8.23 264.78,9.15 265.11,9.48 265.11,10.51 265.24,10.64 265.24,13.88 265.25,13.88 265.25,14.91 265.38,15.04 266.97,15.04
+3.3V_ALW on TOP (solid shape): 290.36,64.65 290.36,64.53 290.33,64.5 290.13,64.29 290.05,64.01 289.85,63.81 289.84,63.81 289.63,63.59 289.63,62.82 289.24,62.44 288.63,62.44 288.56,62.51 288.56,62.9 288.59,62.93 288.59,63.93 288.75,64.09 288.79,64.09 288.84,64.09 288.89,64.09 289.04,64.09 289.32,64.37 289.32,64.77 289.39,64.85 290.16,64.85
+3.3V_ALW on TOP (solid shape): 230.1,39.42 230.1,38.92 230.53,38.92 230.53,39.42 230.56,39.45 231.13,39.45 231.14,39.44 232.22,39.44 233.21,38.45 233.21,38.45 233.8,37.86 233.8,36.64 233.34,36.18 233.34,35.27 233.59,35.02 233.6,35 233.61,34.93 233.64,34.85 233.64,34.76 233.68,34.72 233.68,34.19 233.57,34.08 232.88,34.08 232.38,34.58 232.38,36.51 232.32,36.56 232.32,36.59 231.04,37.88 229.68,37.88 229.51,38.05 229.51,39.35 229.61,39.45 230.07,39.45
+3.3V_ALW on TOP (solid shape): 253.2,41.27 253.2,40.06 253.07,39.93 252.69,39.93 252.54,39.78 252.45,39.76 252.38,39.72 251.92,39.72 251.75,39.72 251.69,39.66 251.69,39.12 251.44,38.87 250.79,38.87 250.74,38.92 250.74,39.66 250.78,39.7 251.06,39.82 251.17,40.11 251.17,40.19 251.47,40.49 251.47,40.71 251.47,40.71 251.47,41.24 251.7,41.47 253,41.47
+3.3V_ALW on TOP (solid shape): 244.11,76.36 244.11,74.4 244.46,74.04 245.15,74.04 245.3,73.89 245.3,73.46 245.07,73.23 244.54,73.23 244.39,73.08 244.39,72.98 244.31,72.9 244.31,71.66 244.56,71.4 246.14,71.4 247,72.27 249.67,72.27 250.23,72.83 253.81,72.83 254.01,72.62 254.01,72.06 253.78,71.84 253,71.84 252.84,71.68 252.84,70.79 252.68,70.63 251.33,70.63 251.32,70.62 250.38,70.62 250.35,70.64 246.19,70.64 246.16,70.62 243.9,70.62 243.6,70.92 243.6,71.28 243.45,71.43 243.45,72.42 243.05,72.81 243.05,73.88 243.21,74.04 243.21,74.72 242.86,75.08 242.86,76.43 242.99,76.56 243.9,76.56
+3.3V_ALW on TOP (solid shape): 245.79,49.63 247.1,49.63 247.17,49.55 247.17,48.86 247.04,48.73 245.19,48.73 245.18,48.74 244.72,48.63 244.71,48.17 244.72,48.15 244.72,48.02 244.71,48 244.64,47.77 244.72,47.54 244.72,47.53 244.33,47.13 243.58,47.13 243.53,47.19 243.53,49.07 243.75,49.29 243.75,49.5 243.76,49.51 243.77,49.61 243.76,49.72 243.75,49.72 243.75,49.8 244.19,50.23 245.18,50.23
+3.3V_ALW on TOP (solid shape): 250.11,48.78 250.11,48.78 250.08,48.31 250.13,47.84 250.13,47.07 250.66,46.54 250.66,45.22 250.34,44.9 250.11,44.9 249.82,44.6 248.22,44.6 248.15,44.68 248.15,45.76 248.34,45.95 248.37,45.94 248.83,46.45 248.15,46.51 248.15,46.54 248.03,46.54 248.03,47.98 248.22,48.16 248.78,48.28 248.58,48.82 248.55,48.84 248.55,49.53 248.63,49.61 249.29,49.61
+3.3V_ALW on TOP (solid shape): outline of 99 points within 186.42,62.52 188.22,65.34
+3.3V_ALW on TOP (solid shape): 264.04,48.47 264.68,48.47 264.76,48.39 264.76,47.88 264.61,47.74 263.13,47.74 262.68,47.78 262.5,47.37 262.5,47.33 262.47,47.31 262.34,47.25 262.25,47.15 261.58,47.15 261.48,47.2 261.5,47.31 261.24,47.93 260.86,47.38 260.88,47.35 260.79,47.26 260.73,47.26 260.67,47.32 260.61,47.32 260.6,47.32 260.41,47.35 260.23,47.27 260.2,47.25 260.14,47.23 260.08,47.26 259.99,47.31 259.89,47.35 259.82,47.35 259.76,47.34 259.69,47.32 259.63,47.32 259.45,47.15 257.8,47.15 257.39,47.55 257.39,48.75 257.47,48.82 259.37,48.82 259.41,48.78 260.19,48.78 260.2,48.82 262.12,48.82 262.12,48.34 262.56,48.34 262.56,48.9 262.97,48.9 263.15,48.9 263.61,48.9
+3.3V_ALW on TOP (solid shape): outline of 243 points within 245.27,90.55 255.71,99.47
+3.3V_ALW on BOTTOM (solid shape): 227.51,52.28 227.64,52.08 227.76,51.88 227.77,51.87 227.77,50.45 227.72,50.4 226.83,50.4 226.73,50.5 226.73,51.59 226.27,52.05 224.95,52.05 224.95,52.35 227.44,52.35
+3.3V_ALW on BOTTOM (solid shape): 207.61,67.68 207.09,67.68 207.07,67.66 207.07,66.91 207.08,66.9 207.09,66.9 207.61,66.9 207.64,66.87 207.64,66.48 207.61,66.46 207.09,66.46 207.07,66.44 207.07,65.73 207.61,65.73 207.64,65.7 207.64,65.07 208.06,64.65 208.06,63.4 207.81,63.15 205.62,63.15 205.45,63.33 205.45,67.95 205.7,68.2 207.61,68.2
+3.3V_ALW on BOTTOM (solid shape): 92.85,81.56 92.86,81.5 92.87,81.45 92.87,80.74 92.87,80.59 93.17,80.29 94.63,80.29 95.35,79.57 95.35,78.06 95.08,77.79 94.72,77.79 94.22,78.3 94.22,78.54 93.99,78.77 93.85,78.77 93.31,79.3 93.18,79.43 92.87,79.43 92.86,79.42 92.38,79.42 92.21,79.58 92.21,80.34 91.99,80.57 91.35,80.57 91.25,80.67 91.25,81.21 91.44,81.4 92.04,81.4 92.17,81.42 92.28,81.48 92.32,81.52 92.34,81.55 92.49,81.69 92.72,81.69
+3.3V_ALW on BOTTOM (solid shape): 246.22,93.09 246.24,93.09 246.48,92.89 246.76,92.82 246.92,92.82 247.31,92.43 247.31,89.49 246.9,89.08 246.9,88.7 247.08,88.52 247.08,87.84 247.31,87.61 248.44,87.61 248.8,87.25 248.8,87.1 248.72,87.01 248.46,87.01 248.41,87.01 248.12,86.72 248.12,86.3 248.14,86.28 248.14,85.89 247.86,85.61 247.33,85.61 246.97,85.97 246.95,85.98 246.95,86 246.95,86.2 246.79,86.36 246.78,86.39 246.78,86.41 246.72,86.77 246.39,86.92 246.26,86.91 246.14,86.85 246.11,86.84 246.08,86.86 245.4,87.53 245.39,87.57 245.4,87.6 245.47,87.92 245.28,88.17 245.26,88.19 245.25,88.22 245.25,90.72 245.26,90.75 245.27,90.76 245.42,91.24 244.97,91.46 244.95,91.45 244.93,91.46 244.82,91.57 244.82,92.79 245.12,93.09
+3.3V_ALW on BOTTOM (solid shape): outline of 714 points within 247.81,13.05 267.73,41.44
+3.3V_ALW on IN2 (solid shape): 233.52,35.46 233.52,34.2 234.04,33.69 234.85,32.87 240.16,32.87 240.44,32.59 240.44,31.78 239.97,31.31 238.22,31.31 237.73,30.82 233.75,30.82 231.89,32.68 231.89,32.7 231.85,32.84 231.76,32.96 231.74,32.99 231.74,34.87 232.52,35.65 233.33,35.65
+3.3V_ALW on IN2 (solid shape): outline of 339 points within 247.26,33.72 253.58,41.52
+3.3V_ALW on IN3 (solid shape): 181.44,32.87 181.44,32.45 181.83,32.06 181.83,31.15 181.69,31.01 180.46,31.01 180.25,31.22 180.25,32.88 180.36,32.99 181.33,32.99
+3.3V_ALW on IN3 (solid shape): outline of 208 points within 220.37,28.61 233.47,35.69
+3.3V_ALW on IN3 (solid shape): outline of 352 points within 255.59,47.23 260.57,61.95
+3.3V_ALW on IN4 (solid shape): outline of 980 points within 238.39,75.49 248.09,87.02
+3.3V_ALW on VCC: outline of 146 points within 91.15,36.58 305.13,111.18 ; 1 cut-out
+3.3V_ALW_DSW on TOP (solid shape): 180.7,61.83 180.7,61.25 180.6,61.15 180.43,61.15 180.43,61.14 180.24,61.14 180.05,60.95 180.05,59.63 179.75,59.33 179.73,59.33 179.69,59.29 175.81,59.29 175.61,59.48 175.61,59.81 176.85,59.81 176.85,59.75 176.87,59.7 176.89,59.65 176.91,59.6 176.95,59.55 176.99,59.51 177.03,59.48 177.08,59.46 177.14,59.44 177.19,59.43 177.25,59.43 177.3,59.43 177.36,59.45 177.41,59.47 177.45,59.5 177.5,59.53 177.53,59.57 177.57,59.62 177.59,59.67 177.6,59.72 177.61,59.78 177.61,59.84 177.6,59.89 177.59,59.94 177.57,59.99 177.53,60.04 177.5,60.08 177.45,60.12 177.41,60.15 177.36,60.17 177.3,60.18 177.25,60.19 177.19,60.19 177.14,60.18 177.08,60.16 177.03,60.13 176.99,60.1 176.95,60.06 176.91,60.02 176.89,59.97 176.87,59.92 176.85,59.86 176.85,59.81 175.61,59.81 175.61,60.45 175.63,60.47 175.66,60.51 175.69,60.56 175.7,60.62 175.71,60.66 175.78,60.73 176.27,60.73 176.27,60.74 177.79,60.74 178.14,61.09 178.14,61.61 178.47,61.94 180.59,61.94
+3.3V_ALW_DSW on IN1 (solid shape): 220.59,39.13 220.59,37.77 220.28,37.47 218.4,37.47 218.35,37.52 218.35,38.96 218.67,39.29 220.43,39.29
+3.3V_ALW_DSW on IN1 (solid shape): 176.68,60.15 176.71,60.14 176.9,60.14 177,60.04 177,60.04 176.9,59.81 177,59.58 177,59.03 175.55,57.59 174.59,57.59 174.38,57.79 174.38,58.5 175.7,59.82 175.93,59.82 176.26,60.15
+3.3V_ALW_DSW on IN4 (solid shape): outline of 943 points within 162.65,58.44 177.13,65.74
+3.3V_ALW_PCH on TOP (solid shape): 239.38,49.94 239.38,49.45 239.94,49.45 239.94,49.27 239.38,49.27 239.38,48.24 237.82,46.68 237.82,44.97 236.33,43.49 236.33,40.9 236.69,40.54 237.5,40.54 237.73,40.32 237.73,39.47 237.48,39.22 236.36,39.22 235.09,40.49 235.09,44.07 236.74,45.72 236.74,47.04 238.35,48.66 238.35,49.65 238.75,50.04 239.28,50.04
+3.3V_ALW_PCH on TOP (solid shape): outline of 126 points within 213.38,39.39 218.74,46.98
+3.3V_ALW_PCH on TOP (solid shape): outline of 660 points within 162.04,47.71 191.32,68.18
+3.3V_ALW_PCH on BOTTOM (solid shape): 176.92,84.99 176.92,84.32 175.92,83.32 175.53,83.32 175.52,83.3 174.37,83.3 174.25,83.42 174.25,84.03 174.3,84.08 174.46,84.08 174.54,84.17 174.58,84.17 174.58,84.18 174.75,84.36 175,84.36 175.03,84.39 175.13,84.39 175.39,84.65 175.87,84.65 176.36,85.14 176.77,85.14
+3.3V_ALW_PCH on BOTTOM (solid shape): 164.91,66.81 164.91,66.7 164.95,66.66 164.95,66.65 165.01,66.52 165.13,66.43 165.16,66.42 165.16,66.15 165.14,66.12 165.07,66.09 165.02,66.04 164.78,66.04 164.66,66.12 164.52,66.13 164.43,66.12 164.35,66.04 164.13,66.04 164.09,66.09 164.02,66.12 163.97,66.17 163.97,66.41 164.01,66.42 164.13,66.5 164.2,66.62 164.2,66.63 164.22,66.65 164.22,66.81 164.3,66.88 164.83,66.88
+3.3V_ALW_PCH on IN3 (solid shape): 236.54,40.21 238.44,40.21 238.49,40.16 238.49,39.63 238.19,39.32 235.7,39.32 235.44,39.58 235.44,40.31 235.55,40.42 236.33,40.42
+3.3V_ALW_PCH on IN3 (solid shape): 190.36,51.74 190.36,50.92 189.97,50.52 188.84,50.52 188.81,50.55 187.95,50.55 187.7,50.31 187.65,50.31 187.36,50.6 187.36,51.54 187.77,51.95 190.16,51.95
+3.3V_ALW_PCH on IN3 (solid shape): outline of 137 points within 217.6,38.24 222.89,41.63
+3.3V_ALW_PCH on IN3 (solid shape): outline of 772 points within 160.64,54.74 164.68,63.3
+3.3V_ALW_PCH on IN4 (solid shape): outline of 374 points within 157.87,62.5 162.62,69.79
+3.3V_ALW_PCH_UZ24 on TOP (solid shape): 242.28,49.74 242.28,47.2 242.21,47.13 241.35,47.13 241.03,47.45 240.4,47.45 240.17,47.68 240.17,48.19 239.97,48.39 239.79,48.39 239.51,48.67 239.51,49.14 240.07,49.14 240.07,49.57 239.51,49.57 239.51,49.86 242.15,49.86
+3.3V_ALW_UE1 on TOP (solid shape): 247.18,90.94 247.18,90.43 247.2,90.4 248.24,90.4 248.28,90.4 248.32,90.4 248.43,90.38 248.54,90.4 248.93,90.4 249.09,90.56 249.26,90.66 249.36,90.83 249.47,90.94 249.8,90.94 249.92,90.81 249.92,90.3 249.21,89.59 248.69,89.59 248.44,89.76 248.15,89.7 247.68,89.7 247.57,89.59 246.21,89.59 245.69,89.07 244.85,89.07 244.74,89.18 244.74,89.4 244.75,89.41 244.75,89.53 244.87,89.64 244.93,89.64 244.94,89.64 245.07,89.61 245.2,89.64 245.21,89.64 245.4,89.64 245.53,89.77 245.53,90.12 245.81,90.4 247.03,90.4 247.03,90.94 247.05,90.96 247.15,90.96
+3.3V_ALW_UE1 on BOTTOM (solid shape): outline of 453 points within 242.51,79.65 256.12,87.46
+3.3V_ALW_UE2 on TOP (solid shape): outline of 81 points within 261.44,48.47 263,52.51
+3.3V_ALW_UE2 on BOTTOM (solid shape): outline of 312 points within 262.14,49.33 265.47,54.54
+3.3V_ALWP on TOP (solid shape): 212.53,72.75 212.53,66.35 212.08,65.89 208.16,65.89 208.09,65.97 208.09,67.59 208.22,67.72 208.22,72.62 208.44,72.85 212.43,72.85
+3.3V_ALWP on BOTTOM (solid shape): 212.64,72.77 212.64,65.41 212.25,65.03 207.97,65.03 207.79,65.2 207.79,65.85 207.79,65.86 207.26,65.86 207.23,65.88 207.23,66.27 207.25,66.29 207.76,66.29 207.77,66.29 207.79,66.31 207.79,67.05 207.79,67.06 207.21,67.06 207.21,67.53 207.76,67.53 207.76,68.23 208.06,68.23 208.22,68.38 208.22,72.7 208.42,72.9 212.51,72.9
+3.3V_HDD on TOP (solid shape): 265.47,22.58 266,22.58 266.1,22.48 266.1,21.97 266,21.87 263.99,21.87 263.89,21.97 263.05,21.97 262.95,22.08 262.95,23.02 263,23.07 264.98,23.07
+3.3V_HDD on TOP (solid shape): 258.08,27.18 258.1,27.16 259.66,27.16 259.67,27.17 259.82,27.17 260.03,26.95 261.2,26.95 261.28,26.88 261.28,25.89 261.17,25.78 260.9,25.78 260.49,26.19 259.7,26.19 259.47,26.42 258.02,26.42 257.9,26.55 257.9,27.08 257.91,27.12 257.93,27.16 257.97,27.17 258.01,27.18
+3.3V_HDD on TOP (solid shape): 262.85,33.46 262.85,33.1 263.17,32.78 263.2,32.75 263.23,32.72 263.31,32.64 263.31,30.94 263.21,30.84 258.23,30.84 257.87,31.2 257.87,32.67 258.27,33.07 258.74,33.07 258.76,33.09 259.08,33.09 259.09,33.1 259.78,33.1 260.32,33.64 260.65,33.64 260.65,33.21 260.67,33.19 260.67,33.11 260.76,33.11 260.77,33.1 261.2,33.1 261.2,33.64 261.45,33.64 261.45,33.1 262,33.1 262,33.64 262.55,33.64 262.58,33.66 262.65,33.66
+3.3V_HDD on TOP (solid shape): outline of 170 points within 264.07,17.17 275.63,20.7
+3.3V_HDD on BOTTOM (solid shape): 275.14,19.49 275.14,17.1 275.07,17.02 274.9,17.02 274.89,17.02 274.76,17.05 274.63,17.02 274.62,17.02 274.48,17.02 274.36,17.15 274.36,18.14 274.2,18.29 273.6,18.29 273.42,18.47 273.42,19.74 273.6,19.92 274.71,19.92
+3.3V_HDD on IN1 (solid shape): outline of 270 points within 263.94,17.02 274.59,22.86
+3.3V_HDD on IN3 (solid shape): outline of 609 points within 257.87,21.75 265.09,32.24
+3.3V_HDD_M2 on TOP (solid shape): 233.39,31.96 233.39,31.45 233.23,31.3 231.76,31.3 231.74,31.27 231.13,31.27 230.95,31.45 230.95,32.01 231.02,32.08 233.26,32.08
+3.3V_HDD_M2 on TOP (solid shape): 243.88,33.35 243.88,33.18 244.26,32.8 244.97,32.8 245.12,32.64 245.12,32.16 245.02,32.06 244.07,32.06 243.52,31.5 243.52,30.66 243.04,30.18 242.28,30.18 242.15,30.31 242.15,30.56 242.77,31.18 242.77,32.3 243.09,32.62 243.09,33.56 243.17,33.63 243.6,33.63
+3.3V_HDD_M2 on TOP (solid shape): 272.63,14.48 273.14,14.48 273.14,15.03 273.43,15.03 273.43,14.48 273.9,14.48 275.01,14.48 275.3,14.2 275.3,11.38 275.2,11.28 271.82,11.28 271.69,11.15 271.66,11.15 271.66,11.13 271.61,11.08 271.61,10.86 271.4,10.65 270.67,10.65 270.45,10.88 270.45,14.13 270.8,14.48 272.34,14.48 272.34,15.03 272.63,15.03
+3.3V_HDD_M2 on TOP (solid shape): outline of 91 points within 222.36,24.26 227.7,32.16
+3.3V_HDD_M2 on BOTTOM (solid shape): 251.75,4.7 251.75,3.08 251.42,2.75 249.69,2.75 249.44,2.49 249.44,0.94 249.34,0.84 248.2,0.84 248.12,0.92 248.12,3.27 248.34,3.78 248.27,4.35 248.96,5.03 251.42,5.03
+3.3V_HDD_M2 on BOTTOM (solid shape): 266.53,4.6 266.53,4.16 266.53,4.15 266.5,3.93 266.53,3.71 266.53,3.7 266.53,0.99 266.41,0.87 265.68,0.87 265.6,0.9 265.58,0.99 265.58,1.03 265.58,2.28 265.42,2.53 265.12,2.49 265.05,2.46 264.98,2.49 264.88,2.55 264.77,2.56 264.67,2.59 264.66,2.69 264.19,3.19 264.07,2.52 264.09,2.49 264.08,2.45 264.03,2.37 264.02,2.28 264.02,1.03 264.02,0.99 264,0.9 263.92,0.87 262.24,0.87 262.11,0.99 262.11,4.65 262.5,5.03 266.1,5.03
+3.3V_HDD_M2 on BOTTOM (solid shape): outline of 617 points within 235.01,22.94 246.65,32.9
+3.3V_HDD_M2 on IN1 (solid shape): outline of 813 points within 223.21,23.88 246.85,30.48
+3.3V_HDD_M2 on IN3 (solid shape): 237.85,23.7 237.94,23.66 237.95,23.57 238.31,23.06 238.67,23.57 238.69,23.66 238.77,23.7 240.53,23.7 240.61,23.66 240.62,23.56 240.98,23.04 241.33,23.56 241.34,23.66 241.43,23.7 241.97,23.7 242.25,23.42 242.25,21.95 241.95,21.64 241.83,21.62 241.77,21.71 241.77,21.88 241.39,22.26 241.01,21.88 241.01,20.93 240.99,20.9 240.96,20.88 237.12,20.88 236.71,21.29 236.71,23.45 236.97,23.7
+3.3V_HDD_M2 on IN3 (solid shape): outline of 933 points within 249.77,1.29 274.9,12.63
+3.3V_LAN on TOP (solid shape): 268.77,100.36 268.77,99.47 268.47,99.17 261.98,99.17 261.83,99.31 261.83,100.54 262.03,100.74 268.39,100.74
+3.3V_LAN on TOP (solid shape): 273.9,81.26 273.9,81.16 273.82,81.08 272.88,81.08 272.78,80.98 272.78,80.83 272.58,80.62 272.25,80.62 272.1,80.78 272.1,81 272.38,81.28 272.55,81.28 272.63,81.36 273.8,81.36
+3.3V_LAN on TOP (solid shape): 276.21,74.71 276.21,73.31 276.27,73.24 277.01,73.24 277.13,73.12 277.13,72.69 277.01,72.57 275.63,72.57 275.55,72.65 275.55,73.16 275.75,73.36 275.75,74.71 275.83,74.78 276.14,74.78
+3.3V_LAN on TOP (solid shape): 273.93,76.35 273.93,76.11 273.9,76.08 272.91,76.08 272.83,76 271.92,76 271.64,75.72 271.51,75.72 271.37,75.86 271.37,76.17 271.59,76.38 273.9,76.38
+3.3V_LAN on TOP (solid shape): 272.71,79.38 273.93,79.38 273.98,79.33 273.98,79.1 273.93,79.05 272.91,79.05 272.78,78.92 272.43,78.92 272.2,78.69 270.75,78.69 270.65,78.79 270.65,79.15 270.76,79.26 271.78,79.26 271.99,79.48 272.6,79.48
+3.3V_LAN on TOP (solid shape): 250.89,55.73 250.89,54.31 250.48,53.9 249.89,53.9 249.48,53.9 249.48,53.38 249.45,53.35 249.32,53.35 249.3,53.37 249.3,53.9 248.85,53.9 248.83,53.88 248.7,53.88 248.55,54.03 248.55,55.63 248.75,55.83 250.79,55.83
+3.3V_LAN on TOP (solid shape): 259.27,93.63 259.55,93.63 259.68,93.5 259.68,93.07 259.5,92.89 257.82,92.89 257.57,92.64 257.57,92.38 257.55,92.37 257.55,91.94 257.36,91.75 256.94,91.75 256.46,91.27 256.46,90.77 254.77,89.08 254.16,89.08 254.04,89.21 254.04,90.05 254.42,90.43 254.49,90.46 254.57,90.43 255.11,90.41 255.12,90.95 255.1,90.99 255.12,91.03 255.73,91.64 255.8,91.64 256.31,92.14 256.31,92.47 256.73,92.89 256.78,92.89 257.76,93.87 259.03,93.87
+3.3V_LAN on TOP (solid shape): 273.59,85.78 273.59,84.78 273.8,84.57 273.8,84.24 273.79,84.22 273.77,84.21 273.55,83.86 273.77,83.51 273.79,83.51 273.8,83.48 273.8,83.4 273.55,83.15 272.96,83.15 272.82,83.01 272.6,83.01 272.5,83.11 272.5,83.36 272.52,83.39 272.53,83.39 272.79,83.69 272.65,84.06 272.64,84.06 272.63,84.09 271.94,84.79 270.17,84.79 270.13,84.8 270.12,84.84 270.12,86.24 270.24,86.36 270.61,86.36 270.62,86.36 271.16,86.91 272.46,86.91
+3.3V_LAN on BOTTOM (solid shape): 289.86,92.45 289.86,91.99 289.78,91.91 287.89,91.91 287.83,91.97 287.83,92.5 288.06,92.73 289.58,92.73
+3.3V_LAN on BOTTOM (solid shape): 254.65,90.36 254.85,90.3 255.05,90.36 255.54,90.36 255.66,90.24 255.66,89.5 255.58,89.43 254.68,89.43 254.35,89.1 254.17,89.1 254.03,89.24 254.03,90.12 254.02,90.13 254.02,90.28 254.1,90.36
+3.3V_LAN on IN1 (solid shape): 242.43,92.69 242.43,91.95 241.41,90.94 240.02,90.94 239.38,91.57 239.38,92.92 239.76,93.3 241.82,93.3
+3.3V_LAN on IN1 (solid shape): 259.87,92.14 259.87,91.61 259.83,91.39 259.93,91.18 260.03,91.01 260.21,90.91 260.3,90.9 260.39,90.91 260.56,90.91 260.76,90.72 260.76,90.42 260.01,89.67 258.89,89.67 258.23,90.33 258.23,90.73 257.92,91.04 256.17,91.04 255.76,91.44 255.76,92.84 255.92,92.99 255.99,93.02 256.06,92.99 256.6,93 256.6,93.53 256.57,93.61 256.6,93.68 256.86,93.93 258.07,93.93
+3.3V_LAN on IN1 (solid shape): outline of 202 points within 280.28,91.65 289.62,100.71
+3.3V_LAN on IN2 (solid shape): outline of 1051 points within 270.83,72.6 291.32,92.92
+3.3V_LAN on IN3 (solid shape): outline of 395 points within 235.9,86.72 240.88,93.93
+3.3V_LAN on IN3 (solid shape): outline of 472 points within 241.26,54.82 250.53,70.84
+3.3V_LAN on IN3 (solid shape): outline of 1030 points within 257.34,80.6 277.2,100.83
+3.3V_LAN_OUT on TOP (solid shape): 261.63,87.99 261.63,87.43 259.45,87.43 259.37,87.51 259.37,87.81 259.5,87.94 260.38,87.94 260.49,88.04 261.58,88.04
+3.3V_LAN_OUT on BOTTOM (solid shape): 257.59,88.6 258.46,88.6 258.68,88.37 258.92,88.16 259.22,88.24 259.34,88.24 259.36,88.23 259.57,88.17 259.79,88.23 259.81,88.24 259.93,88.24 259.94,88.23 260.17,88.17 260.39,88.24 261.23,88.24 261.35,88.12 261.35,87.51 261.15,87.3 260.22,87.3 260.03,87.36 259.84,87.3 257.83,87.3 257.3,86.78 255.42,86.78 254.56,87.64 254.56,87.79 254.57,87.81 254.64,88.03 254.57,88.25 254.56,88.26 254.56,88.38 254.57,88.39 254.63,88.53 254.63,88.68 254.65,88.77 254.73,88.8 257.39,88.8
+3.3V_LAN_OUT on IN4 (solid shape): outline of 208 points within 258.74,82.41 264.56,88.51
+3.3V_LAN_UZ2 on TOP (solid shape): outline of 90 points within 248.56,50.71 252.04,53.74
+3.3V_M on TOP (solid shape): 254.37,44.85 254.37,42.87 254.03,42.53 253.82,42.53 253.69,42.66 253.71,42.81 253.66,42.96 253.66,43.06 252.97,43.75 252.97,44.54 252.47,44.54 252.41,44.6 252.41,44.74 252.45,44.77 252.97,44.77 252.97,45.26 253.96,45.26
+3.3V_M on IN1 (solid shape): outline of 82 points within 244.38,39.55 249.6,42.81
+3.3V_M_TPM on TOP (solid shape): 186.33,64.91 186.33,64.22 186.27,64.01 186.35,63.81 186.35,63.21 186.32,63.14 186.25,63.11 186.11,63.08 185.99,63.01 185.37,63.01 185.21,63.17 185.2,63.18 185.12,63.3 185,63.38 184.99,63.39 184.72,63.66 184.72,64.95 184.95,65.18 186.06,65.18
+3.3V_M_TPM on TOP (solid shape): 191.15,63.85 191.15,63.24 191.1,63.19 190.41,63.19 190.31,63.08 190.31,62.62 189.99,62.31 189.96,62.29 188.5,62.29 188.39,62.39 188.39,63.02 188.49,63.12 188.65,63.16 188.77,63.26 188.82,63.22 189.21,63.16 189.45,63.47 189.45,63.48 189.94,63.97 191.02,63.97
+3.3V_M_TPM on TOP (solid shape): 187.87,73.54 187.87,72.83 187.79,72.6 187.87,72.37 187.87,72.19 187.83,71.79 188.18,71.58 189.06,70.69 189.06,69.57 188.96,69.47 188.86,69.47 188.73,69.6 188.73,70.44 188.48,70.69 187.92,70.69 187.06,71.56 187.06,72.36 187.34,72.63 187.34,73.54 187.39,73.59 187.82,73.59
+3.3V_M_UZ8 on TOP (solid shape): 252.84,45.22 252.84,44.9 252.3,44.9 252.29,44.88 252.29,44.44 252.31,44.42 252.41,44.42 252.41,44.41 252.84,44.41 252.84,43.67 252.64,43.46 251.5,43.46 251.2,43.17 251.17,43.17 250.99,43.19 250.82,43.11 250.75,43.09 250.69,43.12 250.43,43.21 250.18,43.12 250.09,43.01 250.05,42.88 249.59,42.42 249.31,42.49 249.06,42.34 248.96,42.24 248.35,42.24 248.17,42.42 248.17,43.23 248.25,43.31 249.01,43.31 249.54,43.84 249.8,43.84 249.95,44 250.04,44 250.09,44.05 250.17,44.05 250.48,44.05 250.69,44.29 250.7,44.33 251.22,44.33 251.37,44.48 251.37,45.01 251.8,45.44 252.61,45.44
+3.3V_MMI_AUX on TOP (solid shape): 268.16,43.87 268.16,42.74 268.52,42.38 268.52,41.55 268.42,41.44 268.08,41.44 267.78,41.14 267.78,40.62 267.6,40.44 266.97,40.44 266.79,40.62 265.77,40.62 265.44,40.95 264.17,40.95 264.12,41 264.12,41.05 264.2,41.13 266.13,41.13 266.2,41.2 266.71,41.2 266.86,41.36 266.86,42.85 267.03,43.02 267.29,43.02 267.39,43.12 267.39,43.95 267.48,44.05 267.98,44.05
+3.3V_MMI_IN on TOP (solid shape): 267.05,44.84 267.05,44.3 266.83,44.08 266.83,43.19 266.75,43.11 266.18,43.11 266.1,43.18 266.1,43.9 265.95,44.05 265.95,44.63 266.28,44.96 266.93,44.96
+3.3V_MMI_IN on TOP (solid shape): 258.76,45.65 258.76,45.07 258.88,44.95 258.88,43.93 258.72,43.76 258.72,43.51 258.69,43.13 259.02,42.92 259.19,42.82 259.4,42.82 259.43,42.82 259.88,42.37 260.77,42.37 260.87,42.27 260.87,42.12 260.85,42.08 260.12,42.07 260.09,42.07 259.46,42.07 259.38,42.09 259.31,42.09 259.23,42.09 259.16,42.07 258.93,42.07 258.79,42.11 258.65,42.11 258.6,42.09 258.53,42.06 258.5,42.06 258.38,41.94 258.38,41.88 258.38,41.87 258.35,41.74 258.38,41.61 258.38,41.6 258.38,41.31 258.36,41.28 258.36,41.08 258.33,41.05 257.85,41.05 257.75,41.15 257.75,41.69 257.61,41.82 257.61,42.43 256.81,43.23 256.81,44.13 257.34,44.13 257.34,44.64 256.79,44.64 256.79,44.93 257.34,44.93 257.34,45.44 256.79,45.44 256.79,45.79 258.62,45.79
+3.3V_MMI_IN on IN1 (solid shape): outline of 86 points within 257.95,43.92 267.32,46.89
+3.3V_PGPPD on TOP (solid shape): 182.82,64.35 182.82,63.59 182.62,63.39 181.91,63.39 181.74,63.56 181.74,64.07 181.65,64.42 181.31,64.54 181.22,64.64 181.22,65.11 181.28,65.18 181.98,65.18
+3.3V_PGPPD on IN3 (solid shape): outline of 648 points within 165.72,63.89 183.5,66.73
+3.3V_PGPPE on TOP (solid shape): 164.14,68.82 164.14,68.23 164.19,68.19 164.32,68.19 164.5,68 164.5,67.85 164.38,67.72 163.46,67.72 163.38,67.8 163.38,68.1 163.43,68.14 163.43,68.8 163.57,68.94 164.02,68.94
+3.3V_PGPPE on TOP (solid shape): 181.01,65.09 181.01,64.3 181.02,64.02 181.22,63.81 181.22,63.45 181.11,63.35 180.69,63.35 180.21,63.83 180.21,64.99 180.38,65.16 180.94,65.16
+3.3V_PGPPE on BOTTOM (solid shape): 164.76,68.48 164.76,68.28 164.53,68.05 164.53,67.87 164.41,67.76 164.37,67.72 164.17,67.72 164.1,67.8 164.02,67.8 163.93,67.81 163.82,67.8 163.76,67.75 163.72,67.72 163.48,67.72 163.45,67.75 163.4,67.78 163.36,67.82 163.36,68.05 163.51,68.2 163.7,68.2 163.96,68.09 164.19,68.26 164.19,68.27 164.48,68.56 164.68,68.56
+3.3V_PGPPE on IN4 (solid shape): outline of 600 points within 163.38,61.59 181.22,68.35
+3.3V_RUN on TOP (solid shape): 241.44,84.28 241.44,82.63 241.21,82.4 240.12,82.4 239.61,82.91 239.61,83.93 240.24,84.56 241.16,84.56
+3.3V_RUN on TOP (solid shape): 234.19,88.45 234.19,88.01 234.14,87.97 233.72,87.97 233.32,87.57 233.11,87.57 232.99,87.69 232.99,88.18 233.33,88.52 234.12,88.52
+3.3V_RUN on TOP (solid shape): 247.43,68.63 247.43,66.37 247.36,66.3 246.42,66.3 245.25,67.47 245.25,68.89 245.68,69.32 246.75,69.32
+3.3V_RUN on TOP (solid shape): 263.08,11.48 263.08,10.14 263.61,9.61 263.61,8.21 263.54,8.13 263.38,8.13 263.31,8.21 263.31,9.38 262.57,10.11 262.57,11.46 262.67,11.56 263,11.56
+3.3V_RUN on TOP (solid shape): 266.23,48.16 266.23,46.71 266,46.49 264.96,46.49 264.74,46.71 264.74,47.45 264.96,47.67 264.96,48.44 265.16,48.64 265.75,48.64
+3.3V_RUN on TOP (solid shape): 225.72,34.35 225.72,34.34 226.1,33.96 226.1,33.18 225.94,33.02 224.55,33.02 224.55,33.26 225.08,33.26 225.08,33.7 224.57,33.7 224.55,33.72 224.55,34.47 224.69,34.61 225.45,34.61
+3.3V_RUN on TOP (solid shape): 172.1,45.8 173.06,45.8 173.19,45.67 173.19,45.17 173.06,45.04 172.53,45.04 172.27,44.78 172.27,41.69 172.12,41.53 170.8,41.53 170.65,41.69 170.65,44.91 170.52,45.04 169.89,45.04 169.76,45.17 169.76,45.8 169.79,45.83 172.07,45.83
+3.3V_RUN on TOP (solid shape): 186.9,60.24 186.9,59.79 186.75,59.64 185.52,59.64 185.38,59.79 185.38,60.28 185.39,60.29 185.39,60.7 185.49,60.96 185.39,61.21 185.39,61.41 185.41,61.43 185.71,61.43
+3.3V_RUN on TOP (solid shape): 232.55,14.89 232.55,12.6 231.58,11.64 229.37,11.64 229.3,11.71 229.3,12.27 229.4,12.37 230.54,12.37 230.8,12.63 230.8,13.19 230.49,13.49 230.3,13.49 230.26,13.44 229.47,13.44 229.29,13.63 229.29,14.88 229.57,15.16 230.92,15.16 231.08,15.32 232.12,15.32
+3.3V_RUN on TOP (solid shape): 277.43,44.99 277.59,44.99 277.59,44.99 278,44.99 278,44.43 278.44,44.43 278.44,44.99 278.85,44.99 278.85,44.99 279.23,44.99 279.39,44.83 279.39,42.45 279.23,42.29 277.48,42.29 277.25,42.52 276.26,42.52 275.88,42.9 275.88,45.22 276,45.33 277.09,45.33
+3.3V_RUN on TOP (solid shape): 273.47,17.17 273.47,16.26 273.98,15.75 273.98,14.74 273.85,14.61 273.56,14.61 273.56,15.16 273.01,15.16 273.01,14.61 272.76,14.61 272.76,15.16 272.21,15.16 272.21,14.61 270.82,14.61 270.63,14.81 270.63,14.82 270.54,14.95 270.4,15.04 270.39,15.05 270.11,15.33 270.07,15.48 269.99,15.62 269.99,17.3 270.19,17.5 273.14,17.5
+3.3V_RUN on TOP (solid shape): 148.98,19.17 148.98,19.15 149.07,18.48 149.26,17.84 149.34,17.62 149.44,17.41 149.65,17.05 149.89,16.71 149.89,14.04 149.19,12.73 148.98,11.25 148.95,11.18 148.88,11.15 148.07,11.15 147.59,11.64 147.59,12.27 147.69,12.37 148.12,12.37 148.45,12.7 148.45,14.25 148.25,14.46 147.59,14.46 147.51,14.53 147.51,15.85 148.1,16.44 148.1,18.47 148.05,18.52 148.05,19.15 148.11,19.22 148.93,19.22
+3.3V_RUN on TOP (solid shape): 96.71,98.71 96.96,98.45 96.96,97.69 96.58,97.31 94.19,97.31 93.61,96.73 93.61,96.65 93.59,96.57 93.58,96.49 93.58,96.31 93.59,96.23 93.61,96.14 93.61,95.3 93.79,95.12 93.79,94.27 93.79,94.01 93.36,93.58 93.36,92.46 93.36,89.64 92.48,88.77 92.48,88.1 92.68,87.9 92.68,86.51 92.32,86.15 91.73,86.15 91.7,86.18 91.7,86.62 91.91,86.83 92.04,86.99 92.05,87.2 92.05,87.2 92.05,87.63 91.9,87.79 91.9,87.8 91.81,87.97 91.64,88.07 91.61,88.09 91.6,88.12 91.6,92.33 92.17,92.9 92.17,93.41 91.98,93.6 91.98,96.3 92.13,96.45 92.15,96.45 92.36,96.56 92.46,96.77 92.47,96.78 92.73,97.04 92.73,98.16 92.89,98.32 92.96,98.32 92.97,98.33 93.36,98.33 93.74,98.71 95.95,98.71
+3.3V_RUN on TOP (solid shape): 185.41,70.9 185.41,70.49 185.23,70.31 185.23,69.04 185.36,68.91 185.36,68.6 185.56,68.4 185.56,67.52 185.39,67.35 184.98,67.35 184.68,67.66 184.66,67.68 184.66,68.4 184.55,68.51 184.55,68.86 184.5,68.93 184.52,69.02 184.6,69.54 184.16,69.82 183.89,69.82 183.49,69.42 182.23,69.42 182.16,69.5 180.97,69.5 180.96,69.5 180.75,69.53 180.56,69.42 179.46,69.42 179.39,69.5 179.39,70.72 179.51,70.84 179.92,70.84 180,70.77 180,70.74 179.97,70.68 180.11,70.22 180.59,70.26 181.01,70.26 181.1,70.21 181.2,70.19 181.38,70.14 181.56,70.19 181.73,70.19 181.88,70.26 182.28,70.26 182.4,70.18 182.55,70.16 182.63,70.14 182.7,70.13 182.83,70.15 182.94,70.2 183,70.17 183.07,70.15 183.17,70.1 183.29,70.09 183.66,70.36 183.5,70.79 183.5,70.99 183.66,71.15 185.15,71.15
+3.3V_RUN on TOP (solid shape): outline of 227 points within 144.79,71.1 146.75,76.53
+3.3V_RUN on TOP (solid shape): outline of 253 points within 253.86,33.23 262.8,46.13
+3.3V_RUN on TOP (solid shape): outline of 278 points within 138.91,86.37 189.37,98.96
+3.3V_RUN on BOTTOM (solid shape): 153.39,93.14 153.39,92.52 153.17,92.31 151.73,92.31 151.55,92.49 151.55,92.94 151.83,93.22 153.3,93.22
+3.3V_RUN on BOTTOM (solid shape): 178.57,91.49 178.8,91.49 179.51,90.79 179.51,89.37 179.51,89.37 179.51,89.23 179.79,88.95 180.5,88.95 180.78,88.68 180.78,87.68 180.55,87.46 178.65,87.46 178.5,87.61 178.5,89.51 178.27,89.74 178.27,90.5 178.14,90.63 177.63,90.63 177.38,90.89 177.38,91.39 177.51,91.52 178.55,91.52
+3.3V_RUN on BOTTOM (solid shape): 190.46,83.77 190.46,83.67 190.44,83.65 190.44,83.53 190.42,83.49 190.42,83.44 190.42,82.72 189.93,82.22 189.37,82.22 189.06,82.53 189.06,82.63 189.19,82.76 189.72,82.76 189.88,82.91 189.88,83.44 189.7,83.62 189.52,83.62 189.47,83.67 189.47,83.77 189.52,83.82 190.41,83.82
+3.3V_RUN on BOTTOM (solid shape): 108.12,95.61 108.14,95.61 108.15,95.59 108.19,95.56 108.19,94.61 108.25,94.55 108.25,94.54 108.32,94.45 108.41,94.39 108.42,94.38 108.47,94.32 108.64,94.32 108.72,94.24 109,94.24 109.05,94.19 109.05,93.78 108.98,93.7 108.5,93.7 107.67,94.53 107.67,95.07 107.38,95.36 107.38,95.58 107.4,95.61
+3.3V_RUN on BOTTOM (solid shape): outline of 192 points within 182.16,59.52 187.03,71.58
+3.3V_RUN on BOTTOM (solid shape): outline of 210 points within 223.18,94.8 228.74,105.49
+3.3V_RUN on BOTTOM (solid shape): outline of 230 points within 264.58,46.46 280,54.11
+3.3V_RUN on IN1 (solid shape): 189.76,53.76 189.76,51.81 189.34,51.39 188.25,51.39 187.79,51.85 187.79,53.68 188.15,54.03 189.49,54.03
+3.3V_RUN on IN1 (solid shape): outline of 630 points within 207.49,35.82 254.75,45.8
+3.3V_RUN on IN2 (solid shape): 97.57,98.83 97.57,97.64 97.32,97.39 93.86,97.39 93.55,97.7 93.55,98.52 94.32,99.29 97.12,99.29
+3.3V_RUN on IN2 (solid shape): 280.06,50.52 280.13,50.5 280.2,50.5 280.65,50.5 280.67,50.52 281.19,50.52 281.42,50.3 281.42,44.73 279.61,42.93 279.61,42.89 279.54,42.76 279.51,42.61 277.75,42.61 277.74,42.63 277.74,44.58 279.21,46.05 279.21,50.32 279.41,50.52
+3.3V_RUN on IN3 (solid shape): outline of 81 points within 240.8,65.84 245.86,68.28
+3.3V_RUN on IN3 (solid shape): outline of 115 points within 232.68,82.48 236.08,88.64
+3.3V_RUN on IN3 (solid shape): outline of 663 points within 285.58,41.81 295.25,83.25
+3.3V_RUN on IN3 (solid shape): outline of 1063 points within 179.07,68.1 199.88,89.87
+3.3V_RUN on IN4 (solid shape): 187.97,61.62 187.97,60.23 187.67,59.92 185.71,59.92 185.42,60.21 185.42,60.74 185.49,60.96 185.42,61.17 185.42,61.61 185.57,61.76 187.83,61.76
+3.3V_RUN on IN4 (solid shape): 190.64,55.61 190.64,54.33 190.69,54.28 190.75,54.08 190.89,53.95 190.89,53.22 190.92,53.19 191.1,53.19 191.15,53.14 191.15,52.71 191.05,52.61 189.68,52.61 189.36,52.93 189.36,54.07 189.19,54.24 189.19,55.43 189.47,55.71 190.54,55.71
+3.3V_RUN on IN4 (solid shape): 139.81,98.51 139.81,97.92 137.68,95.79 131.63,95.79 131.36,96.07 124.99,96.07 124.8,96.12 124.61,96.07 124.31,96.07 124.12,96.12 123.94,96.07 123.92,96.07 123.76,96.07 123.33,95.63 118.16,95.63 118.01,95.48 117.93,95.42 117.87,95.34 117.11,94.59 114.56,94.59 114.39,94.76 114.39,95.22 114.93,95.76 116.02,95.76 117.27,97.02 123.14,97.02 123.71,97.59 135.03,97.59 135.23,97.39 135.57,97.18 135.91,97.39 136.64,97.39 138.26,99.01 139.31,99.01
+3.3V_RUN on VCC: outline of 177 points within 203.92,1.17 305.13,48.24
+3.3V_RUN on VCC: 296.38,68.4 296.38,77.15 287.72,85.81 269.43,85.81 268.9,85.28 265.28,85.28 264.75,85.81 247.76,85.81 247,85.04 243.06,85.04 240.77,82.76 233.87,82.76 231.35,85.28 231.35,87.18 229.94,88.6 226.63,88.6 222.49,92.74 222.49,104.67 222.9,105.08 225.36,105.08 228.03,107.75 228.29,107.39 228.66,107.13 228.81,106.98 250.37,106.98 250.52,107.13 251.23,107.93 251.18,109 252.17,109 252.17,110.45 251.06,110.45 251.06,111.18 256.33,111.18 256.33,109.87 256.36,109.84 260.69,105.69 265.53,109.24 265.53,105.49 265.51,105.49 264.56,104.54 264.56,93.23 268.18,89.62 285.33,89.62 285.64,89.93 285.64,89.93 285.96,90.25 285.97,90.26 285.97,91.27 286.34,91.65 289.15,91.65 289.52,92.01 289.52,93.08 297.36,93.08 297.41,93.03 298.27,93.03 298.87,92.05 299.95,91.67 300.01,91.67 300.63,90.8 301.65,90.47 304.18,90.47 304.18,90.15 304.23,90.15 304.23,75.14 304.06,74.91 303.94,74.65 303.83,74.54 303.83,70.94 302.85,70.01 302.35,68.76 302.3,68.71 302.3,68.4 ; 2 cut-outs
+3.3V_RUN_AUDIO on TOP (solid shape): 278.33,46.82 278.36,46.82 278.36,46.79 281.27,46.79 281.49,46.56 281.49,42.76 281.01,42.27 279.82,42.27 279.59,42.5 279.59,44.91 279.39,45.11 278.72,45.11 278.31,45.11 278.31,44.56 278.13,44.56 278.13,45.11 277.72,45.11 277.63,45.11 277.58,45.17 277.58,46.66 277.69,46.77 278.14,46.77 278.14,46.82 278.15,46.82 278.15,47.32 278.33,47.32
+3.3V_RUN_AUDIO on TOP (solid shape): 274.74,35.64 275.05,35.64 275.26,35.43 275.26,35.28 275.56,34.98 276.44,34.98 276.52,34.9 276.52,34.73 275.48,34.73 275.13,35.07 274.9,35.07 274.87,35.11 274.64,35.11 274.51,34.98 274.51,34.53 274.74,34.31 274.74,34.12 274.29,33.67 274.15,33.53 273.6,33.53 273.6,33.74 273.6,33.92 273.54,33.97 273.54,34.04 273.52,34.07 273.45,34.07 273.14,34.38 273.14,35.46 273.32,35.64 274.74,35.64
+3.3V_RUN_AUDIO on IN3 (solid shape): outline of 326 points within 272.84,24.81 281,44.89
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 277.93,48.57 280.82,48.57 281.08,48.31 281.08,47.14 280.88,46.94 278.51,46.94 278.46,46.99 278.46,47.45 278.03,47.45 278.03,46.98 277.99,46.94 277.56,46.94 277.2,46.59 275.93,46.59 275.86,46.66 275.86,47.58 276.47,48.19 276.47,48.5 276.75,48.79 277.7,48.79
+3.3V_RUN_CARD on TOP (solid shape): 272.17,37.19 272.17,36.48 271.97,36.28 271.89,36.28 271.89,36.27 270.48,34.86 270.48,34.28 270.37,34.17 270.01,34.17 269.92,34.26 269.92,34.89 269.7,35.11 269.7,37.34 269.95,37.6 271.77,37.6
+3.3V_RUN_CARD on BOTTOM (solid shape): outline of 925 points within 254.57,29.21 275.35,42.56
+3.3V_RUN_DIMM1 on TOP (solid shape): outline of 103 points within 141.77,19.79 149.45,23.32
+3.3V_RUN_DIMM1 on BOTTOM (solid shape): 143.88,22.6 143.88,21.9 143.75,21.77 142.53,21.77 142.48,21.72 142.48,21.39 142.47,21.35 142.36,21.24 142.28,21.21 142.02,21.21 141.85,21.39 141.85,22.43 142.15,22.73 143.75,22.73
+3.3V_RUN_DIMM2 on TOP (solid shape): 227.65,17.86 227.81,17.82 227.96,17.86 227.97,17.86 228.95,17.86 229.46,17.35 230.97,17.35 231.23,17.1 231.23,15.97 231.18,15.88 231.15,15.77 231.15,15.76 229.55,15.76 229.48,15.83 229.07,16.56 228.24,16.57 227.69,16.57 227.42,16.84 227.42,17.73 227.54,17.86 227.64,17.86
+3.3V_RUN_DIMM2 on BOTTOM (solid shape): 226.53,20.7 226.53,18.37 227.04,17.86 227.64,17.86 227.81,17.82 227.97,17.86 228.08,17.86 228.36,17.58 228.36,16.84 228.23,16.72 226.78,16.72 226.12,17.38 226.12,18.65 226.23,18.75 226.23,19.94 226.23,19.94 226.23,20.66 226.33,20.76 226.47,20.76
+3.3V_RUN_UZ3 on TOP (solid shape): 254.19,39.03 254.73,39.03 254.73,38.53 254.19,38.53 254.19,37.83 254.73,37.83 254.73,37.33 254.19,37.33 254.19,36.63 254.04,36.48 251.11,36.48 250.71,36.88 250.71,37.66 251.4,37.66 251.4,38.64 251.78,39.02 252.28,39.02 252.35,39.08 252.38,39.08 252.85,39.12 252.93,39.58 252.93,39.68 253.02,39.73 254.19,39.73
+3.3V_RUN_VDDA on BOTTOM (solid shape): 220.69,90.72 222.01,90.72 222.01,89.89 222.07,89.83 222.07,89.19 220.54,89.19 220.35,89 220.35,88.05 220.23,87.92 219.97,87.92 219.85,88.05 219.85,89.06 220.1,89.32 220.1,89.7 220.16,89.76 220.35,89.76 220.46,89.87 220.46,90.7 220.51,90.75 220.66,90.75
+3.3V_RUN_VDDA on IN1 (solid shape): 220.13,89.02 220.17,89 220.21,88.98 220.34,88.87 220.35,88.85 220.35,88.84 220.39,88.64 220.54,88.48 220.55,88.45 220.55,88.43 220.82,88.16 220.82,86.48 220.55,86.21 220.28,86.21 219.87,86.21 219.74,86.34 219.71,86.39 219.59,86.51 219.43,86.55 219.29,86.55 219.22,86.61 219.22,86.62 219.2,86.66 219.19,86.68 219.19,86.99 219.15,87.03 219.15,87.03 218.97,87.21 218.68,87.21 218.52,87.38 218.52,87.62 218.67,87.77 219.03,87.77 219.11,87.74 219.14,87.67 219.25,87.25 219.68,87.3 219.71,87.33 219.76,87.35 219.81,87.33 219.85,87.28 219.9,87.24 219.91,87.19 219.9,87.14 220.08,86.54 220.27,87.14 220.25,87.19 220.27,87.24 220.32,87.75 219.81,87.7 219.76,87.69 219.71,87.7 219.67,87.75 219.62,87.79 219.6,87.84 219.62,87.89 219.72,88 219.76,88.19 219.76,88.8 219.76,88.82 219.77,88.85 219.8,88.87 219.86,88.89 219.9,88.91 219.96,88.98 220.04,89.02
+3.3V_RUN_VDDA on IN2 (solid shape): outline of 1172 points within 213.8,87.12 221.53,93.19
+3.3V_RUN_VDDA on IN3 (solid shape): 220.55,88.25 220.55,86.4 220.35,86.21 219.95,86.21 219.58,86.57 219.26,86.57 219.09,86.75 219.1,86.78 218.99,87.13 218.62,87.16 218.55,87.19 218.52,87.26 218.52,87.62 218.67,87.77 219.03,87.77 219.11,87.74 219.14,87.67 219.27,87.23 219.71,87.33 219.76,87.35 219.81,87.33 219.85,87.28 219.9,87.24 219.91,87.19 219.9,87.14 220.08,86.54 220.27,87.14 220.25,87.19 220.27,87.24 220.32,87.75 219.81,87.7 219.76,87.69 219.71,87.7 219.67,87.75 219.62,87.79 219.6,87.84 219.62,87.89 219.72,88 219.76,88.15 219.76,88.17 219.98,88.38 220.42,88.38
+3.3V_RUN_VDDIO on BOTTOM (solid shape): 222.08,93.07 222.08,92.72 221.98,92.61 221.23,92.61 221.17,92.54 221.07,92.54 221.07,92.44 220.63,92 220.63,91.37 220.5,91.24 219.9,91.24 219.82,91.32 219.82,93.84 220.05,94.07 221.09,94.07
