# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BIA_PWM_EC: length 235.3
  TOP w0.102: v2(265.77,64.29) 266.13,64.65 266.13,65.28 266.4,65.55 UE2.B25
  IN2 w0.122: v2(85.57,84.55) 85.72,84.7 85.72,85.23 86.57,86.09 92.92,86.09 93.3,86.47 95.51,86.47 95.51,86.47 95.72,86.47 96.35,87.1 96.49,87.25 97.21,87.25 97.27,87.3 99.09,87.3 100.26,88.47 100.26,89.34 102.54,91.63 102.75,91.63 104.32,91.63 104.46,91.6 104.94,91.51 105.53,91.26 106.06,90.91 107.17,89.8 116.69,89.8 117.41,89.07 117.83,89.07 120.63,89.07 122.24,90.68 125.81,90.68 126,90.86 128.95,90.86 129.09,91.01 130.36,92.28 133.56,92.28 135.6,94.32 140.22,94.32 140.36,94.46 144.36,98.46 144.36,101.87 144.89,102.4 144.89,102.4 145.04,102.55 145.51,103.02 145.66,103.17 145.66,103.58 145.66,103.58 145.66,104.95 146.81,106.1 150.67,106.1 151.78,107.21 156.64,107.21 157.05,107.21 157.71,106.55 158.22,106.04 159.75,106.04 160.52,105.27 160.52,104 159.5,102.99 159.5,102.21 160.31,101.4 160.31,100.42 159.62,99.72 159.17,99.72 158.9,99.46 158.9,98.97 161.13,96.74 161.9,96.74 168.04,90.61 169.25,90.61 170.09,89.77 175.76,89.77 177.81,87.72 180.34,87.72 183.18,84.87 183.39,84.66 184,84.66 187.63,81.03 187.63,80.07 189.26,78.44 189.44,78.26 190.1,77.6 200.89,77.6 201.12,77.37 203.71,77.37 204.08,77.75 222.9,77.75 223.73,76.93 228.68,76.93 229.75,75.85 232.88,75.85 235.02,78 236.62,78 237.53,77.09 239.33,77.09 240.95,78.72 v2(241.51,78.72)
  IN3 w0.122: v2(241.51,78.72) 241.78,78.98 243.29,78.98 243.51,78.76 243.51,77.73 243.51,77.32 244.89,75.93 244.89,74.76 245.08,74.57 245.08,74.3 245.62,73.77 246.57,73.77 246.58,73.76 246.98,73.36 247.53,73.36 247.72,73.17 248.51,73.17 253.36,68.32 253.36,67.22 253.11,66.97 252.96,66.97 252.85,66.86 252.85,66.22 253.38,65.69 254.67,65.69 256.01,67.03 259.87,67.03 260.96,65.94 263.59,65.94 264.17,65.36 264.17,64.12 264.66,63.63 265.13,63.63 265.77,64.27 v2(265.77,64.29)
  BOTTOM w0.102: DV1.2 85.58,84.55 v2(85.57,84.55)
BL_PWR_SRC_ON: length 5.6
  BOTTOM w0.254: RV4.2 CV11.2 ; CV11.2 90.61,80.04 CV374.1 RV5.1 ; CV11.2 89.8,80.83 90.76,81.78 QV1.3
BOARD_ID: length 9.1
  TOP w0.102: UE2.B10 270.12,61.79 270.09,61.77 269.41,61.77 v2(269.33,61.85) ; v2(273.72,61.78) v3(274.64,61.78) 275.3,62.44 CE40.1 RE79.2
  BOTTOM w0.102: v2(273.72,61.78) 273.7,61.75 269.43,61.75 v2(269.33,61.85)
BOOT_1.2V:
  vias: v3(89.86,54.55)
BQ24770_REGN: length 32
  TOP w0.508: PR801.1 v2(56.6,86.39)
  IN2 w0.508: v2(66.2,84.51) 66.6,84.9 66.6,90.79 v2(66.53,90.86)
  IN4 w0.508: v2(56.6,86.39) 59.48,86.39 59.93,86.84 59.93,89.72 60.79,90.58 65.04,90.58 65.44,90.17 65.9,90.17 66.51,90.78 66.51,90.83 v2(66.53,90.86)
  BOTTOM w0.203: PU801.24 62.1,86.07 62.19,85.99 62.19,85.3 62.29,85.2 PC813.1
  BOTTOM w0.508: PC813.1 64.27,83.21 65.82,83.21 v3(66.2,83.6) v2(66.2,84.51) 67.37,84.51 67.55,84.69 PR821.2 ; v2(66.53,90.86) 66.53,90.89 66.56,90.91 66.56,90.92 66.78,91.14 66.79,91.14 67.07,91.42 PR827.1
BREATH_LED#: length 232.3
  TOP w0.102: v2(248.58,101.88) 247.71,102.75 246.44,102.75 246.22,102.98 225.61,102.98 225.12,102.49 218.76,102.49 218.05,103.2 218.05,104.45 216.52,105.98 216.52,108.86 215.04,110.34 209.65,110.34 205.93,106.61 205.93,101.16 200.83,96.06 193.4,96.06 189.37,100.09 184.15,100.09 181.34,102.9 181.34,108.1 178.21,111.23 163.83,111.23 v3(162.32,109.72) 161.53,108.93 161.53,107.85 v2(161.05,107.37) ; v2(264.15,57.89) 264.4,57.65 UE2.B57
  IN1 w0.089: v2(289.01,51.29) 288.99,51.26 284.07,51.26 282.5,52.83 282.5,54.27 282.5,54.66 281.84,55.31 280.8,56.35 277.53,56.35 276.71,57.17 273.71,57.17 273,56.47 269.02,56.47 268.53,56.96 265.23,56.96 264.3,57.89 v2(264.15,57.89)
  IN2 w0.122: v2(248.58,101.88) 248.93,101.53 252.55,101.53 257.08,96.99 260.69,96.99 262.86,94.82 262.86,92.77 264.57,91.06 264.57,90.71 264.92,90.37 265.94,90.37 266.32,89.98 266.33,89.98 266.51,89.8 266.51,89.45 267.38,88.59 267.38,86.11 266.7,85.43 266.7,84.08 268.95,81.82 268.95,75.89 268.95,75.58 271.48,73.06 271.73,73.06 273.38,71.4 275.5,71.4 275.88,71.78 279.82,71.78 279.84,71.76 281.83,71.76 282.15,72.08 287.35,72.08 288.26,71.16 288.26,70.03 288.79,69.5 v2(288.79,68.94) 288.79,66.5 287.72,65.42 287.72,63.71 287.16,63.15 287.16,60.8 288.03,59.92 288.03,54.91 289.01,53.93 v2(289.01,51.29)
  BOTTOM w0.102: JDOCK1.98 160.5,107.81 160.94,107.37 v2(161.05,107.37) ; v2(288.79,68.94) 288.63,68.78 QZ7.4 288.81,67.67 RZ34.1
BREATH_LED#_Q: length 3.1
  BOTTOM w0.102: RZ32.1 288.33,70.05 QZ7.3 288.64,69.73 290.1,69.73 v3(290.19,69.65)
BREATH_WHITE_LED#: length 71.8
  TOP w0.102: JLED1.2 279.15,9.46 279.67,9.99 v2(279.67,9.99)
  IN2 w0.122: v2(286.03,66.62) 285.62,66.21 284.73,66.21 281.7,63.18 281.7,58.89 281.82,58.77 281.82,53.41 281.58,53.16 281.57,53.16 280.46,52.04 279.55,52.04 279.44,51.93 279.15,51.64 278.18,50.67 278.18,46.84 278.12,46.78 278.12,46.74 277.87,46.49 275.58,44.2 275.58,43.54 275.58,43.19 275.24,42.84 275.24,40.3 275.31,40.23 275.31,37.12 275.24,37.05 275.24,36.62 272.58,33.97 272.58,31.93 271.39,30.73 271.39,28.3 272.58,27.1 272.58,26.32 271.96,25.7 271.96,22.06 273.06,20.96 273.06,18.55 274.22,17.38 274.64,17.38 275.19,16.83 275.19,14.56 276.92,12.83 277.21,12.83 279.67,10.36 279.67,9.99 v2(279.67,9.99)
  BOTTOM w0.102: RZ34.2 287.6,67.17 287.09,67.17 286.53,66.62 v2(286.03,66.62)
BREATH_WHITE_LED_SNIFF#: length 25.3
  TOP w0.508: v2(290,70.72) 291.28,71.99 291.28,85.53 LED3.1
  BOTTOM w0.102: v2(290,70.72) 290.63,71.34 v3(290.63,71.43)
  BOTTOM w0.381: v2(290,70.72) 289.6,70.72 RZ32.2
BST_3V:
  vias: v3(219.42,74.26)
BST_5V:
  vias: v3(221.4,66.5)
BST_+1VALWP:
  vias: v2(226.1,51.62) v2(226.1,51.03) v3(225.21,52.34)
BT_RADIO_DIS#: length 114.2
  TOP w0.102: v2(255.74,23.65) 255.74,24.03 255.87,24.16 DZ2.1 ; UE1.A13 247.39,88.43 247.77,88.81 v2(247.77,89.22)
  IN2 w0.122: v2(255.74,23.65) 256.16,24.07 259.99,24.07 261,23.07 262.89,23.07 264.13,24.31 264.13,24.92 265.3,26.08 265.3,33.8 265.76,34.27 266.23,34.27 266.47,34.5 266.47,35.23 266.95,35.7 266.95,40.37 267.42,40.85 267.42,43.08 268.28,43.94 268.28,46.38 270.81,48.9 270.81,52.04 270.5,52.35 270.5,52.63 269.25,53.88 269.25,55.81 270.04,56.6 270.43,56.6 270.83,57 270.83,66.41 271.77,67.35 271.77,67.56 271.79,67.58 271.79,68.92 271,69.71 269.89,69.71 264.21,75.39 264.21,76.54 264.96,77.28 264.96,81.18 263.63,82.5 263.63,84.41 262.39,85.65 262.39,86.35 262.3,86.44 262.14,86.6 262.14,87.98 261.59,88.53 261.59,91.47 260.67,92.38 258.15,92.38 256.18,94.36 255.13,94.36 254.28,95.21 252.73,95.21 v2(252.72,95.22)
  BOTTOM w0.102: RE11.2 247.56,88.52 247.77,88.73 v2(247.77,89.22) 247.77,89.75 248.12,90.1 249.57,90.1 250.26,90.78 250.26,93.56 251.31,94.62 252.12,94.62 v2(252.72,95.22) v3(252.72,99.02)
BT_RADIO_DIS#_R: length 5.2
  TOP w0.102: DZ2.2 v2(256.5,26.12) 256.92,26.12 v3(257.06,25.97)
  BOTTOM w0.102: v2(256.5,26.12) 256.95,25.67 JNGFF1.46
CAM_MIC_CBL_DET#: length 116.4
  IN1 w0.076: 159.85,66.88 160.43,66.88 160.74,67.2 165.3,67.2 165.55,66.95 166.75,66.95 167.46,66.23 167.87,66.23 167.95,66.32 168.1,66.32 v2(168.28,66.5) 168.44,66.66 168.56,66.66 169.08,67.18 170.15,67.18 172.48,69.51 172.86,69.51
  IN1 w0.089: v2(182.71,70.51) 182.71,71.08 181.62,72.17 180.99,72.17 180.71,72.46 177.56,72.46 174.62,69.51 172.86,69.51 ; 159.85,66.88 159.48,67.26 157.61,67.26 157.44,67.09 150.13,67.09 149.16,68.06 149.16,68.99 147.91,70.23 147.36,70.23 146.52,71.07 145.38,71.07 143.65,72.8 142.87,72.8 142.4,73.26 142.4,76.68 140.33,78.75 139.84,78.75 139.08,79.51 137.82,79.51 137.56,79.78 135.26,79.78 135.15,79.67 133.52,79.67 132.93,80.26 132.93,80.66 130.3,83.29 129.36,83.29 124.54,88.12 121.79,88.12 121.3,88.61 120.12,88.61 119.23,89.5 118.04,89.5 117.13,90.41 107.13,90.41 105.81,91.73 105.51,92.03 102.16,92.03 98.63,88.5 94.95,88.5 94.53,88.92 91.56,88.92 v2(91.15,88.51)
  BOTTOM w0.076: UC1.AB11 167.63,66.23 167.86,66.23 168.12,66.5 v2(168.28,66.5)
  BOTTOM w0.102: v2(91.15,88.51) 90.99,88.35 90.99,87.3 90.75,87.06 JEDP1.14 ; v2(182.71,70.51) 182.23,70.03 182.23,69.3 182.5,69.02 RPC5.7
CD3301_DCIN: length 5.1
  TOP w0.102: v3(22.4,77.57) 22.4,76.85 PC906.1
  TOP w0.203: PC906.1 22.95,76.31 PR921.2 24.37,77.49 24.68,77.8 PU901.1
CD3301_SDC_IN: length 2.7
  TOP w0.203: PR928.2 27.18,76.42 v3(27.18,77.08) PU901.6
CD_PBATT_OFF: length 7.7
  TOP w0.102: v3(23.53,90.7) 24.17,90.07 24.17,86.77 PR930.1 24.42,85.45 24.6,85.45 25.18,84.87 PU901.26
CFG0: length 101.9
  TOP w0.102: v2(89.83,38.52) 89.83,39.21 90.13,39.51 RC126.1 ; v2(81.62,40.97) 81.61,40.98 JXDP1.9 81.61,43.74 82.63,44.76 85.76,44.76 86.09,45.09 86.92,45.09 87.35,45.52 95.47,45.52 95.64,45.34 97.14,45.34 97.45,45.65 97.74,45.65 97.82,45.65 98.81,46.64 100.45,46.64 101.36,47.54 v3(102.78,47.54) 110.67,47.54 113.68,50.55 113.68,51.78 114.22,52.32 114.22,55.84 121.42,63.04 121.42,63.96 123.78,66.32 124.4,66.32 124.4,66.32 124.97,66.32 126.65,68.01 127.75,69.1 127.75,73.32 130.06,75.63 130.06,77.96 v2(130.69,78.59)
  IN4 w0.089: v2(81.62,40.97) 83.35,39.25 89.11,39.25 v2(89.83,38.52)
  BOTTOM w0.076: 130.68,78.59 130.77,78.68 131.66,78.68 131.75,78.59 134.75,78.59 135.37,77.97 135.37,77.73 135.57,77.53 135.57,77.01 135.55,76.95 135.55,76.7 135.55,76.69 135.57,76.62 135.57,76.39 135.55,76.33 135.52,76.25 135.47,76.06 135.43,75.8 135.36,75.54 UC1.E68 ; 130.68,78.59 v2(130.69,78.59) ; 130.68,78.59 130.68,78.59 130.68,78.58 130.5,78.41 129.29,78.41 129.25,78.45
  BOTTOM w0.102: RC113.2 128.41,82.2 128.41,81.49 128.65,81.24 128.65,79.04 129.25,78.45
CFG1: length 88.9
  TOP w0.102: v2(130.85,77.73) 130.85,77.53 130.29,76.97 130.29,75.53 128.59,73.83 128.59,72.5 128.31,72.22 128.31,69.34 127.44,68.47 127.44,68.47 126.75,67.78 126.75,67.78 125.07,66.09 123.88,66.09 121.65,63.87 121.65,62.94 114.45,55.74 114.45,51.08 v3(114.15,50.78) 114.15,50.7 110.58,47.13 101.27,47.13 100.52,46.38 98.88,46.38 97.92,45.42 97.79,45.42 97.79,45.42 97.55,45.42 97.24,45.11 95.55,45.11 95.37,45.29 87.44,45.29 87.01,44.86 86.18,44.86 85.85,44.53 82.72,44.53 82.11,43.92 JXDP1.11
  BOTTOM w0.076: 128.93,78.1 129.3,77.73 v2(130.85,77.73) 131.06,77.94 131.66,77.94 131.98,78.26 133.8,78.26 134.78,77.28 134.78,76.87 UC1.B67
  BOTTOM w0.102: RC112.2 123.66,84.89 124.61,84.89 125.03,84.47 125.03,84.47 125.09,84.41 125.48,84.41 127.95,81.94 127.95,81.3 128.2,81.05 128.2,78.83 128.93,78.1
CFG2: length 79.5
  TOP w0.102: v2(135.57,78.36) 135.22,78.72 131.34,78.72 131.1,78.48 131.1,78.14 131.25,77.99 131.25,77.56 131.01,77.32 130.96,77.32 130.52,76.87 130.52,75.14 129.93,74.55 129.93,73.26 128.61,71.94 128.61,69.22 125.23,65.84 123.95,65.84 121.88,63.77 121.88,62.85 114.68,55.65 114.68,53.57 114.68,50.69 v3(113.21,49.23) 110.89,46.9 101.37,46.9 100.97,46.5 100.62,46.16 98.98,46.16 98.01,45.19 97.85,45.19 97.85,45.19 97.71,45.19 97.4,44.89 96.9,44.89 95.45,44.89 95.28,45.06 87.54,45.06 87.11,44.63 86.28,44.63 85.85,44.2 83.73,44.2 83.11,43.59 JXDP1.15
  BOTTOM w0.076: v2(135.57,78.36) 135.8,78.36 136.18,77.98 136.18,77.68 136.06,77.55 136.06,77.02 136.08,76.96 136.08,76.7 136.06,76.64 136.06,76.4 136.07,76.35 136.12,76.2 136.2,75.92 136.2,75.8 136.27,75.54 UC1.D65
CFG3: length 98.3
  TOP w0.102: v2(131.51,78.31) 131.51,77.49 131.11,77.09 131.06,77.09 130.75,76.78 130.75,74.83 130.19,74.27 130.19,73.19 128.84,71.84 128.84,69.12 125.3,65.59 124.02,65.59 122.11,63.68 122.11,62.75 114.91,55.56 114.91,53.66 114.91,50.36 v3(112.16,47.62) 111.22,46.68 101.46,46.68 100.71,45.93 100.22,45.93 100.22,45.93 99.07,45.93 98.11,44.96 97.9,44.96 97.87,44.96 97.57,44.66 96.81,44.66 96.81,44.66 95.36,44.66 95.18,44.83 87.63,44.83 87.2,44.4 86.37,44.4 85.94,43.97 83.91,43.97 83.61,43.68 JXDP1.17 83.61,41.55 82.99,40.93 82.99,38.23 85.53,35.69 RC121.2
  BOTTOM w0.076: 129.08,78.29 129.26,78.11 131.25,78.11 131.46,78.31 v2(131.51,78.31) 131.62,78.43 134.68,78.43 135.2,77.91 135.2,77.67 135.41,77.46 135.41,77.05 135.38,77.01 135.38,76.67 135.41,76.59 135.41,76.42 135.32,76.17 UC1.D67
  BOTTOM w0.102: 129.08,78.29 128.42,78.95 128.42,81.15 128.18,81.39 128.18,82.03 125.57,84.64 125.18,84.64 124.71,85.12 124.45,85.12 RC110.2
CFG4: length 76
  TOP w0.102: v2(131.19,75.3) 131.19,74.95 130.42,74.18 130.42,73.1 129.15,71.83 129.15,69.11 125.4,65.36 124.11,65.36 122.33,63.58 122.33,62.66 115.13,55.46 115.13,53.76 115.13,49.95 111.63,46.45 101.56,46.45 100.81,45.7 100.12,45.7 99.17,45.7 98.2,44.73 97.97,44.73 97.66,44.43 96.71,44.43 96.71,44.43 95.22,44.43 95.04,44.61 87.73,44.61 87.3,44.17 86.52,44.17 86.11,43.76 JXDP1.27
  BOTTOM w0.076: 128.71,75.56 130.92,75.56 v2(131.19,75.3) 131.28,75.39 132.27,75.39 132.6,75.06 132.7,75.06 132.71,75.05 132.9,75.05 133.1,74.85 UC1.E70
  BOTTOM w0.102: RC109.2 124.82,73.28 v3(125.38,73.84) 125.97,74.44 126.46,74.44 127.58,75.56 128.71,75.56
CFG5: length 70.3
  TOP w0.102: JXDP1.29 86.61,43.75 86.8,43.95 87.39,43.95 87.82,44.38 94.94,44.38 95.12,44.2 96.62,44.2 97.75,44.2 98.06,44.5 98.3,44.5 99.26,45.47 100.03,45.47 100.9,45.47 101.65,46.22 112.06,46.22 v3(115.04,49.2) 115.36,49.53 115.36,53.85 115.36,55.37 122.56,62.57 122.56,63.49 124.18,65.1 125.47,65.1 129.37,69.01 129.37,71.73 130.64,73 130.64,73.68 131.57,74.6 131.9,74.6 132.14,74.84 132.14,75.21 v2(131.57,75.78)
  BOTTOM w0.076: v2(131.57,75.78) 131.95,76.16 132,76.16 132.01,76.17 132.39,76.17 132.57,76.35 132.96,76.35 133.13,76.18 133.66,76.18 133.93,75.91 133.97,75.91 UC1.C68
CFG6: length 67.9
  TOP w0.102: v2(132.16,75.8) 132.37,75.58 132.37,74.75 132,74.38 131.66,74.38 130.87,73.58 130.87,72.91 129.6,71.64 129.6,68.92 125.56,64.88 124.28,64.88 122.79,63.39 122.79,62.47 115.59,55.27 115.59,53.95 115.59,49.2 v3(114.02,47.63) 112.39,45.99 101.75,45.99 101,45.24 99.94,45.24 99.93,45.24 99.36,45.24 98.39,44.28 98.15,44.28 97.85,43.97 96.52,43.97 96.52,43.97 95.03,43.97 94.85,44.15 88.02,44.15 87.61,43.74 JXDP1.33
  BOTTOM w0.076: v2(132.16,75.8) 132.27,75.69 132.92,75.69 133.23,75.38 UC1.D68
CFG7: length 73.3
  TOP w0.102: v2(131.15,76.61) 131.51,76.97 132.18,76.97 132.6,76.55 132.6,74.65 132.09,74.15 131.76,74.15 131.1,73.49 131.1,72.81 129.83,71.54 129.83,68.82 125.66,64.65 124.37,64.65 123.02,63.3 123.02,62.38 115.82,55.18 115.82,54.04 115.82,48.85 112.46,45.48 v3(112.2,45.48) 101.56,45.48 101.09,45.01 99.84,45.01 99.45,45.01 98.49,44.05 98.25,44.05 97.94,43.74 96.43,43.74 94.93,43.74 94.75,43.92 88.41,43.92 88.11,43.63 88.11,43.63 JXDP1.35
  BOTTOM w0.076: v2(131.15,76.61) 131.15,76.72 132.19,77.77 133.03,77.77 133.52,77.28 133.52,77.05 133.74,76.82 134.13,76.82 134.55,76.39 UC1.C67
CFG8: length 71.5
  TOP w0.102: JXDP1.10 81.61,46.53 v2(81.47,46.38)
  IN1 w0.089: v2(81.47,46.38) 83.1,44.75 98.32,44.75 100.24,46.67 105.94,46.67 112.43,53.16 112.43,55.59 113.75,56.92 114.04,56.92 128.03,70.9 128.03,71.85 128.55,72.38 128.55,72.92 127.87,73.6 v2(127.87,74.67)
  BOTTOM w0.076: 128.71,74.99 130.54,74.99 131.14,74.39 132.42,74.39 132.51,74.3 133.11,74.3 UC1.F71
  BOTTOM w0.102: v2(127.87,74.67) 127.98,74.67 128.3,74.99 128.71,74.99
CFG9: length 69.1
  TOP w0.102: v2(82.2,46.28) 81.96,46.52 81.96,47.08 82.11,47.23 JXDP1.12
  IN1 w0.089: v2(128.15,72.75) 128.15,72.29 127.81,71.94 127.81,70.99 113.95,57.13 113.66,57.13 112.21,55.68 112.21,53.24 105.85,46.88 100.15,46.88 98.24,44.97 83.51,44.97 82.54,45.94 82.54,45.94 v2(82.2,46.28)
  BOTTOM w0.076: 128.71,72.65 129.27,72.65 129.45,72.83 130.86,72.83 131.76,73.73 132.15,73.73 132.54,73.34 132.83,73.34 132.91,73.37 133.16,73.37 133.29,73.34 133.48,73.34 133.67,73.4 133.92,73.4 UC1.G69
  BOTTOM w0.102: v2(128.15,72.75) 128.25,72.65 128.71,72.65
CFG10: length 70.3
  TOP w0.102: v2(82.94,46.77) 83.11,46.93 JXDP1.16
  IN1 w0.089: v2(82.94,46.77) 83.47,46.23 83.47,46.18 84.25,45.4 98.06,45.4 99.97,47.32 105.67,47.32 111.77,53.42 111.77,55.86 113.48,57.57 113.77,57.57 126.77,70.57 126.77,73.39 v2(126.16,74.01)
  BOTTOM w0.076: 128.71,75.31 130.45,75.31 131.21,74.55 132.49,74.55 132.56,74.48 132.88,74.48 132.9,74.5 133.5,74.5 UC1.F70
  BOTTOM w0.102: 128.71,75.31 127.65,75.31 126.36,74.02 126.17,74.02 v2(126.16,74.01)
CFG11: length 70.9
  TOP w0.102: v2(82.94,46.1) 83.35,46.51 83.35,47.02 83.61,47.28 JXDP1.18
  IN1 w0.089: v2(82.94,46.1) 83.86,45.18 98.15,45.18 100.06,47.1 105.76,47.1 111.99,53.33 111.99,55.77 113.57,57.35 113.86,57.35 127.34,70.83 v2(127.34,74.43)
  BOTTOM w0.076: 128.71,74.61 v3(129.2,74.61) 130.63,74.61 131.02,74.22 132.35,74.22 132.46,74.12 132.71,74.12 132.99,73.99 133.27,73.87 134.31,73.87 UC1.G68
  BOTTOM w0.102: 128.71,74.61 128.36,74.26 127.51,74.26 v2(127.34,74.43)
CFG12: length 64.3
  TOP w0.102: v2(85.79,46.51) 86.11,46.84 JXDP1.28
  IN1 w0.089: v2(124.26,71.98) 124.23,71.95 124.23,70.33 119.85,65.95 119.85,65.16 110.91,56.22 110.91,53.78 105.31,48.18 99.61,48.18 97.7,46.26 87.19,46.26 86.59,46.86 86.17,46.86 85.82,46.51 v2(85.79,46.51)
  BOTTOM w0.076: 128.71,71.82 128.97,71.82 129.57,72.42 131.57,72.42 131.9,72.75 132.66,72.75 132.88,72.7 132.96,72.67 133.16,72.67 133.21,72.7 133.25,72.71 133.47,72.71 UC1.H70
  BOTTOM w0.102: 128.71,71.82 124.42,71.82 v2(124.26,71.98)
CFG13: length 64.1
  TOP w0.102: JXDP1.30 86.61,46.99 86.4,46.78 v2(86.4,46.46)
  IN1 w0.089: v2(86.4,46.46) 86.81,46.05 97.79,46.05 99.7,47.96 105.4,47.96 111.13,53.69 111.13,56.13 120.07,65.07 120.07,65.86 124.66,70.46 124.66,72.25 v2(124.3,72.62)
  BOTTOM w0.076: UC1.G71 132.55,73.78 132.33,73.78 132.22,73.89 131.57,73.89 131.27,73.59 v3(130.64,73.59) 129.99,73.59 129.58,74 128.96,74 128.71,73.76
  BOTTOM w0.102: v2(124.3,72.62) 125.1,72.62 125.44,72.96 126.3,72.96 126.99,73.66 128.61,73.66 128.71,73.76
CFG14: length 64.7
  TOP w0.102: JXDP1.34 87.61,47.18 87.98,46.81 95.86,46.81 96.13,47.07 97.5,47.07 98.26,47.83 100.03,47.83 101.82,49.62 111.13,49.62 112.36,50.85 112.36,55.63 120.2,63.48 120.2,64.37 123.33,67.49 124.52,67.49 126.37,69.34 v2(126.37,72.43)
  BOTTOM w0.076: UC1.H69 134.08,73.21 133.61,73.21 133.51,73.17 133.26,73.17 133.13,73.21 132.95,73.21 132.9,73.19 132.87,73.17 132.47,73.17 132.09,73.55 131.81,73.55 130.93,72.67 129.52,72.67 129.09,72.24 128.71,72.24
  BOTTOM w0.102: v2(126.37,72.43) 126.56,72.24 128.71,72.24
CFG15: length 63.5
  TOP w0.102: v2(126.08,73.4) 125.97,73.29 v3(125.97,69.97) 125.97,69.57 124.14,67.75 123.26,67.75 119.98,64.46 119.98,63.57 112.13,55.72 112.13,50.94 111.06,49.88 101.75,49.88 99.93,48.06 98.03,48.06 97.29,47.32 96.02,47.32 95.74,47.04 88.26,47.04 88.11,47.18 JXDP1.36
  BOTTOM w0.076: 128.71,74.16 128.79,74.24 130.77,74.24 130.95,74.06 132.28,74.06 132.39,73.95 132.67,73.95 133.08,73.75 133.23,73.6 UC1.G70
  BOTTOM w0.102: 128.71,74.16 128.53,73.98 126.83,73.98 126.25,73.4 v2(126.08,73.4)
CFG16: length 84.7
  TOP w0.102: v2(129.52,79.41) 129.09,78.98 129.09,77.16 126.71,74.78 126.71,74.16 126.8,74.07 126.8,69.44 124.59,67.24 123.4,67.24 120.51,64.34 120.51,63.42 113.31,56.22 113.31,53.46 112.59,52.75 112.59,50.76 111.07,49.24 v3(102.17,49.24) 101.76,49.24 100.12,47.6 98.48,47.6 97.44,46.56 96.94,46.56 96.63,46.26 96.18,46.26 96,46.44 86.97,46.44 86.54,46 85.69,46 85.38,45.7 81.02,45.7 80.3,46.42 80.3,46.83 80.61,47.14 JXDP1.6
  IN4 w0.089: v2(137.22,74.25) 137.17,74.25 136.7,73.77 136.04,73.77 133.12,76.7 133.12,77.58 131.28,79.41 v2(129.52,79.41)
  BOTTOM w0.076: UC1.E63 137.47,74.5 v2(137.22,74.25)
CFG17: length 84.5
  TOP w0.102: v2(129.49,78.77) 129.37,78.66 129.37,77.03 126.94,74.59 126.94,74.26 127.03,74.17 127.03,69.35 124.69,67.01 123.5,67.01 120.73,64.24 120.73,63.32 113.53,56.12 113.53,53.36 112.83,52.65 112.83,50.68 110.97,48.81 v3(104.16,48.81) 101.65,48.81 100.22,47.37 98.58,47.37 97.54,46.33 97.12,46.33 96.81,46.03 96.05,46.03 95.87,46.21 87.06,46.21 86.63,45.77 85.78,45.77 85.48,45.47 80.93,45.47 80.07,46.32 80.07,46.93 80.11,46.97 JXDP1.4
  IN4 w0.089: v2(129.49,78.77) 129.71,78.99 131.4,78.99 132.9,77.49 132.9,76.61 136,73.51 v2(137.23,73.51)
  BOTTOM w0.076: UC1.F63 137.56,73.85 v2(137.23,73.51)
CFG18: length 74.6
  TOP w0.102: JXDP1.24 85.11,46.99 v2(84.55,46.43)
  IN1 w0.089: v2(84.55,46.43) 85.15,45.83 97.88,45.83 99.79,47.75 105.49,47.75 111.34,53.6 111.34,56.04 113.3,58 113.59,58 124.88,69.28 124.88,72.96 v2(123.91,73.93)
  BOTTOM w0.076: UC1.E66 135.46,74.73 135.34,74.73 135.02,74.92 134.88,75.05 134.85,75.12 134.85,75.28 134.86,75.35 134.86,75.35 134.88,75.44 134.87,75.58 134.87,75.68 134.85,75.71 134.85,76.39 134.2,77.04 134.2,77.23 133.5,77.93 132.12,77.93 131.17,76.98 130.75,76.98 130.37,76.6 128.72,76.6 128.71,76.61
  BOTTOM w0.102: v2(123.91,73.93) 124.42,74.44 125.02,74.44 127.19,76.61 v3(127.9,76.61) 128.71,76.61
CFG19: length 74.3
  TOP w0.102: JXDP1.22 84.61,47.06 84.01,46.46 v2(84.01,46.21)
  IN1 w0.089: v2(124.5,73.93) 125.1,73.33 125.1,69.19 113.68,57.78 113.39,57.78 111.56,55.95 111.56,53.51 105.58,47.53 99.88,47.53 97.97,45.62 84.6,45.62 v2(84.01,46.21)
  BOTTOM w0.076: UC1.F66 135.69,74 134.77,74.92 134.68,75.07 134.68,75.29 134.71,75.42 134.71,75.59 134.44,75.85 134.27,75.85 133.66,76.46 133.66,76.66 133.47,76.84 133.06,76.84 133.02,76.88 132.88,77.02 131.95,77.02 131.52,76.59 131.52,76.46 131.23,76.17 128.71,76.17
  BOTTOM w0.102: 128.71,76.17 127.83,76.17 127.02,75.35 v3(126.56,75.35) 126.33,75.35 124.91,73.93 v2(124.5,73.93)
CFG_RCOMP: length 4.1
  TOP w0.381: RC114.1 139.33,72.77 139.11,72.98 139.11,73.39 v3(138.32,74.18) 138.32,74.46 138.53,74.67 v2(139.11,74.67)
  BOTTOM w0.254: UC1.E60 139.55,74.44 139.17,74.62 139.1,74.66 139.1,74.67 v2(139.11,74.67)
CHAGER_SRC:
  vias: v2(54.52,77.5) v2(54.52,76.84) v2(54.52,76.23) v2(55.17,76.61) v2(55.77,76.6) v2(58.36,76.08) v2(58.38,75.46) v3(56.71,74.06)
CHARGER_SMBCLK: length 313.9
  TOP w0.102: v2(259.33,51.46) 259.12,51.25 RPE3.1 ; UE2.B50 261.75,57.79 261.96,57.59 v2(261.96,57.51)
  IN2 w0.122: v2(259.33,51.46) 260.43,50.35 260.43,49.47 260.44,49.46 260.44,49.05 261.65,47.84 261.65,46.68 260.62,45.65 260.62,43.75 260.21,43.34 260.21,39.33 258.91,38.04 258.91,36.28 259.76,35.43 259.76,34.95 260.29,34.42 260.29,31.27 259.39,30.37 259.39,29.6 259.14,29.35 256.06,29.35 255.88,29.17 252.55,29.17 252.2,28.82 250.47,28.82 246.8,25.15 240.2,25.15 239.59,24.54 238.11,24.54 237.91,24.34 235.04,24.34 232.61,26.77 225.8,26.77 224.17,28.4 221.23,28.4 220.32,27.49 203.76,27.49 202.29,28.96 193.12,28.96 191.47,30.61 111.87,30.61 107.02,25.76 85.08,25.76 84.25,24.93 80.6,24.93 79.48,26.04 77.73,26.04 74.18,29.58 74.18,39.22 71.6,41.81 71.6,46.22 71.09,46.73 71.09,47.48 71.09,47.48 71.09,47.83 71.09,47.83 71.09,51.04 70.14,51.99 70.14,52.73 69.95,52.92 69.95,65.81 65.02,70.74 65.02,70.78 64.49,71.31 62.74,71.31 60.49,73.56 57.73,73.56 56.82,74.47 56.82,83.46 55.39,84.88 55.39,88.69 55.44,88.73 55.44,88.73 56.12,89.41 56.12,91.1 57.67,92.66 62.62,92.66 63.38,93.42 63.38,94.49 63.46,94.57 63.46,94.57 v2(63.61,94.72)
  BOTTOM w0.102: v2(63.61,94.72) 63.61,94.08 63.33,93.8 PR835.1 ; v2(261.96,57.51) 261.94,57.48 261,57.48 259.83,56.32 259.83,51.85 259.43,51.46 v2(259.33,51.46)
CHARGER_SMBDAT: length 317.4
  TOP w0.102: v2(259.35,57.59) 259.7,57.59 260.16,58.04 UE2.A47 ; v2(259.32,52.09) 259.21,52.09 258.62,51.5 RPE3.2
  IN2 w0.122: v2(259.32,52.09) 259.47,52.09 259.85,51.71 259.85,51.68 260.93,50.61 260.93,49.68 260.95,49.66 260.95,49.25 262.15,48.05 262.15,47.23 262.16,47.23 262.16,47.12 262.15,47.12 262.15,46.48 261.12,45.44 261.12,43.54 260.71,43.13 260.71,39.13 259.42,37.83 259.42,36.48 260.27,35.63 260.27,35.16 260.79,34.63 260.79,31.06 259.9,30.16 259.9,29.39 259.35,28.84 256.27,28.84 256.09,28.67 252.76,28.67 252.41,28.31 250.68,28.31 247.01,24.65 240.41,24.65 239.8,24.04 238.31,24.04 238.11,23.84 234.83,23.84 232.4,26.27 225.59,26.27 223.96,27.89 221.44,27.89 220.53,26.98 203.55,26.98 202.16,28.38 192.95,28.38 191.22,30.11 112.08,30.11 107.23,25.26 106.81,25.26 85.28,25.26 84.45,24.43 80.39,24.43 79.27,25.54 77.52,25.54 73.68,29.38 73.68,39.01 71.09,41.6 71.09,46.01 70.59,46.52 70.59,47.27 70.59,47.27 70.59,48.04 70.59,48.04 70.59,50.83 69.64,51.78 69.64,52.52 69.45,52.71 69.45,65.6 64.52,70.53 64.52,70.57 64.28,70.81 62.53,70.81 60.28,73.05 57.52,73.05 56.31,74.26 56.31,83.25 54.89,84.67 54.89,88.89 54.94,88.94 55.61,89.62 55.61,91.31 57.46,93.16 62.41,93.16 62.88,93.63 62.88,94.28 62.88,94.7 63.41,95.22 63.54,95.36 v2(63.54,95.33)
  BOTTOM w0.102: v2(259.32,52.09) 259.32,52.4 259.35,52.43 v2(259.35,57.59) ; PR836.1 62.44,93.59 63.13,94.28 63.13,94.92 63.18,94.97 63.18,94.97 v2(63.54,95.33)
CHG_LGATE: length 2.9
  IN4 w1.016: 63.89,84.66 63.89,81.79
  vias: v2(62.67,85.6) v2(63.21,85.35) v2(64.05,80.9) v2(64.05,80.29) v3(64.43,81.56)
CHG_SNUB:
  vias: v3(63.24,76.47)
CHG_SW: length 7.4
  IN2 w1.016: 60.67,84.13 60.67,83.47 61.76,82.37 61.76,79.6 62.95,78.41 63.74,78.41
  vias: v2(60.59,85.5) v2(60.57,84.92) v2(64.78,78.77) v2(64.78,78.06) v3(65.65,79.72)
CHG_UGATE: length 8.4
  IN4 w1.016: 63.66,76.2 63.66,77.73 61.71,79.68 61.71,83.82
  vias: v2(61.23,85.05) v2(61.28,85.68) v2(63.96,75.4) v2(63.97,74.83)
CLK_27M_IN: length 10.6
  TOP w0.102: YV2.1 227.01,83.37 226.88,83.49 224.35,83.49 CV115.1 224.11,83.34 223.49,82.73 223.49,82.61 RV80.1 222.97,82.42 222.69,82.7 222.69,83.05 v3(222.08,83.67) 221.94,83.8 221.94,84.56 221.73,84.78 220.22,84.78 UV8.K1
CLK_27M_OUT: length 5.3
  TOP w0.076: UV8.L1 220.72,85.55 221.6,85.55
  TOP w0.102: RV81.2 RV80.2 222.69,83.94 222.69,84.8 221.94,85.55 221.6,85.55
CLK_27M_OUT_R: length 2.7
  TOP w0.102: RV81.1 CV113.1 224.98,84.2 YV2.3
CLK_ITPXDP_N: length 12.7
  TOP w0.094: v2(148.34,74.08) 147.8,74.61 147.8,74.95 147.59,75.16 147.59,79.03 147.73,79.17 147.73,80.82 148.38,81.48 v4(148.38,82.77) 148.38,83.84 148.35,83.87 148.35,84.46 148.38,84.49 148.38,85.03 RC297.1
  BOTTOM w0.102: UC1.F43 148.63,73.79 v2(148.34,74.08)
CLK_ITPXDP_N_R: length 102.2
  TOP w0.094: RC297.2 148.09,86.24 148.4,86.24 148.55,86.39 148.55,86.8 148.39,86.96 143.38,86.96 142.55,87.79 142.55,88.8 142.33,89.02 141.74,89.02 141.27,89.49 141.27,90.2 140.91,90.56 136.13,90.56 136.1,90.53 135.48,90.53 135.45,90.56 v4(134.31,90.56) 134.06,90.56 132.98,89.49 132.28,89.49 127.49,84.7 121.41,84.7 121.09,84.37 120.5,84.37 117.83,81.7 117.83,77.3 124.23,70.89 124.23,69.77 123.72,69.25 122.77,69.25 119.25,65.74 119.25,63.76 111.42,55.93 111.42,55.8 111.42,51.13 110.93,50.64 99.04,50.64 98.37,51.31 93.01,51.31 92.48,51.31 92.04,50.86 91.52,50.86 91.17,50.51 89.67,50.51 89.31,50.15 89.31,49.78 89.4,49.69 89.5,49.69 89.61,49.57 JXDP1.42
CLK_ITPXDP_P: length 12.7
  TOP w0.094: v2(148.32,74.67) 148.22,74.56 148.12,74.56 147.99,74.69 147.99,75.03 147.78,75.24 147.78,78.95 147.92,79.09 147.92,80.74 148.58,81.4 148.58,82.44 148.61,82.47 148.61,83.07 148.58,83.1 v4(148.58,84.17) 148.58,84.97 RC298.1
  BOTTOM w0.102: v2(148.32,74.67) 148.53,74.87 148.68,74.87 148.79,74.76 148.79,74.48 UC1.E43
CLK_ITPXDP_P_R: length 102.2
  TOP w0.094: JXDP1.40 89.11,50.23 89.59,50.71 91.09,50.71 91.44,51.06 91.96,51.06 92.4,51.5 92.41,51.5 98.45,51.5 99.12,50.83 110.85,50.83 111.23,51.21 111.23,55.19 111.23,56.01 119.06,63.84 119.06,65.82 122.69,69.45 123.64,69.45 124.04,69.85 124.04,70.81 117.64,77.22 117.64,81.78 120.42,84.56 121.01,84.56 121.33,84.89 127.41,84.89 132.2,89.68 132.9,89.68 133.98,90.76 133.98,90.77 134,90.79 134.6,90.79 134.63,90.76 v4(135.8,90.76) 140.99,90.76 141.46,90.28 141.46,89.57 141.82,89.21 142.41,89.21 142.74,88.88 142.74,87.87 143.46,87.15 148.47,87.15 148.74,86.88 148.74,86.58 RC298.2
CLK_KBD: length 171.1
  TOP w0.102: v2(154.5,110.08) 154.62,109.96 154.62,109.6 155.13,109.1 155.35,109.1 155.36,109.1 157.84,109.1 158.4,109.66 159.88,109.66 160.36,109.18 160.36,108.15 160.16,107.95 160.16,107 160.84,106.32 166.5,106.32 167.32,105.5 167.32,104.24 168.84,102.72 169.17,102.72 169.76,102.12 171.27,102.12 174.24,99.15 188.74,99.15 192.77,95.12 201.22,95.12 207,100.9 207,105.88 209.79,108.67 211.44,108.67 211.86,109.1 214.66,109.1 215.58,108.18 215.58,105.59 217.11,104.06 217.11,102.81 218.5,101.43 224.37,101.43 225.21,100.59 226.71,100.59 228.09,101.97 236.2,101.97 v3(237.8,100.37) 242.78,95.39 v2(242.78,90.33) ; v2(259.02,68.23) 258.91,68.33 RPE2.8 ; UE2.A38 259.52,62.54 v2(259.17,62.9)
  IN2 w0.122: v2(250.79,67.69) 250.71,67.77 250.71,67.84 250.71,72.99 249.6,74.1 249.6,74.33 249.54,74.4 249.54,75.4 248.86,76.07 248.86,81.72 248.92,81.78 248.92,82.97 248.76,83.13 248.76,83.13 248.57,83.32 248.57,84.28 248.57,84.9 248.02,85.45 247.53,85.45 247.29,85.7 247.29,86.92 247.28,86.93 247.28,87.08 245.24,89.11 244.13,89.11 242.91,90.33 v2(242.78,90.33)
  BOTTOM w0.102: v2(259.17,62.9) 259.53,62.54 259.96,62.54 260.95,63.53 260.95,65.86 261.71,66.62 261.71,68.7 261.37,69.04 261.05,69.04 260.7,69.39 260.18,69.39 v2(259.02,68.23) 259.02,68.08 258.66,67.72 257.42,67.72 257.16,67.98 251.07,67.98 v2(250.79,67.69) ; JDOCK1.78 v2(154.5,110.08)
CLK_MSE: length 161.8
  TOP w0.102: UE2.A39 259.81,62.04 v2(259.75,62.11) ; RPE2.6 257.91,68.81 257.79,68.69 257.6,68.69 257.57,68.65 256.94,68.65 256.57,68.28 256.52,68.24 255.59,67.3 255.59,66.13 255.03,65.57 252.6,65.57 251.41,64.38 249.97,64.38 249.44,63.85 249.44,60.9 249.84,60.51 v2(250.44,60.51)
  IN2 w0.122: v2(242.89,63.4) 242.43,63.86 242.43,67.38 243.44,68.38 244.2,68.38 244.85,69.03 244.85,72 242.44,74.4 242.44,79.09 241.27,80.26 238.06,80.26 236.96,79.17 235,79.17 232.45,76.62 230.05,76.62 228.99,77.68 224.1,77.68 223.14,78.65 203.92,78.65 203.4,78.12 201.44,78.12 201.21,78.35 190.41,78.35 189.97,78.79 189.88,78.88 189.79,78.97 188.44,80.32 188.44,81.6 184.27,85.77 183.45,85.77 180.51,88.72 179.04,88.72 178.68,89.07 178.68,89.51 177.42,90.78 170.38,90.78 169.13,92.03 168.1,92.03 161.93,98.19 161.44,98.19 161.25,98.38 v2(161.25,99.22)
  IN4 w0.089: v2(259.75,62.11) 260.31,61.55 260.31,60.67 260.31,60.67 260.31,60.6 259.3,59.58 259.22,59.58 257.58,59.58 257.09,60.07 255.35,60.07 254.09,61.33 253.49,61.33 253.17,61.65 251.9,61.65 250.76,60.51 v2(250.44,60.51)
  BOTTOM w0.102: v2(161.25,99.22) 161.15,99.12 161.15,98.74 160.71,98.3 154.45,98.3 153.79,98.96 153,99.75 JDOCK1.71 ; v2(242.89,63.4) 246.01,63.4 248.9,60.51 v2(250.44,60.51)
CLK_PCI_5048: length 129.3
  TOP w0.102: v2(174.15,50.02) 174.2,49.97 174.2,49.11 177.94,45.38 v3(177.94,45.15) 177.94,44.86 178.95,43.84 178.95,42.89 178.7,42.64 CC3.2 178.29,42.02 178.07,42.24 RC16.2 ; UE1.A28 243.83,80.88 243.62,80.67 243.24,80.67 242.84,81.08 v2(242.81,81.08) 242.66,81.23 RE27.1
  IN2 w0.122: v2(174.15,50.02) 176.28,47.9 187.6,47.9 188.08,48.38 190.34,48.38 190.99,47.73 190.99,47.16 191.09,47.05 192.15,47.05 193.48,48.39 196.83,48.39 203.8,41.42 209.21,41.42 210.58,42.79 211.78,42.79 212.3,43.31 212.3,45.02 214.39,47.11 221.07,47.11 221.45,46.73 222.9,46.73 223.99,45.63 236.34,45.63 239.06,48.35 239.06,50.54 242.43,53.91 243.5,53.91 243.91,54.32 243.91,55.08 245.52,56.7 245.52,60.68 243.73,62.47 243.73,64.01 242.94,64.8 242.94,67.17 243.57,67.8 244.41,67.8 245.36,68.75 245.36,72.43 243.75,74.03 243.75,76.62 243.31,77.07 243.31,78.79 243.76,79.24 243.76,79.86 243.23,80.38 243.23,80.67 242.82,81.08 v2(242.81,81.08)
CLK_PCI_DOCK: length 94.8
  TOP w0.102: v2(157.34,99.32) 157.69,99.67 160.23,99.67 v3(161.6,101.04) R273.1 163.36,100.87 162.62,100.13 162.62,99.48 162.9,99.2 v2(164.02,99.2) ; v2(176.82,57.08) 176.74,57 176.74,54.53 175.66,53.45 175.66,52.1 175.04,51.49 175.04,49.44 175.78,48.7 176.6,48.7 178.78,46.51 180.03,46.51 180.28,46.27 180.28,45.3 181.7,43.89 CC6.2 181.27,43.72 180.53,44.45 180.06,44.45 179.77,44.74 RC24.2
  IN2 w0.122: v2(176.82,57.08) 176.82,57.17 177.26,57.61 179.84,60.19 179.84,64.55 180.12,64.83 180.94,65.65 181.11,65.65 182.52,67.06 182.52,68.29 182.79,68.57 182.79,69.59 182.29,70.09 182.29,70.8 180.71,72.37 180.71,75.05 179.34,76.43 179.34,82.69 177.39,84.64 177.39,85.5 175.71,87.18 173.85,87.18 172.32,87.18 172.32,87.18 170.88,87.18 170.31,87.75 167.68,87.75 166.19,89.24 166.19,90.03 161.54,94.68 161.42,94.68 157.34,98.76 157.34,99.32 v2(157.34,99.32)
  BOTTOM w0.102: v2(164.02,99.2) 164.43,98.8 165.69,98.8 166.5,99.6 JDOCK1.121
CLK_PCI_LPDEBUG: length 111.8
  TOP w0.102: JLPDE1.10 251.3,66.37 251.5,66.17 251.5,65.82 251.12,65.43 v2(250.79,65.43) ; RC22.2 178.88,44.73 CC5.2 180.28,43.82 180.76,43.34 v3(180.76,41.62) v2(180.76,40.47)
  IN2 w0.122: v2(250.35,51.82) 249.77,51.24 249.77,50.45 247.66,48.34 247.66,44.95 244.64,41.93 244.64,40.25 240.81,36.42 236.65,36.42 234.72,38.35 228.43,38.35 228.15,38.63 224.16,38.63 221.9,36.37 219.45,36.37 219.09,36.73 218.67,36.73 218.38,36.43 218.38,36.08 217.85,35.55 217.85,34.87 216.43,33.45 205.21,33.45 204.66,34 194.28,34 187.43,40.86 181.15,40.86 v2(180.76,40.47)
  BOTTOM w0.102: v2(250.79,65.43) 252.08,64.14 253,64.14 253.99,63.15 253.99,60.14 252.3,58.45 251.77,58.45 251.5,58.17 251.5,52.37 250.94,51.82 v2(250.35,51.82)
CLK_PCI_MEC: length 123.3
  TOP w0.102: v2(261.12,70.26) 261.78,69.6 261.78,69.09 262.17,68.71 RE66.1 262.47,68.28 263.65,67.1 UE2.A29 ; v2(174.87,41.49) 175.39,42.02 CC4.2 175.98,42.57 176.29,42.88 RC18.2
  IN2 w0.122: v2(174.87,41.49) 175.24,41.86 187.01,41.86 188.56,41.86 195.41,35.01 215.89,35.01 217.37,36.49 217.37,36.85 218.26,37.74 221.72,37.74 223.83,39.84 228.87,39.84 229.33,39.39 235.1,39.39 236.41,38.08 238.06,38.08 238.49,37.65 240.57,37.65 242.93,40.01 242.93,41.65 243.3,42.02 246.09,44.8 246.09,48.39 247.41,49.71 247.41,50.6 249.98,53.18 253.08,53.18 253.67,53.76 253.67,53.77 253.69,53.79 253.69,54.37 256.61,57.29 256.61,57.36 257.52,58.27 257.52,63.22 257.86,63.57 258.17,63.57 259.46,64.86 260.22,64.86 260.53,65.17 260.53,67.9 260.88,68.25 260.88,68.73 261.12,68.96 v2(261.12,70.26)
CLK_PCIE_N0: length 130.2
  IN1 w0.112: v2(236.38,66.04) 236.43,65.99 236.94,65.99 237.08,66.13 237.08,72.67 235.74,74.01 235.49,74.01 234.28,75.22 234.28,78.91 231.34,81.85 229.54,81.85 228.59,82.8 228.59,85.14 227.64,86.1 224.71,86.1 224.08,85.47 224.08,83.7 222.52,82.14 210.13,82.14 209.03,83.23 209.03,83.24 208.42,83.84 203.83,83.84 203.62,84.06 197.01,84.06 196.96,84 191.27,84 190.99,84.28 189.07,84.28 188.92,84.13 188.61,84.13 186.85,84.13 186.47,84.51 182.21,84.51 181.7,85.02 179.65,85.02 178.69,85.97 176.86,85.97 175.77,84.89 175.77,84.41 174.51,83.15 173.57,83.15 172.7,82.27 172.7,80.77 170.8,78.87 170.03,78.87 168.13,76.97 166.75,76.97 166.54,77.19 162.68,77.19 161.78,78.08 161.78,81.49 160.7,82.57 155.02,82.57 153.5,81.06 150.02,81.06 149.62,80.65 149.62,79.67 149.2,79.25 148.8,79.25 148.49,79.57 148.49,79.93 v2(148.32,80.09)
  BOTTOM w0.076: 148.46,79.31 148.46,78.94 148.6,78.79 148.6,77.59 148.45,77.43 148.45,77.02 148.48,76.92 148.48,76.73 148.45,76.64 148.45,76.4 148.46,76.35 148.51,76.2 148.59,75.92 148.59,75.8 148.66,75.54 UC1.D42
  BOTTOM w0.094: v2(236.38,66.04) 236.27,65.93 235.85,65.93 235.23,65.31 235.23,64.55 235.07,64.4 234.97,64.4 234.82,64.55 JNGFF2.45 ; v2(148.32,80.09) 148.47,79.95 148.46,79.94 148.46,79.31
CLK_PCIE_N1: length 270.5
  IN4 w0.112: v2(257.57,13.06) 257.69,13.18 257.84,13.18 258.04,12.98 258.04,11.95 260.97,9.02 269.05,9.02 271.46,11.43 271.46,15.17 269.94,16.7 269.94,17.89 269.74,18.09 269.74,19.08 268.97,19.84 268.97,26.17 269.53,26.72 269.53,29.79 268.52,30.8 268.52,33.69 267.84,34.37 267.84,36.88 267.66,37.06 267.66,37.36 267.66,37.36 267.66,40.91 269.02,42.26 269.96,42.26 270.37,42.68 270.83,42.68 271.47,43.32 272.9,43.32 273.42,42.8 274.8,42.8 282.1,50.1 282.1,56.68 281.55,57.23 281.55,60.58 281.7,60.72 281.7,64.05 282.35,64.7 282.35,69.59 280.58,71.35 274.73,71.35 273.7,72.38 273.7,73.48 272.65,74.54 271.28,74.54 268.97,76.85 267.6,76.85 265.14,79.31 265.14,83.79 263.91,85.01 262.96,85.01 261.4,86.57 261.4,88.4 257.55,92.25 257.55,92.71 256.15,94.11 254.92,94.11 252.99,96.04 248.81,96.04 247.32,97.52 229.93,97.52 228.26,99.2 228.26,101.05 226.69,102.62 224.98,102.62 220.41,98.05 220.41,97.45 220.41,97.24 219.58,96.41 218.06,96.41 217.65,96 211.4,96 210.32,94.92 210.32,94.31 210.43,94.21 210.43,92.82 210.17,92.56 210.17,89.84 209.69,89.36 209.11,89.36 208.16,90.31 202.4,90.31 201.1,89.01 199.77,89.01 198.98,88.22 191.23,88.22 189.18,90.26 186.8,90.26 186.31,90.75 184.98,90.75 183.81,91.92 180.6,91.92 179.92,91.24 172.05,91.24 171.47,91.82 170.39,91.82 169.36,92.86 167.36,92.86 166.86,92.36 160.92,92.36 156.96,88.39 150.76,88.39 149.41,87.05 149.41,83.21 149.86,82.76 149.86,82.46 150,82.32 150.16,82.32 150.25,82.23 v2(150.25,82)
  BOTTOM w0.076: 149.47,79.31 149.47,79.04 149.15,78.72 149.15,76.78 UC1.B42
  BOTTOM w0.094: JNGFF1.41 255.7,13.99 255.6,13.89 255.46,13.89 255.39,13.83 255.39,13.62 256.19,12.82 257.33,12.82 v2(257.57,13.06) ; 149.47,79.31 149.47,79.63 149.62,79.78 149.62,80.56 150.26,81.2 150.26,81.99 v2(150.25,82)
CLK_PCIE_N2: length 257.3
  IN4 w0.112: v2(261.75,13.05) 261.75,13.4 261.63,13.52 261.43,13.52 261.3,13.4 261.3,12.75 262.23,11.83 264.97,11.83 266.99,9.81 268.27,9.81 270.72,12.26 270.72,14.97 269.28,16.42 269.28,17.05 268.31,18.01 268.31,26.57 268.86,27.12 268.86,29.51 267.85,30.52 267.85,33.42 267.18,34.09 267.18,36.6 266.91,36.86 266.91,41.23 269.07,43.39 270.5,43.39 271.1,43.99 272.9,43.99 273.96,45.05 275.92,45.05 280.82,49.95 280.82,51.45 281.21,51.85 281.21,56.31 280.81,56.71 280.81,60.78 281.02,60.99 281.02,63.21 279.89,64.35 278.88,64.35 276.19,67.04 276.19,69.93 275.47,70.64 273.88,70.64 268.44,76.08 267.39,76.08 261.13,82.35 261.13,83.12 260.09,84.16 259.2,84.16 258.13,85.22 258.13,89.02 252.72,94.44 249.27,94.44 247.59,96.12 245.6,96.12 245.05,96.67 241.23,96.67 241.21,96.69 232.77,96.69 231.91,95.82 231.27,95.82 231.02,95.57 230.07,95.57 228.19,97.45 228.19,98.08 227.6,98.68 227.6,100.78 226.41,101.96 225.26,101.96 221.25,97.95 221.25,97.12 219.88,95.75 218.34,95.75 217.92,95.34 213.4,95.34 211.31,93.24 211.31,92.49 211.47,92.33 211.47,89.72 210.1,88.35 208.85,88.35 208.33,88.86 205.75,88.86 205.18,88.29 200.2,88.29 199.47,87.56 190.96,87.56 188.93,89.58 186.45,89.58 185.93,90.09 180.64,90.09 180.23,90.5 170.44,90.5 169.3,91.65 161.21,91.65 157.29,87.73 151.03,87.73 150.07,86.77 150.07,83.72 151.44,82.35 151.44,81.43 150.88,80.86 150.88,80.74 v2(151.04,80.57)
  BOTTOM w0.076: 150.13,79.31 150.06,79.24 150.06,78.9 149.53,78.37 149.53,76.51 149.74,76.31 149.74,76 149.44,75.71 UC1.D41
  BOTTOM w0.094: 150.13,79.31 150.86,80.04 150.86,80.39 v2(151.04,80.57) ; v2(261.75,13.05) 261.57,13.05 261.42,13.21 261.42,13.45 261.55,13.58 261.55,13.78 261.7,13.93 JNGFF1.65
CLK_PCIE_N3: length 253.8
  IN4 w0.112: v2(151.55,77.95) 151.48,78.03 151.48,78.17 151.56,78.25 151.75,78.25 151.92,78.42 152.67,78.42 155.02,80.77 155.02,82.02 157.49,84.48 157.49,86.88 161.52,90.91 169.1,90.91 170.18,89.83 179.68,89.83 180.6,88.91 188.66,88.91 190.7,86.87 198.93,86.87 199.33,86.47 200.85,86.47 201.22,86.84 201.22,87.35 201.49,87.63 205.08,87.63 205.21,87.49 210.2,87.49 212.74,90.02 212.74,93.45 213.96,94.67 217.94,94.67 218.61,94 220.73,94 223.19,96.47 223.19,96.9 223.64,97.34 224.26,97.34 227.29,94.31 231.55,94.31 231.96,94.72 237.25,94.72 237.68,95.15 247.49,95.15 249.12,93.53 252.69,93.53 255.42,90.8 255.42,88.48 256.22,87.68 256.22,84.67 257.4,83.49 259.82,83.49 260.46,82.85 260.46,81.82 266.99,75.29 268.3,75.29 273.61,69.98 275.02,69.98 275.52,69.47 275.52,66.71 279.86,62.38 279.86,61.06 280.11,60.81 280.11,57.63 279.34,56.85 279.34,54.47 278.77,53.9 278.77,49.58 275.8,46.61 272.76,46.61 270.22,44.07 268.52,44.07 266.2,41.76 266.2,36.64 266.51,36.33 266.51,33.76 267.14,33.14 267.14,29.85 267.14,29.06 267.14,29.06 267.14,23.1 266.74,22.71 266.74,18.39 268.34,16.79 268.34,11.15 268.06,10.88 267.24,10.88 263.64,14.47 256.4,14.47 253.54,11.61 252.78,11.61 252.65,11.75 252.65,11.87 252.57,11.95 v2(252.43,11.95)
  BOTTOM w0.076: UC1.D40 150.29,75.75 150.29,75.79 150.31,75.87 150.31,75.95 150.34,76.05 150.38,76.2 150.42,76.35 150.43,76.37 150.44,76.39 150.44,76.64 150.4,76.73 150.4,76.92 150.43,76.99 150.44,77.01 150.44,77.84 150.75,78.16 151.35,78.16 v2(151.55,77.95)
  BOTTOM w0.094: JNGFF3.53 253.55,10.21 253.43,10.34 253.43,11.53 253.06,11.9 252.48,11.9 v2(252.43,11.95)
CLK_PCIE_N4: length 147.7
  TOP w0.094: UL1.45 263.09,90.95 260.98,93.07 260.98,94.49 260.41,95.06 260.02,95.06 v2(259.63,94.67)
  IN1 w0.112: v2(259.63,94.67) 259.96,95.01 260.07,95.01 260.21,94.87 260.21,93.81 259.92,93.51 259.37,93.51 258.65,94.23 258.65,95.54 258.1,96.09 257.69,96.09 257.04,96.74 254.26,96.74 251.85,99.15 250.38,99.15 249.55,98.32 240.9,98.32 240.35,97.77 231.39,97.77 231.19,97.57 225.41,97.57 224.05,96.21 221.46,96.21 221.32,96.35 210.96,96.35 209.74,97.57 207.28,97.57 202.04,92.32 192.52,92.32 189.13,95.71 172.62,95.71 171.61,96.72 155.89,96.72 154.34,95.17 154.34,94.21 v2(154.24,94.11)
  BOTTOM w0.076: UC1.B40 150.01,76.73 149.71,77.03 149.71,78.26 150.35,78.89 150.58,79.13 150.68,79.23 150.68,79.27 150.72,79.31
  BOTTOM w0.094: v2(154.24,94.11) 154.25,94.1 154.25,93.38 154.76,92.87 154.76,91.77 150.07,87.08 150.07,83.22 151.2,82.09 151.2,81.33 151.59,80.94 151.88,80.94 152.03,80.78 152.03,80.34 151.58,79.89 151.3,79.89 150.72,79.31
CLK_PCIE_N5: length 199.6
  TOP w0.094: UR2.6 261.92,44.3 261.69,44.52 v2(261.69,44.56)
  IN4 w0.112: v2(261.69,44.56) 261.69,44.3 261.69,44.3 261.69,43.95 261.96,43.68 264.36,43.68 264.77,43.27 267.02,43.27 268.37,44.61 269.99,44.61 272.6,47.22 275.2,47.22 278.08,50.11 278.08,56.52 279.03,57.47 279.03,62.59 274.74,66.88 274.74,67.08 268.22,73.59 266.8,73.59 264.93,75.47 262.17,75.47 261.5,76.13 261.5,77.35 261,77.85 260.12,77.85 259.46,78.5 256.58,78.5 255.32,79.76 255.32,86.31 253.47,88.17 253.47,91.47 252.01,92.93 249.04,92.93 247.29,94.68 242.29,94.68 240.99,93.37 232.22,93.37 231.82,93.77 224.97,93.77 224.74,93.54 218.37,93.54 217.7,94.21 214.21,94.21 213.25,93.26 213.25,89.87 212.51,89.13 212.51,88.91 210.55,86.95 205.98,86.95 205.55,86.52 201.55,86.52 201.06,86.03 197.49,86.03 190.95,86.03 188.49,88.5 176.85,88.5 176.67,88.67 176.03,89.31 170.05,89.31 169.06,90.3 166.22,90.3 165.31,89.39 161.75,89.39 158.08,85.71 158.08,84.48 155.46,81.86 155.46,80.59 153.53,78.67 153.53,77.14 151.03,74.64 v2(151.03,74.64)
  BOTTOM w0.076: UC1.E40 150.84,74.44 v2(151.03,74.64)
CLK_PCIE_P0: length 130.2
  IN1 w0.112: v2(148.91,80.12) 148.73,79.95 148.73,79.67 148.91,79.5 149.1,79.5 149.37,79.77 149.37,80.75 149.92,81.3 153.4,81.3 154.92,82.82 160.8,82.82 162.03,81.59 162.03,78.19 162.78,77.44 166.64,77.44 166.86,77.22 168.03,77.22 169.93,79.12 170.7,79.12 172.45,80.87 172.45,82.38 173.47,83.39 174.41,83.39 175.53,84.51 175.53,84.99 176.75,86.22 178.8,86.22 179.75,85.27 181.8,85.27 182.31,84.76 186.57,84.76 186.96,84.37 188.71,84.37 188.82,84.37 188.97,84.53 191.09,84.53 191.37,84.25 196.85,84.25 196.91,84.3 203.72,84.3 203.93,84.09 208.53,84.09 209.28,83.34 209.28,83.34 210.23,82.39 222.42,82.39 223.84,83.81 223.84,85.57 224.61,86.34 227.74,86.34 228.84,85.25 228.84,82.9 229.65,82.1 231.44,82.1 234.52,79.01 234.52,75.32 235.59,74.25 235.84,74.25 237.32,72.77 237.32,66.03 237.04,65.75 236.72,65.75 236.43,65.46 v2(236.36,65.46)
  BOTTOM w0.076: UC1.C42 148.7,76.17 148.61,76.42 148.61,76.59 148.67,76.79 148.67,76.94 148.61,77.05 148.61,77.36 148.77,77.52 148.77,78.9 148.65,79.01 148.65,79.31
  BOTTOM w0.094: 148.65,79.31 148.65,79.85 148.72,79.93 148.72,79.94 v2(148.91,80.12) ; JNGFF2.47 234.82,64.05 234.97,64.2 235.15,64.2 235.42,64.47 235.42,65.23 235.93,65.74 236.08,65.74 v2(236.36,65.46)
CLK_PCIE_P1: length 270.5
  IN4 w0.112: v2(257.57,12.48) 257.79,12.25 257.79,11.85 260.87,8.77 269.15,8.77 271.71,11.33 271.71,15.28 270.19,16.8 270.19,17.99 269.99,18.19 269.99,19.18 269.22,19.94 269.22,26.07 269.77,26.62 269.77,29.89 268.76,30.9 268.76,33.8 268.09,34.47 268.09,36.98 267.91,37.16 267.91,37.26 267.91,40.8 269.12,42.02 270.06,42.02 270.47,42.43 270.93,42.43 271.57,43.07 272.79,43.07 273.32,42.55 274.9,42.55 282.35,49.99 282.35,56.78 281.8,57.33 281.8,60.48 281.94,60.62 281.94,63.95 282.59,64.6 282.59,69.69 280.68,71.6 274.83,71.6 273.95,72.48 273.95,73.58 272.75,74.78 271.38,74.78 269.07,77.09 267.71,77.09 265.38,79.41 265.38,83.89 264.02,85.26 263.06,85.26 261.65,86.67 261.65,88.5 257.8,92.35 257.8,92.81 256.25,94.36 255.02,94.36 253.09,96.28 248.91,96.28 247.43,97.77 230.04,97.77 228.51,99.3 228.51,101.16 226.79,102.87 224.88,102.87 220.31,98.29 220.16,98.15 220.16,97.34 219.48,96.66 217.96,96.66 217.55,96.24 211.3,96.24 210.08,95.03 210.08,94.21 210.18,94.11 210.18,92.92 209.92,92.66 209.92,89.95 209.59,89.61 209.21,89.61 208.27,90.55 202.3,90.55 201,89.25 199.67,89.25 198.88,88.46 191.33,88.46 189.29,90.51 186.9,90.51 186.41,91 185.08,91 183.92,92.16 180.49,92.16 179.82,91.49 172.16,91.49 171.57,92.07 170.5,92.07 169.46,93.1 167.25,93.1 166.75,92.6 160.82,92.6 156.85,88.64 150.65,88.64 149.17,87.15 149.17,83.11 149.62,82.66 v2(149.62,82)
  BOTTOM w0.076: 149.27,79.31 149.27,79.3 149.29,79.28 149.29,79.1 148.98,78.79 148.98,77.26 UC1.A42
  BOTTOM w0.094: JNGFF1.39 255.2,13.54 256.11,12.63 257.42,12.63 v2(257.57,12.48) ; 149.27,79.31 149.27,79.71 149.42,79.86 149.42,80.64 150.06,81.28 150.06,81.55 149.91,81.71 149.73,81.71 149.62,81.82 v2(149.62,82)
CLK_PCIE_P2: length 257.7
  IN4 w0.112: v2(150.43,80.57) 150.63,80.77 150.63,80.96 151.2,81.53 151.2,82.24 149.83,83.61 149.83,86.87 150.93,87.97 157.19,87.97 161.11,91.9 169.4,91.9 170.54,90.75 180.33,90.75 180.75,90.34 186.03,90.34 186.55,89.82 189.04,89.82 191.06,87.8 199.37,87.8 200.1,88.54 205.08,88.54 205.65,89.11 208.44,89.11 208.95,88.59 209.99,88.59 211.22,89.82 211.22,92.23 211.06,92.39 211.06,93.34 213.3,95.58 217.82,95.58 218.24,96 219.78,96 221,97.22 221,98.05 225.16,102.21 226.52,102.21 227.84,100.88 227.84,98.78 228.44,98.19 228.44,97.55 230.17,95.82 230.91,95.82 231.17,96.07 231.8,96.07 232.67,96.93 241.31,96.93 241.33,96.91 245.15,96.91 245.7,96.36 247.69,96.36 249.37,94.69 252.82,94.69 258.38,89.13 258.38,85.32 259.3,84.4 260.2,84.4 261.37,83.22 261.37,82.45 267.49,76.33 268.54,76.33 273.98,70.89 275.58,70.89 276.43,70.03 276.43,67.14 278.98,64.6 279.99,64.6 281.27,63.31 281.27,60.89 281.06,60.68 281.06,56.81 281.46,56.41 281.46,51.75 281.06,51.35 281.06,49.85 276.02,44.8 274.07,44.8 273,43.74 271.2,43.74 270.6,43.14 269.18,43.14 267.16,41.13 267.16,36.97 267.42,36.7 267.42,34.2 268.1,33.52 268.1,30.62 269.11,29.61 269.11,27.02 268.56,26.47 268.56,18.11 269.52,17.15 269.52,16.52 270.97,15.08 270.97,12.16 268.37,9.56 266.89,9.56 264.87,11.58 262.13,11.58 261.06,12.65 261.06,12.88 v2(260.88,13.06)
  BOTTOM w0.076: 149.9,79.31 149.9,78.96 149.37,78.44 149.37,76.57 149.13,76.33 149.13,76.04 149.25,75.91 149.36,75.91 149.44,76 UC1.C41
  BOTTOM w0.094: v2(260.88,13.06) 261.07,13.06 261.22,13.21 261.22,13.53 261.28,13.59 261.35,13.66 261.35,13.78 261.2,13.93 JNGFF1.63 ; v2(150.43,80.57) 150.67,80.34 150.67,80.12 149.9,79.35 149.9,79.31
CLK_PCIE_P3: length 253.7
  IN4 w0.112: v2(252.43,11.37) 253.64,11.37 256.5,14.23 263.53,14.23 267.13,10.63 268.17,10.63 268.58,11.05 268.58,16.9 266.99,18.49 266.99,22.61 267.38,23 267.38,28.96 267.38,28.96 267.38,29.95 267.38,33.24 266.76,33.86 266.76,36.43 266.45,36.74 266.45,41.66 268.62,43.83 270.32,43.83 272.86,46.37 275.91,46.37 279.01,49.47 279.01,53.8 279.59,54.37 279.59,56.75 280.36,57.53 280.36,60.91 280.11,61.17 280.11,62.48 275.77,66.82 275.77,69.57 275.12,70.22 273.71,70.22 268.4,75.54 267.1,75.54 260.71,81.92 260.71,82.95 259.92,83.74 257.5,83.74 256.47,84.78 256.47,87.79 255.67,88.59 255.67,90.9 252.79,93.77 249.22,93.77 247.59,95.4 237.58,95.4 237.15,94.97 231.86,94.97 231.45,94.56 227.4,94.56 224.37,97.59 223.54,97.59 222.95,97 222.95,96.57 220.63,94.25 218.71,94.25 218.04,94.92 213.86,94.92 212.49,93.55 212.49,90.12 210.1,87.74 205.32,87.74 205.18,87.87 201.39,87.87 200.98,87.46 200.98,86.94 200.75,86.71 199.43,86.71 199.03,87.12 190.8,87.12 188.76,89.16 180.7,89.16 179.78,90.08 170.28,90.08 169.2,91.15 161.42,91.15 157.24,86.98 157.24,84.58 154.78,82.12 154.78,80.88 152.57,78.67 151.55,78.67 v2(151.55,78.67)
  BOTTOM w0.076: v2(151.55,78.67) 151.63,78.59 151.63,78.43 151.53,78.32 150.68,78.32 150.27,77.91 150.27,77.05 150.22,76.94 150.22,76.79 150.27,76.59 150.27,76.42 150.19,76.17 150.15,76.1 150.15,76 UC1.C40
  BOTTOM w0.094: JNGFF3.55 253.05,10.17 253.23,10.36 253.23,11.45 252.98,11.71 252.77,11.71 v2(252.43,11.37)
CLK_PCIE_P4: length 147.9
  TOP w0.094: v2(259.63,95.25) 260.49,95.25 261.17,94.57 261.17,93.15 263.28,91.03 263.28,90.78 263.49,90.57 UL1.44
  IN1 w0.112: v2(259.63,95.25) 260.18,95.25 260.46,94.97 260.46,93.7 260.02,93.27 259.27,93.27 258.41,94.13 258.41,95.44 258,95.85 257.59,95.85 256.94,96.49 254.16,96.49 251.75,98.9 250.48,98.9 249.65,98.07 241,98.07 240.45,97.52 231.49,97.52 231.3,97.32 225.51,97.32 224.15,95.97 221.35,95.97 221.22,96.1 210.86,96.1 209.64,97.32 207.39,97.32 202.14,92.08 192.42,92.08 189.03,95.46 172.52,95.46 171.51,96.47 155.99,96.47 154.59,95.07 154.59,94.35 v2(154.82,94.11)
  BOTTOM w0.076: 150.99,79.31 150.74,79.06 150.41,78.73 150.22,78.53 150.22,78.4 150.1,78.29 149.97,78.29 149.88,78.19 149.88,78.08 149.99,77.97 149.99,77.88 149.88,77.77 149.88,77.69 149.99,77.57 149.99,77.47 149.88,77.36 149.88,77.29 UC1.A40
  BOTTOM w0.094: 150.99,79.31 151.38,79.69 151.66,79.69 152.23,80.26 152.23,80.86 151.96,81.13 151.67,81.13 151.58,81.22 151.39,81.41 151.39,82.17 150.26,83.3 150.26,87 154.96,91.69 154.96,92.95 154.44,93.46 154.44,93.73 v2(154.82,94.11)
CLK_PCIE_P5: length 199.5
  TOP w0.094: v2(262.29,44.56) 262.11,44.37 262.11,44.24 262.32,44.04 UR2.5
  IN4 w0.112: v2(151.02,74.01) 151.12,73.92 151.34,73.92 151.47,74.04 151.47,74.73 153.78,77.04 153.78,78.56 155.71,80.49 155.71,81.76 158.32,84.37 158.32,85.61 161.85,89.14 165.42,89.14 166.33,90.05 168.96,90.05 169.95,89.06 175.93,89.06 176.42,88.57 176.74,88.25 188.38,88.25 190.85,85.78 191.1,85.78 197.06,85.78 201.16,85.78 201.65,86.27 205.65,86.27 206.08,86.7 210.65,86.7 212.76,88.8 212.76,89.02 213.5,89.77 213.5,93.15 214.31,93.97 217.6,93.97 218.27,93.29 224.84,93.29 225.07,93.53 231.72,93.53 232.12,93.13 241.09,93.13 242.39,94.43 247.19,94.43 248.94,92.68 251.91,92.68 253.22,91.37 253.22,88.07 255.08,86.21 255.08,79.66 256.48,78.25 259.36,78.25 260.01,77.6 260.9,77.6 261.26,77.24 261.26,76.02 262.06,75.22 264.83,75.22 266.7,73.35 268.12,73.35 274.49,66.98 274.49,66.78 278.78,62.49 278.78,57.57 277.84,56.62 277.84,50.21 275.09,47.47 272.5,47.47 269.89,44.86 268.27,44.86 266.92,43.51 264.87,43.51 264.46,43.93 262.06,43.93 261.94,44.05 261.94,44.2 v2(262.29,44.56)
  BOTTOM w0.076: v2(151.02,74.01) 151.1,74.1 151.45,74.1 151.52,74.17 151.52,74.41 UC1.E38
