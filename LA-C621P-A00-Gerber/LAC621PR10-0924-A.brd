# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML1_SMBCLK: length 122.3
  TOP w0.102: UE2.B6 270.14,59.79 269.98,59.95 v2(269.84,59.95)
  IN1 w0.089: v2(177.7,69.17) 178.16,69.62 180.96,69.62 181.89,68.7 184.11,68.7 184.35,68.95 185.17,69.76 187.21,69.76 187.41,69.96 189.41,69.96 190.1,70.65 190.1,71 190.07,71.03 190.07,72.06 193.91,75.9 197.98,75.9 197.98,75.9 198.56,75.9 199.77,77.11 220.48,77.11 221.22,76.37 227.24,76.37 229.98,73.63 229.98,73.44 231.04,72.38 231.04,69.81 231.15,69.7 231.15,67.51 231.45,67.21 231.45,64.62 232.34,63.73 232.34,62.53 234.12,60.75 239.11,60.75 239.42,61.06 248.66,61.06 249.37,61.77 250.71,61.77 252.35,60.13 v2(252.72,60.13)
  IN4 w0.089: v2(269.84,59.95) 269.46,60.33 261.7,60.33 260.35,58.99 260.35,57.2 259.85,56.7 257.09,56.7 253.61,60.18 252.76,60.18 v2(252.72,60.13)
  BOTTOM w0.076: UC1.W3 172.25,67.22 172.41,67.22 172.63,67.29 172.76,67.29 172.76,67.29 172.92,67.25 173.17,67.25 173.27,67.29 173.45,67.37 173.48,67.38 173.74,67.38 173.78,67.35 173.91,67.35 173.91,67.35 175.68,67.35 176.56,68.22
  BOTTOM w0.102: RC15.1 177.96,68.91 v2(177.7,69.17) 177.47,68.94 177.29,68.76 177.28,68.75 177.01,68.75 176.56,68.3 176.56,68.22
SML1_SMBDATA: length 126.4
  TOP w0.102: v2(272.05,59.54) 272,59.54 272,59.54 UE2.A5
  IN1 w0.089: v2(177.12,69.2) 177.12,69.4 177.82,70.09 181.16,70.09 181.97,69.28 184.02,69.28 184.98,70.23 185.37,70.23 187.02,70.23 187.21,70.43 188.56,70.43 189.6,71.47 189.6,72.25 193.72,76.37 198.17,76.37 198.36,76.37 199.58,77.58 220.67,77.58 221.42,76.84 227.43,76.84 230.45,73.83 230.45,73.63 231.51,72.57 231.51,70.01 231.62,69.9 231.62,67.71 231.92,67.41 231.92,64.81 232.81,63.92 232.81,62.73 234.32,61.22 238.92,61.22 239.23,61.53 248.47,61.53 249.04,62.1 249.04,62.15 249.13,62.24 250.91,62.24 252.41,60.73 252.69,60.73 v2(252.72,60.76)
  IN4 w0.089: v2(272.05,59.54) 271.08,59.54 270.34,60.28 270.34,60.96 270.09,61.22 268.29,61.22 267.88,60.8 261.5,60.8 259.88,59.18 259.88,57.39 259.66,57.17 257.29,57.17 253.81,60.65 252.81,60.65 252.72,60.73 v2(252.72,60.76)
  BOTTOM w0.076: UC1.V3 172,67.42 172.47,67.42 172.6,67.46 172.79,67.46 172.81,67.45 172.94,67.42 173.14,67.42 173.39,67.52 173.45,67.54 173.81,67.54 173.84,67.51 175.5,67.51 176.29,68.3 176.29,68.37 v2(177.12,69.2) 177.12,69.22 177.35,69.45
  BOTTOM w0.102: RC17.1 177.7,69.8 177.35,69.45
SNB_+1VALWP:
  vias: v3(221.76,54.3)
SNUB_1.2V:
  vias: v3(81.14,48.68)
SNUB_1.8VALW:
  vias: v3(211.24,109.97)
SNUB_1VS_VCCIO: length 1.2
  BOTTOM w0.381: PR405.2 v3(199.78,48.67)
SOFT_START_GC: length 20.2
  TOP w0.203: PU901.2 25.18,77.51 v2(24.86,77.2)
  TOP w0.254: PR14.2 30.94,89.61 29.22,87.89 v2(29.22,86.54)
  IN2 w0.254: v2(29.22,86.54) 28.61,85.93 28.61,80.6 27.02,79.01 26.06,79.01 24.86,77.81 v2(24.86,77.2)
SPKR: length 142.2
  TOP w0.102: v2(263.94,35.43) 264.03,35.34 266.89,35.34 v3(268.64,33.59) 269.68,32.54 269.68,29.65 269.98,29.35 270.65,29.35 271.54,28.46 RA12.2 ; RC183.2 187.25,57.09 185.82,57.09 185.31,57.6 178.75,57.6 178.48,57.87 172.58,57.87 172.3,57.59 171.57,57.59 v2(171.23,57.24)
  IN1 w0.089: v2(263.94,35.43) 264.15,35.64 264.15,36.7 263.08,37.76 259.43,37.76 259.43,37.76 257.99,37.76 257.29,37.06 256.78,37.06 255.87,37.96 255.13,37.96 253.88,36.71 250.55,36.71 250.28,36.98 249.51,36.98 249.33,37.16 248.56,37.16 248.39,36.99 247.3,36.99 246.49,36.18 246.49,35.91 246.2,35.61 244.24,35.61 243.11,35.61 242.1,34.61 239.1,34.61 238.53,35.18 235.93,35.18 235,36.11 232.36,36.11 231.42,35.17 227.67,35.17 225.96,35.17 225.34,34.56 222.62,34.56 222.42,34.76 220.55,34.76 219.73,33.94 213.97,33.94 213.72,34.2 191.74,34.2 184,41.94 181.43,41.94 180.9,42.47 179.76,42.47 172.58,49.65 172.58,50.82 172.13,51.27 172.13,54.98 171.67,55.44 171.67,56.8 v2(171.23,57.24)
  BOTTOM w0.076: v2(171.23,57.24) 171.13,57.24 UC1.AW5
SRTCRST#: length 35.8
  TOP w0.102: CC24.1 187.51,45.34 188.41,46.24 RC56.1 188.66,46.35 188.66,47.5 188.76,47.6 v2(188.76,47.74)
  IN4 w0.089: v2(188.76,47.74) 188.62,47.88 187.68,47.88 186.81,48.76 179.85,48.76 176.37,52.24 171.77,52.24 171.21,52.8 168.39,52.8 166.8,54.39 166.24,54.39 163.41,57.21 163.41,59.52 v2(163,59.92)
  BOTTOM w0.076: v2(163,59.92) 163.33,60.25 UC1.AN18
SS_1V_PRIM: length 3.5
  BOTTOM w0.254: PU402.7 199.26,70.87 199.13,71 199.13,71.58 198.72,71.99 198.72,71.99 198.54,72.17 198.54,72.19 PC420.1 PR428.1
SS_1VS_VCCIO: length 5.8
  BOTTOM w0.254: PR427.2 PC410.1 204.18,58.59 v3(204.03,58.44) 204.03,55.74 203.78,55.49 PU401.7
STSTART_DCBLOCK_GC: length 115.6
  TOP w0.254: PR906.2 123.51,102.4 123.81,102.71 v2(123.81,103.73) ; PU901.16 30.3,82.29 31.03,83.01 v2(31.03,84.1)
  IN2 w0.254: v2(98.03,101.13) 97.54,100.64 94.96,100.64 92.94,98.62 60.47,98.62 60.19,98.91 56.74,98.91 54.94,97.11 54.94,96.56 45.81,87.43 39.86,87.43 38.42,88.88 33.97,88.88 31.63,86.54 31.63,84.71 v2(31.03,84.1) ; v2(123.81,103.73) 123.81,102.72 118.43,97.34 116.12,97.34 v2(115.3,98.15)
  IN3 w0.254: v2(115.3,98.15) 115.3,97.36 113.42,95.48 107.3,95.48 107.16,95.62 106.59,95.85 106.56,95.86 106.55,95.86 106.49,95.89 106.49,95.89 106,95.89 104.93,95.89 99.69,101.13 v2(98.03,101.13)
SUS_STAT#: length 18.4
  TOP w0.102: v2(173.24,49.56) 173.24,48.84 175.72,46.36 175.72,45.8 v3(175.85,45.67) 176.06,45.46 176.5,45.46 176.8,45.17 176.8,44.45 RC26.1
  BOTTOM w0.076: 170.58,51.91 170.2,52.29 169.39,52.29 167.97,53.71 167.83,53.71 167.83,53.71 167.63,53.71 166.96,54.38 166.96,54.92 UC1.BA11
  BOTTOM w0.102: 170.58,51.91 171.23,51.26 171.23,50.14 172.1,49.28 172.96,49.28 v2(173.24,49.56)
SUSACK#: length 151.6
  TOP w0.102: UE2.B7 270.09,60.29 270.01,60.38 269.51,60.38 v2(269.1,60.79)
  IN1 w0.089: v2(258.69,35.29) 258.69,35.28 258.17,34.77 258.02,34.77 257.58,34.33 254.86,34.33 254.42,34.77 249.88,34.77 249.77,34.67 249.23,34.67 247.22,32.66 245.59,32.66 244.94,32.01 242.65,32.01 242.21,32.45 236.69,32.45 236.19,31.94 234.95,31.94 233.62,31.94 233.45,31.77 230.68,31.77 230.34,32.11 228.28,32.11 227.57,31.4 227.57,30.69 226.73,29.84 225.48,29.84 225,30.32 213.79,30.32 212.53,31.58 187.04,31.58 180.04,38.58 175.86,38.58 171.82,42.62 171.82,45.43 168.25,48.99 168.25,54.7 166.19,56.77 166.19,58.82 v2(166.61,59.24)
  IN3 w0.122: v2(269.1,60.79) 266.68,60.79 264.63,58.73 264.63,57.21 263.86,56.44 262.01,56.44 261.68,56.11 261.68,55.31 261.68,53.15 261.92,52.91 261.92,51.35 261.75,51.18 261.75,49.53 263.6,47.69 263.6,46.77 262.7,45.88 262.01,45.88 260.79,44.66 260.79,39.57 259.29,38.07 259.29,35.89 v2(258.69,35.29)
  BOTTOM w0.076: UC1.AP11 166.97,59.6 v2(166.61,59.24)
SUSCLK: length 126.3
  TOP w0.102: RC48.1 175.98,44.53 176.14,44.53 v2(176.31,44.71) ; v2(257.39,18.37) 257.01,18.75 RZ56.1 ; v2(250.28,11.54) 250.74,11.08 RN99.2
  IN1 w0.089: v2(257.39,18.37) 257.39,18.26 255.94,16.81 255.42,16.81 253.47,14.86 252,14.86 251.28,14.14 251.28,12.54 v2(250.28,11.54)
  IN4 w0.089: v2(214.69,41.86) 215.38,41.18 215.56,41.18 219.09,37.65 219.36,37.65 220.27,36.73 220.27,36.43 222.28,34.41 222.38,34.41 222.61,34.18 222.61,33.68 223.11,33.18 224.5,31.79 224.5,30.99 224.5,30.24 225.53,29.2 227.17,27.56 227.17,26.85 228.57,25.45 228.57,24.5 232.24,20.83 232.24,20.55 236.05,16.75 240.6,16.75 241.39,15.96 241.84,15.96 242.67,15.12 243.11,15.12 244.04,14.19 250.8,14.19 251.1,13.89 251.1,12.36 v2(250.28,11.54)
  BOTTOM w0.076: 166.89,50.4 163.88,53.41 163.88,54.71 163.61,54.98 UC1.BA17
  BOTTOM w0.102: v2(214.69,41.86) 214.34,41.51 213.11,41.51 212.88,41.74 210.54,41.74 209.96,41.16 207.22,41.16 206.97,41.42 179.6,41.42 v2(176.31,44.71) 171.38,44.71 166.89,49.2 166.89,50.4
SUSCLK_R: length 13.8
  TOP w0.102: v2(249.69,11.51) 248.84,11.51 248.66,11.32 v3(248.66,11.12) 248.66,10.84 248.74,10.75 RN99.1
  IN1 w0.089: v2(250.56,1.66) 249.77,2.44 249.77,11.43 v2(249.69,11.51)
  BOTTOM w0.102: JNGFF3.60 v2(250.56,1.66)
SW1_DP0_AUXN: length 29.8
  TOP w0.094: v2(204.51,80.73) 204.51,80.13 206.41,78.23 218.37,78.23 220.2,80.06 220.91,80.77 221.14,81 221.14,81.31 CV111.1
  BOTTOM w0.094: v2(204.51,80.73) 204.51,82.41 204.12,82.79 204.12,83.73 203.69,84.17 202.94,84.17 202.85,84.08 201.41,84.08 RV604.2 200.98,84 200.86,84.11 200.59,84.11 200.3,84.4 200.3,84.84 200.11,85.03 199.59,85.03 199.49,84.93 UV26.27
SW1_DP0_AUXN_C: length 4.9
  TOP w0.094: CV111.2 221.24,82.84 221.24,83.14 220.62,83.76 220.08,83.76 218.77,85.07 218.77,85.56 218.46,85.87 UV8.H2
SW1_DP0_AUXP: length 29.8
  TOP w0.094: v2(205.11,80.75) 204.7,80.34 204.7,80.21 206.49,78.43 218.29,78.43 219.32,79.46 220.07,80.2 220.78,80.91 220.95,81.08 220.95,81.32 CV110.1
  BOTTOM w0.094: UV26.26 199.5,85.33 199.6,85.22 200.19,85.22 200.49,84.92 200.49,84.48 200.67,84.31 200.88,84.31 200.98,84.4 RV608.2 201.44,84.3 202.8,84.3 202.86,84.36 203.02,84.36 203.77,84.36 204.32,83.81 204.32,82.87 204.7,82.49 204.7,81.15 v2(205.11,80.75)
SW1_DP0_AUXP_C: length 4.9
  TOP w0.094: UV8.H1 218.38,85.16 218.38,84.94 218.5,84.81 218.76,84.81 220,83.57 220.54,83.57 221.05,83.06 221.05,82.51 220.94,82.4 220.79,82.4 CV110.2
SW1_DP0_CADET: length 1.6
  BOTTOM w0.102: UV26.43 193.45,82.42 193.31,82.27 RV606.2
SW1_DP0_HPD: length 59.1
  TOP w0.076: 221.33,83.7 220.79,84.24 220.36,84.24 219.36,85.24 UV8.J1
  TOP w0.102: 221.33,83.7 221.33,83.55 222.08,82.8 222.08,81.53 222.72,80.89 229.39,80.89 v2(230.72,79.56)
  BOTTOM w0.102: UV26.48 191.45,82.28 191.11,81.94 191.11,81.8 190.66,81.36 190.66,79.72 191.16,79.23 196.08,79.23 196.18,79.13 199.76,79.13 199.97,79.34 219.27,79.34 219.74,79.81 v3(230.06,79.81) 230.47,79.81 v2(230.72,79.56)
SW1_DP0_N0: length 39.1
  TOP w0.094: CV103.1 219.38,81.32 219.38,81.03 217.18,78.82 208.58,78.82 206.04,81.36 201.42,81.36 200.92,80.86 200.92,79.5 199.92,78.5 191.7,78.5 190.98,79.21 190.69,79.51 190.44,79.76 v2(189.7,79.76)
  BOTTOM w0.094: v2(189.7,79.76) 190.23,79.76 190.45,79.98 190.45,81.71 190.95,82.2 190.95,82.63 191.05,82.73 UV26.49
SW1_DP0_N0_C: length 4.1
  TOP w0.094: UV8.G2 217.81,85.89 218.15,85.55 218.15,84.67 218.47,84.34 v4(219.07,83.75) 219.48,83.33 219.48,82.82 CV103.2
SW1_DP0_N1: length 35.1
  TOP w0.094: CV105.1 217.63,81.33 217.63,80.82 216.22,79.42 208.82,79.42 206.06,82.18 201.23,82.18 200.26,81.21 200.26,79.88 199.7,79.32 199.57,79.19 196.39,79.19 195.22,80.36 193.55,80.36 193.47,80.43 191.89,80.43 191.77,80.32 191.77,80.05 v2(191.88,79.94)
  BOTTOM w0.094: v2(191.88,79.94) 191.73,80.09 191.73,80.96 191.59,81.1 191.59,81.8 192.25,82.46 UV26.46
SW1_DP0_N1_C: length 3.6
  TOP w0.094: UV8.F2 217.46,85.59 217.46,84.47 217.7,84.22 v4(217.7,83.64) 217.7,82.84 CV105.2
SW1_DP0_N2: length 29.3
  TOP w0.094: CV107.1 215.87,81.32 215.87,80.7 215.3,80.12 208.98,80.12 206.22,82.88 196.6,82.88 194.67,80.95 193.79,80.95 192.79,81.95 192.58,81.95 192.49,81.87 192.49,81.65 v2(192.61,81.54)
  BOTTOM w0.094: UV26.44 193.05,82.55 192.47,81.97 192.47,81.66 192.6,81.54 v2(192.61,81.54)
SW1_DP0_N2_C: length 3.9
  TOP w0.094: UV8.E2 216.8,85.6 216.8,84.03 v4(216.38,83.62) 215.96,83.2 215.96,82.83 CV107.2
SW1_DP0_N3: length 24.6
  TOP w0.094: CV109.1 214.02,81.23 214.02,80.93 213.8,80.71 209.25,80.71 206.43,83.53 205.35,83.53 205.32,83.5 204.7,83.5 204.66,83.53 204.26,83.53 203.71,84.08 v4(202.94,84.08) 201.94,84.08 201.64,83.77 195.34,83.77 194.09,82.53 194.09,82.32 v2(194.35,82.07)
  BOTTOM w0.094: v2(194.35,82.07) 194.25,82.16 UV26.41
SW1_DP0_N3_C: length 4.6
  TOP w0.094: UV8.D2 216.14,85.61 216.14,84.99 216.07,84.92 216.07,84.55 215.84,84.33 215.69,84.33 215.53,84.16 215.3,83.93 215.19,83.83 215.19,83.78 214.78,83.37 214.73,83.37 214.44,83.08 214.21,83.08 214.15,83.01 214.15,82.89 CV109.2
SW1_DP0_P0: length 39.1
  TOP w0.094: v2(189.67,80.39) 189.81,80.39 189.93,80.27 189.93,80.1 190.08,79.95 190.52,79.95 190.82,79.65 191.12,79.35 191.78,78.69 199.84,78.69 200.73,79.58 200.73,80.94 201.34,81.55 206.12,81.55 208.66,79.02 217.1,79.02 219.19,81.11 219.19,81.31 CV102.1
  BOTTOM w0.094: v2(189.67,80.39) 189.67,80.22 189.75,80.14 189.86,80.14 190.04,79.95 190.15,79.95 190.26,80.06 190.26,81.79 190.75,82.28 190.75,82.59 190.65,82.7 UV26.50
SW1_DP0_P0_C: length 4.1
  TOP w0.094: UV8.G1 217.69,85.12 217.69,84.94 217.74,84.89 217.87,84.89 217.95,84.8 217.95,84.59 218.7,83.84 218.7,83.8 219.12,83.38 219.16,83.38 219.29,83.25 219.29,82.53 219.19,82.43 218.99,82.43 CV102.2
SW1_DP0_P1: length 35.1
  TOP w0.094: CV104.1 217.44,81.31 217.44,80.9 216.14,79.61 208.9,79.61 206.14,82.38 201.15,82.38 200.07,81.29 200.07,79.96 199.56,79.46 199.49,79.38 196.47,79.38 195.3,80.55 193.63,80.55 193.55,80.63 191.81,80.63 191.58,80.4 191.58,80.24 v2(191.3,79.96)
  BOTTOM w0.094: UV26.47 191.85,82.33 191.39,81.88 191.39,81.02 191.54,80.88 191.54,80.2 v2(191.3,79.96)
SW1_DP0_P1_C: length 3.7
  TOP w0.094: UV8.F1 217.08,85.24 217,85.17 217,84.94 217.11,84.84 217.21,84.84 217.27,84.78 217.27,84.39 217.51,84.14 217.51,83.97 217.48,83.93 217.48,83.34 217.51,83.31 217.51,82.5 217.41,82.4 217.26,82.4 CV104.2
SW1_DP0_P2: length 29.3
  TOP w0.094: v2(192.03,81.57) 192.07,81.57 192.3,81.8 192.3,81.95 192.5,82.15 192.87,82.15 193.87,81.14 194.59,81.14 196.52,83.08 206.3,83.08 209.06,80.31 215.22,80.31 215.68,80.77 215.68,81.32 CV106.1
  BOTTOM w0.094: UV26.45 192.65,82.42 192.27,82.05 192.27,81.81 192.04,81.57 v2(192.03,81.57)
SW1_DP0_P2_C: length 3.9
  TOP w0.094: CV106.2 215.51,82.4 215.61,82.4 215.77,82.56 215.77,83.28 216.01,83.52 216.01,83.56 216.43,83.98 216.47,83.98 216.6,84.11 216.6,84.78 216.55,84.84 216.45,84.84 216.34,84.94 216.34,85.14 216.44,85.24 UV8.E1
SW1_DP0_P3: length 24.6
  TOP w0.094: CV108.1 213.83,81.43 213.83,81.01 213.72,80.91 209.33,80.91 206.51,83.73 v4(204.99,83.73) 204.34,83.73 203.79,84.27 203.26,84.27 203.23,84.3 202.61,84.3 202.58,84.27 201.86,84.27 201.56,83.97 195.26,83.97 193.9,82.61 193.9,82.19 v2(193.76,82.05)
  BOTTOM w0.094: v2(193.76,82.05) 193.98,82.26 193.98,82.41 193.85,82.54 UV26.42
SW1_DP0_P3_C: length 4.6
  TOP w0.094: CV108.2 213.96,82.93 213.96,83.09 214.13,83.27 214.36,83.27 214.65,83.56 v4(214.83,83.73) 215,83.91 215.22,84.12 215.39,84.3 215.61,84.52 215.76,84.52 215.88,84.63 215.88,84.81 215.89,84.82 215.89,84.84 215.76,84.97 215.66,84.97 215.57,85.06 215.57,85.36 215.65,85.45 215.77,85.45 215.86,85.36 UV8.D1
SW1_DP1_AUXN: length 114.1
  TOP w0.094: CV150.1 247.96,23.34 247.96,24.83 248.8,25.67 251.37,25.67 251.53,25.84 251.53,26.03 v2(251.29,26.27)
  IN4 w0.089: v2(251.29,26.27) 251.45,26.42 251.45,27 251.31,27.13 249.87,27.13 246.92,30.08 246.92,33.5 245.79,34.63 244.84,34.63 243.03,36.44 243.03,38.41 239.7,41.74 238.88,41.74 238.17,42.45 237.21,42.45 236.77,42.9 236.77,43.93 239.78,46.94 239.78,47.98 240.54,48.74 240.54,51.3 241.36,52.12 241.36,53 240.08,54.28 240.08,56.82 241.22,57.96 241.22,61.09 239.55,62.75 239.55,69.55 237.71,71.4 237.71,74.99 231.94,80.75 207.21,80.75 206.49,80.03 203.29,80.03 202.98,80.35 202.98,80.48 202.7,80.75 202.7,80.76 202.72,80.76 v2(202.72,80.75)
  BOTTOM w0.094: UV26.29 199.43,84.13 199.53,84.23 199.64,84.23 199.88,83.98 199.88,82.58 200.43,82.03 200.84,82.03 201.03,81.84 RV605.2 201.61,81.97 202.63,81.97 203.12,81.48 203.12,81.15 v2(202.72,80.75)
SW1_DP1_AUXN_C: length 4.4
  TOP w0.094: v2(248.17,20.37) 248.42,20.62 248.42,20.86 247.96,21.32 247.96,21.73 CV150.2
  BOTTOM w0.094: v2(248.17,20.37) 248.37,20.57 248.37,20.98 248.59,21.2 248.59,21.4 248.45,21.54 JNGFF1.12
SW1_DP1_AUXP: length 114.1
  TOP w0.094: CV149.1 248.15,23.34 248.15,24.75 248.88,25.48 251.45,25.48 251.73,25.76 251.73,26.07 v2(251.93,26.27)
  IN4 w0.089: v2(251.93,26.27) 251.63,26.57 251.63,27.08 251.39,27.31 249.94,27.31 247.1,30.16 247.1,33.58 245.87,34.81 244.92,34.81 243.21,36.52 243.21,38.48 239.77,41.93 238.96,41.93 238.24,42.64 237.29,42.64 236.95,42.98 236.95,43.85 239.97,46.87 239.97,47.9 240.72,48.66 240.72,51.23 241.54,52.05 241.54,53.08 240.27,54.36 240.27,56.75 241.4,57.88 241.4,61.16 239.74,62.83 239.74,69.63 237.89,71.47 237.89,75.07 232.02,80.93 207.14,80.93 206.41,80.21 203.37,80.21 203.16,80.42 203.16,80.6 v2(203.31,80.75)
  BOTTOM w0.094: v2(203.31,80.75) 203.31,81.56 202.71,82.16 201.55,82.16 RV609.2 200.98,82.3 200.9,82.22 200.51,82.22 200.08,82.66 200.08,84.06 199.72,84.42 199.51,84.42 199.41,84.53 UV26.28
SW1_DP1_AUXP_C: length 4.4
  TOP w0.094: v2(248.79,20.37) 248.61,20.55 248.61,20.94 248.15,21.4 248.15,21.73 CV149.2
  BOTTOM w0.094: v2(248.79,20.37) 248.56,20.6 248.56,20.9 248.78,21.12 248.78,21.45 248.95,21.61 JNGFF1.14
SW1_DP1_CADET: length 3.5
  BOTTOM w0.102: UV26.33 197.45,82.3 197.68,82.06 197.68,81.57 v3(197.83,81.43) 197.83,80.16 RV607.2
SW1_DP1_HPD: length 128.5
  TOP w0.102: v2(243.39,49.61) 242.96,50.04 239.93,50.04 238.89,51.08 238.89,51.27 238.05,52.11 238.05,62.03 v2(238.5,62.49)
  BOTTOM w0.102: v2(238.5,62.49) 239.12,63.1 239.12,71.01 238.45,71.68 238.45,71.71 235.6,74.55 235.57,74.55 234.72,74.55 234.72,74.55 233.26,74.55 232.8,75.01 232.8,78.54 v3(231.85,79.5) 231.11,80.23 229.35,80.23 229.16,80.04 219.72,80.04 219.53,80.04 219.06,79.57 199.71,79.57 199.5,79.36 196.27,79.36 196.18,79.46 196.17,79.46 195.39,80.24 195.39,81.46 195.45,81.52 UV26.38 ; v2(243.39,49.61) 243.14,49.37 243.14,48.04 243.6,47.59 243.6,45.93 243.18,45.51 243.18,42.37 243.09,42.27 243.09,41.58 242.57,41.06 242.57,40.13 243.37,39.33 243.37,35.95 244.47,34.86 246.19,34.86 247.13,33.92 247.13,29.37 246.99,29.24 246.51,28.76 244.74,28.76 243.75,27.77 243.75,23.52 241.59,21.37 241.59,19.13 242.16,18.56 243.48,18.56 245.34,16.7 250.42,16.7 251.2,15.92 JNGFF1.23
SW1_DP1_N0: length 111.8
  TOP w0.094: v2(251.32,23.96) 251.33,23.96 251.59,23.7 251.59,23.13 251.45,23 CV156.1
  IN4 w0.089: v2(194.53,79.82) 194.28,79.57 194.28,79.45 195.84,77.89 206.06,77.89 206.06,77.89 207.58,77.89 208.3,78.6 229.19,78.6 234.71,73.08 234.71,70.69 234.84,70.56 234.84,63.54 236.48,61.9 236.48,57.55 236.9,57.14 236.9,55.43 236.1,54.63 236.1,52.31 233.11,49.32 233.11,45.29 233.3,45.1 233.45,44.96 233.87,44.54 233.87,42.19 236.91,39.15 237.61,39.15 240.6,36.16 240.6,35.95 240.6,34.1 243.86,30.83 243.86,28.97 244.09,28.74 244.09,27.8 248.37,23.52 251.5,23.52 251.57,23.59 251.57,23.71 v2(251.32,23.96)
  BOTTOM w0.094: UV26.39 195.05,82.38 194.92,82.26 194.92,81.55 194.13,80.76 194.13,80.23 194.53,79.83 v2(194.53,79.82)
SW1_DP1_N0_C: length 4.2
  TOP w0.094: v2(251.45,20.35) 251.63,20.54 251.63,21.01 251.51,21.13 251.51,21.73 CV156.2
  BOTTOM w0.094: JNGFF1.24 251.45,21.48 251.6,21.33 251.6,20.51 v2(251.45,20.35)
SW1_DP1_N1: length 110.2
  TOP w0.094: CV152.1 249.73,23.34 249.73,23.81 249.96,24.04 249.96,24.16 249.58,24.54 v2(249.54,24.54)
  IN4 w0.089: v2(196.46,81.18) 195.93,80.65 195.93,78.97 196.43,78.47 206.3,78.47 207.3,78.47 208.01,79.18 229.44,79.18 230.18,78.45 232,78.45 233.1,77.34 233.1,76.01 235.89,73.22 235.89,70.76 237.33,69.31 237.33,57.73 238.47,56.59 238.47,53.78 237.94,53.24 237.94,52.07 238.99,51.02 238.99,49.58 237.68,48.27 237.68,47.68 235.09,45.08 235.09,42.39 236.57,40.91 237.26,40.91 238.67,39.49 238.67,38.9 241.2,36.38 241.2,34.33 244.44,31.08 244.44,29.32 244.73,29.03 244.73,28.1 248.72,24.11 249.67,24.11 249.74,24.18 249.74,24.34 v2(249.54,24.54)
  BOTTOM w0.094: v2(196.46,81.18) 196.04,81.6 196.04,82.3 196.25,82.51 UV26.36
SW1_DP1_N1_C: length 4.3
  TOP w0.094: v2(249.9,20.37) 250.11,20.59 250.11,21.01 249.73,21.38 249.73,21.73 CV152.2
  BOTTOM w0.094: v2(249.9,20.37) 250.11,20.59 250.11,21.33 249.95,21.49 JNGFF1.18
SW1_DP1_N2: length 124.4
  TOP w0.094: v2(253.35,25.28) 253.45,25.28 253.58,25.15 253.58,24.56 253.78,24.36 253.78,21.92 253.18,21.32 253.18,19.41 252.49,18.72 250.84,18.72 249.94,17.82 249.94,15.77 CV148.1
  IN4 w0.089: v2(253.35,25.28) 253.4,25.28 253.72,24.96 253.72,24.81 253.48,24.57 252.39,24.57 252.08,24.88 251.14,24.88 250.3,25.71 249.57,25.71 246.82,28.46 246.1,28.46 245.29,29.27 245.29,31.8 241.89,35.2 241.89,38.17 239.29,40.77 238.48,40.77 237.77,41.48 237.61,41.48 236.81,41.48 235.7,42.59 235.7,44.88 238.26,47.44 238.26,47.7 238.26,47.7 238.26,47.85 238.26,47.85 238.26,47.96 239.57,49.27 239.57,51.27 238.52,52.33 238.52,52.9 239.05,53.44 239.05,56.83 238.52,57.36 238.52,57.36 237.91,57.97 237.91,69.6 236.51,71 236.51,73.41 233.7,76.23 233.7,77.59 232.26,79.02 230.42,79.02 229.66,79.78 207.75,79.78 207.01,79.04 206.54,79.04 197.02,79.04 196.74,79.32 196.74,79.46 v2(197.14,79.86)
  BOTTOM w0.094: UV26.34 197.05,82.38 196.84,82.18 196.84,81.85 197.27,81.43 197.27,80.75 196.93,80.41 196.93,80.07 v2(197.14,79.86)
SW1_DP1_N2_C: length 3.2
  TOP w0.094: CV148.2 249.94,14.16 249.94,13.48 v2(249.69,13.24)
  BOTTOM w0.094: v2(249.69,13.24) 249.85,13.4 249.85,13.78 249.7,13.93 JNGFF1.17
SW1_DP1_N3: length 124
  TOP w0.094: CV145.1 248.06,15.8 248.06,17.03 250.39,19.36 252.29,19.36 252.59,19.66 252.59,21.6 253,22 253,22.22 252.96,22.25 252.96,22.84 253,22.87 v4(253,23.84) 253,24.33 252.74,24.59 252.74,25.58 252.9,25.74 252.9,25.95 252.74,26.12 252.74,26.24 252.67,26.32 v2(252.51,26.32)
  IN4 w0.089: v2(252.51,26.32) 252.54,26.32 252.77,26.09 252.77,25.81 252.59,25.63 251.27,25.63 250.37,26.53 249.74,26.53 247.18,29.09 246.34,29.09 245.95,29.48 245.95,32.01 244.78,33.18 244.78,33.84 242.6,36.02 242.6,38.28 239.53,41.35 238.72,41.35 238,42.06 237.37,42.06 237.05,42.06 236.31,42.8 236.31,44.67 238.84,47.2 238.84,47.72 240.15,49.03 240.15,51.49 240.94,52.29 240.94,52.87 239.69,54.12 239.69,56.99 240.82,58.12 240.82,60.91 239.16,62.58 239.16,69.34 237.28,71.22 237.28,74.47 235.85,75.9 234.91,75.9 234.31,76.5 234.31,77.81 231.76,80.36 207.47,80.36 206.73,79.62 198.99,79.62 198.57,80.04 198.57,80.23 v2(198.87,80.54)
  BOTTOM w0.094: v2(198.87,80.54) 198.55,80.86 198.55,81.52 198.14,81.93 198.14,82.31 198.25,82.41 UV26.31
SW1_DP1_N3_C: length 3.4
  TOP w0.094: CV145.2 248.03,14.16 248.03,13.94 248.31,13.67 248.31,13.43 v2(248.12,13.24)
  BOTTOM w0.094: JNGFF1.11 248.2,13.93 248.35,13.78 248.35,13.47 v2(248.12,13.24)
SW1_DP1_P0: length 111.8
  TOP w0.094: v2(251.9,23.96) 251.78,23.83 251.78,23.27 CV157.1
  IN4 w0.089: v2(193.94,79.81) 194.09,79.66 194.09,79.37 195.76,77.71 205.99,77.71 207.66,77.71 208.37,78.42 229.11,78.42 234.52,73.01 234.52,70.62 234.66,70.48 234.66,63.46 236.3,61.82 236.3,57.48 236.72,57.06 236.72,55.51 235.91,54.7 235.91,52.38 232.93,49.4 232.93,45.22 233.23,44.92 233.37,44.78 233.68,44.46 233.68,42.11 236.83,38.97 237.53,38.97 240.41,36.09 240.41,36.03 240.41,35.88 240.41,35.88 240.41,34.02 243.68,30.76 243.68,28.89 243.91,28.66 243.91,27.72 248.3,23.34 251.57,23.34 251.75,23.52 251.75,23.8 v2(251.9,23.96)
  BOTTOM w0.094: UV26.40 194.65,82.51 194.73,82.43 194.73,81.63 193.94,80.84 v2(193.94,79.81)
SW1_DP1_P0_C: length 4.2
  TOP w0.094: CV157.2 251.7,21.73 251.7,21.21 251.83,21.09 251.83,20.58 v2(252.06,20.35)
  BOTTOM w0.094: JNGFF1.26 251.95,21.48 251.8,21.33 251.8,20.61 v2(252.06,20.35)
SW1_DP1_P1: length 110.2
  TOP w0.094: v2(250.15,24.54) 250.15,23.96 249.93,23.73 249.93,23.34 CV153.1
  IN4 w0.089: v2(195.87,81.18) 195.87,80.85 195.74,80.73 195.74,78.9 196.36,78.28 206.22,78.28 207.37,78.28 208.09,79 229.37,79 230.1,78.26 231.92,78.26 232.92,77.27 232.92,75.93 235.7,73.15 235.7,70.68 237.15,69.24 237.15,57.65 238.29,56.51 238.29,53.85 237.76,53.32 237.76,52 238.81,50.94 238.81,49.66 237.5,48.35 237.5,47.76 234.91,45.16 234.91,42.31 236.49,40.72 237.18,40.72 238.49,39.42 238.49,38.83 241.02,36.3 241.02,34.25 244.26,31 244.26,29.24 244.55,28.95 244.55,28.02 248.64,23.93 249.74,23.93 249.93,24.11 249.93,24.32 v2(250.15,24.54)
  BOTTOM w0.094: v2(195.87,81.18) 195.85,81.2 UV26.37
SW1_DP1_P1_C: length 4.2
  TOP w0.094: v2(250.48,20.37) 250.3,20.55 250.3,21.09 249.93,21.46 249.93,21.73 CV153.2
  BOTTOM w0.094: JNGFF1.20 250.45,21.51 250.3,21.37 250.3,20.55 v2(250.48,20.37)
SW1_DP1_P2: length 124.5
  TOP w0.094: v2(253.99,25.28) 253.77,25.07 253.77,24.64 253.98,24.44 253.98,21.84 253.38,21.24 253.38,19.33 252.57,18.53 250.92,18.53 250.13,17.74 250.13,15.77 CV147.1
  IN4 w0.089: v2(253.99,25.28) 253.9,25.19 253.9,24.73 253.56,24.39 252.31,24.39 252.01,24.69 251.06,24.69 250.23,25.52 249.49,25.52 246.74,28.28 246.02,28.28 245.11,29.19 245.11,31.72 241.71,35.12 241.71,38.09 239.21,40.59 238.4,40.59 237.69,41.3 237.69,41.3 236.73,41.3 235.52,42.52 235.52,44.95 238.08,47.52 238.08,47.63 238.08,48.04 239.39,49.35 239.39,51.2 238.33,52.25 238.33,52.98 238.87,53.51 238.87,56.75 238.34,57.28 238.34,57.28 237.73,57.9 237.73,69.52 236.33,70.92 236.33,73.34 233.51,76.15 233.51,77.51 232.18,78.84 230.34,78.84 229.58,79.6 207.83,79.6 207.09,78.86 206.46,78.86 196.94,78.86 196.56,79.25 v2(196.56,79.86)
  BOTTOM w0.094: UV26.35 196.65,81.77 197.08,81.35 197.08,80.83 196.73,80.49 196.73,80.04 v2(196.56,79.86)
SW1_DP1_P2_C: length 3.2
  TOP w0.094: CV147.2 250.13,14.16 250.13,13.41 v2(250.3,13.24)
  BOTTOM w0.094: JNGFF1.19 250.2,13.93 250.05,13.78 250.05,13.49 v2(250.3,13.24)
SW1_DP1_P3: length 124.1
  TOP w0.094: v2(253.15,26.29) 253.1,26.24 253.1,25.66 252.93,25.5 252.93,24.67 253.19,24.41 253.19,24.17 253.22,24.14 253.22,23.54 253.19,23.51 v4(253.19,22.55) 253.19,21.92 252.78,21.52 252.78,19.58 252.37,19.17 250.47,19.17 248.25,16.95 248.25,15.75 CV146.1
  IN4 w0.089: v2(253.15,26.29) 252.95,26.09 252.95,25.73 252.67,25.45 251.19,25.45 250.3,26.35 249.66,26.35 247.1,28.91 246.27,28.91 245.77,29.41 245.77,31.93 244.6,33.1 244.6,33.76 242.41,35.95 242.41,38.21 239.45,41.17 238.64,41.17 237.93,41.88 237.45,41.88 236.97,41.88 236.13,42.72 236.13,44.75 238.65,47.28 238.65,47.8 239.96,49.11 239.96,51.57 240.76,52.36 240.76,52.79 239.51,54.04 239.51,57.06 240.64,58.2 240.64,60.83 238.97,62.5 238.97,69.26 237.1,71.14 237.1,74.39 235.77,75.72 234.83,75.72 234.13,76.42 234.13,77.74 231.69,80.18 207.54,80.18 206.8,79.44 198.91,79.44 198.39,79.96 198.39,80.42 v2(198.27,80.54)
  BOTTOM w0.094: v2(198.27,80.54) 198.36,80.64 198.36,81.44 197.95,81.85 197.95,82.31 197.85,82.41 UV26.32
SW1_DP1_P3_C: length 3.4
  TOP w0.094: v2(248.73,13.24) 248.5,13.47 248.5,13.75 248.22,14.02 248.22,14.16 CV146.2
  BOTTOM w0.094: JNGFF1.13 248.7,13.93 248.55,13.78 248.55,13.42 v2(248.73,13.24)
SW1_PS8338_CFG0: length 3.3
  BOTTOM w0.102: UV26.59 189.56,86.93 189.27,87.22 189.27,87.9 188.57,88.6 RV601.2
SW1_PS8338_P0: length 3.9
  BOTTOM w0.102: UV26.60 189.5,87.79 189.5,88.23 v3(188.79,88.94) 188.12,89.62 RV615.2
SW1_PS8338_P1: length 6.3
  BOTTOM w0.102: RV603.2 RV621.1 187.41,91.52 v3(188.3,90.64) 189.78,89.15 189.78,88.23 190,88.01 UV26.1
SW1_PS8338_PC10: length 6.4
  BOTTOM w0.102: UV26.56 189.34,85.73 188.69,86.37 188.69,87.01 v3(188.81,87.14) 188.86,87.18 188.86,87.79 188.56,88.09 187.39,88.09 RV620.1 186.51,87.56 186.19,87.88 RV614.2
SW1_PS8338_PC11: length 4.7
  BOTTOM w0.102: RV613.2 186.51,86.67 RV619.1 187.32,86.21 188.52,86.21 189.41,85.33 UV26.55
SW1_PS8338_PC20: length 4.8
  BOTTOM w0.102: RV612.2 186.51,85.53 RV618.1 187.32,85.99 188.15,85.99 v3(188.76,85.38) 189.21,84.93 UV26.54
SW1_PS8338_PC21: length 5
  BOTTOM w0.102: RV611.2 186.51,84.64 RV617.1 187.87,83.63 v3(188.57,83.63) 189.46,84.53 UV26.53
SW1_PS8338_PEQ: length 6.4
  BOTTOM w0.102: UV26.8 193.45,89.66 RV616.1 192.22,90.89 192.22,92.2 v3(191.9,92.51) RV610.2
SW1_PS8338_SW: length 5.9
  BOTTOM w0.102: QV11.1 200.94,90.65 200.7,90.4 199.86,90.4 RV602.2 199.78,90.33 199.78,89.75 v3(199.51,89.47) 199.17,89.47 199.05,89.59 198.54,89.59 197.45,88.5 UV26.18
SW2_VGA1_BLUE: length 5.2
  TOP w0.102: v2(235.11,94.01) 235.01,93.9 UV16.22
  BOTTOM w0.102: v2(235.11,94.01) 235.51,93.62 v3(235.96,93.62) 236.24,93.62 236.71,94.08 RV34.1 CV53.1 236.92,95.65 LV18.1
SW2_VGA1_GREEN: length 4.8
  TOP w0.102: v3(233.34,94.61) 233.54,94.41 v2(233.54,94.03) 233.81,93.76 UV16.25
  BOTTOM w0.102: LV17.1 234.38,96.1 234.3,96.02 CV52.1 RV33.1 233.8,94.67 233.54,94.42 v2(233.54,94.03)
SW2_VGA1_HSYNC: length 7.8
  TOP w0.102: UV16.20 235.81,93.68 236.03,93.91 236.12,93.91 236.85,94.64 v2(238.24,94.64)
  BOTTOM w0.102: LV19.1 240.05,97.78 v3(239.07,96.8) 239.07,95.47 238.25,94.64 v2(238.24,94.64)
SW2_VGA1_RED: length 5
  TOP w0.102: v3(231.59,94.33) 231.98,93.93 v2(232.31,93.93) 232.61,93.63 232.96,93.63 233.01,93.58 UV16.27
  BOTTOM w0.102: v2(232.31,93.93) 232.3,93.94 232.3,94.18 RV32.1 CV51.1 232.8,95.99 232.72,96.07 LV16.1
SW2_VGA1_SCL: length 20
  TOP w0.102: UV16.14 238.8,91.63 v2(238.94,91.77)
  IN2 w0.122: v2(238.94,91.77) 238.94,92.18 239.68,92.91 240.63,92.91 241.67,93.96 241.67,98.18 243.85,100.36 v2(243.85,101.38)
  BOTTOM w0.102: v2(243.85,101.38) 244.8,102.33 245.9,102.33 246.24,102.67 RV36.2 246.24,103.68 JCRT1.15
SW2_VGA1_SDA: length 20.6
  TOP w0.102: UV16.12 238.82,90.83 v2(238.9,90.91)
  IN2 w0.122: v2(238.9,90.91) 238.44,91.37 238.44,92.39 239.47,93.41 240.42,93.41 241.17,94.17 241.17,96.21 236.13,101.25 v2(235.98,101.25)
  BOTTOM w0.102: JCRT1.12 237.27,105.72 RV35.2 237.27,102.9 237.02,102.65 236.53,102.65 235.98,102.1 v2(235.98,101.25)
SW2_VGA1_VSYNC: length 9
  TOP w0.102: v2(239.58,94.64) 238.95,94.01 236.84,94.01 236.61,93.78 UV16.18
  BOTTOM w0.102: LV20.1 242.02,97.97 240.42,96.37 v3(240.42,95.48) v2(239.58,94.64)
SW2_VGA2_BLUE: length 104.7
  TOP w0.102: v2(235.93,94.28) 235.41,93.76 UV16.21
  IN2 w0.122: v2(235.93,94.28) 235.88,94.28 232.88,97.28 229.43,97.28 228.9,96.75 225.3,96.75 224.77,97.28 220.56,97.28 219.7,98.13 217.56,98.13 217.44,98.02 208.17,98.02 202.46,92.32 192.01,92.32 186.48,97.84 183.12,97.84 v2(182.84,98.12)
  BOTTOM w0.102: v2(182.84,98.12) 182.84,96.34 181.31,94.82 178.12,94.82 177.31,95.62 173.06,95.62 v3(172.89,95.79) 167.76,95.79 166.96,95 152.87,95 151.69,96.18 149.4,96.18 148.6,96.99 148.14,96.99 145.5,99.62 JDOCK1.45
SW2_VGA2_GREEN: length 95.2
  TOP w0.102: v2(234.12,94.03) 234.21,93.95 UV16.24
  IN2 w0.122: v2(234.12,94.03) 234.12,94.04 232.55,95.61 228.6,95.61 228.41,95.42 226.84,95.42 226.32,95.93 224.87,95.93 224.56,96.23 220.83,96.23 220.78,96.29 210.39,96.29 210.01,95.9 207,95.9 202.78,91.69 191.75,91.69 186.22,97.21 182.86,97.21 181.32,98.75 179.15,98.75 v2(178.52,98.12)
  BOTTOM w0.102: JDOCK1.59 150,98.42 150.34,98.08 150.83,97.59 152.07,97.59 153.45,96.22 166.35,96.22 167.16,97.02 v3(168.49,97.02) 177.5,97.02 178.52,98.05 v2(178.52,98.12)
SW2_VGA2_HSYNC: length 103.1
  TOP w0.102: UV16.19 236.21,93.68 236.77,94.24 238.47,94.24 v2(238.9,94.67)
  IN2 w0.122: v2(238.9,94.67) 236.55,92.32 229.49,92.32 228.7,93.11 224.29,93.11 223.85,93.55 217.67,93.55 217.47,93.76 213.76,93.76 213.14,93.15 213.14,90.1 212.16,89.12 199.27,89.12 198.89,88.74 198.54,88.74 197.76,89.52 192.24,89.52 191.51,89.52 190.77,89.52 189.55,90.74 188.84,90.74 184.51,95.07 181.97,95.07 180.43,96.61 177.9,96.61 176.62,97.89 v2(176.62,98.05)
  BOTTOM w0.102: v2(176.62,98.05) 176.46,97.89 166.8,97.89 166,97.08 v3(165.67,97.08) 153.82,97.08 151.5,99.4 JDOCK1.65
SW2_VGA2_RED: length 96.2
  TOP w0.102: v2(232.91,94.01) 233.41,93.51 UV16.26
  IN2 w0.122: v2(232.91,94.01) 232.91,94.06 232.34,94.62 224.97,94.62 223.99,95.6 220.58,95.6 220.47,95.49 210.74,95.49 209.84,94.59 208.63,94.59 208.42,94.8 207.17,94.8 205.88,93.51 205.88,92.38 204.56,91.06 192.62,91.06 192.1,91.06 191.4,91.06 190.2,92.26 189.78,92.26 185.45,96.58 182.6,96.58 181.06,98.12 v2(179.67,98.12)
  BOTTOM w0.102: JDOCK1.53 148.5,98.54 150.24,96.8 151.93,96.8 153.12,95.61 166.61,95.61 167.41,96.41 v3(170.75,96.41) 177.96,96.41 v2(179.67,98.12)
SW2_VGA2_SCL: length 121.1
  TOP w0.102: UV16.15 238.59,92.03 238.77,92.21 239.18,92.21 239.38,92 239.38,91.75 239.67,91.46 240.69,91.46 241.41,92.18 241.41,93.08 v3(241.41,95.11) 241.41,95.35 236.53,100.23 235.57,100.23 235.22,100.57 229.65,100.57 228.23,99.15 225.28,99.15 224.2,100.23 212.28,100.23 211.56,99.52 210.05,99.52 209.68,99.15 209.4,99.15 209,98.75 206.23,98.75 201.62,94.14 192.38,94.14 189.39,97.13 176.19,97.13 175.23,98.1 173.93,98.1 171.25,100.78 168.86,100.78 167.45,102.19 167.45,102.45 166.75,103.14 165.15,103.14 164.61,103.69 160.7,103.69 160.02,103.01 158.19,103.01 157.51,103.69 155.91,103.69 155.4,103.69 155.11,103.97 154.76,103.97 153.5,105.23 153.5,106.45 152.64,107.32 152.64,109.91 v2(152.49,110.06)
  BOTTOM w0.102: v2(152.49,110.06) 152.49,110.65 151.86,111.28 146.52,111.28 146.24,111.01 146.24,110.11 146,109.87 JDOCK1.48
SW2_VGA2_SDA: length 123.1
  TOP w0.102: v2(153.12,110.06) 153.12,107.52 153.99,106.65 153.99,105.43 154.96,104.46 155.31,104.46 155.6,104.17 155.71,104.17 155.71,104.17 157.71,104.17 158.39,103.49 159.82,103.49 160.5,104.17 164.81,104.17 165.35,103.62 166.95,103.62 167.93,102.65 167.93,102.39 169.06,101.26 171.45,101.26 174.13,98.58 175.43,98.58 176.39,97.62 189.59,97.62 192.58,94.62 201.42,94.62 206.03,99.23 208.8,99.23 209.2,99.63 209.48,99.63 209.85,100 211.36,100 212.08,100.71 224.4,100.71 225.48,99.63 228.03,99.63 229.45,101.06 235.42,101.06 235.77,100.71 236.73,100.71 241.9,95.55 v3(241.9,93.08) 241.9,91.98 240.89,90.97 239.44,90.97 239.09,91.32 238.71,91.32 238.62,91.23 UV16.13
  BOTTOM w0.102: JDOCK1.46 145.5,110.06 145.76,110.31 145.76,111.21 146.32,111.76 152.06,111.76 152.97,110.85 152.97,110.34 153.12,110.19 v2(153.12,110.06)
SW2_VGA2_VSYNC: length 103.5
  TOP w0.102: v2(240.22,94.59) 240.11,94.59 239.3,93.78 237.12,93.78 237.01,93.67 UV16.17
  IN2 w0.122: v2(177.41,98.15) 177.41,97.99 178.16,97.24 180.69,97.24 182.23,95.7 184.77,95.7 189.1,91.37 189.84,91.37 191.04,90.17 192.46,90.17 192.98,90.17 192.99,90.17 204.92,90.17 206.82,92.07 206.82,93.2 207.53,93.92 208.06,93.92 208.87,93.1 210.54,93.1 212,94.56 218.1,94.56 218.45,94.2 219.91,94.2 220.32,94.61 223.69,94.61 224.56,93.74 231.75,93.74 232.54,92.95 235.95,92.95 238.35,95.34 239.48,95.34 240.22,94.6 v2(240.22,94.59)
  BOTTOM w0.102: JDOCK1.67 152,99.89 154.2,97.69 v3(163.85,97.69) 165.74,97.69 166.55,98.5 175.59,98.5 175.75,98.66 176.37,98.66 176.9,98.66 v2(177.41,98.15)
SW_1.2V: length 7.5
  IN1 w1.016: 81.75,54.55 81.77,54.54 86.47,54.54 88.07,52.94 88.58,52.94
  vias: v2(80.86,55.45) v2(80.86,54.77) v2(89.52,53.06) v2(90.13,53.06)
SW_+1VALWP:
  vias: v2(222.19,53.45) v2(222.19,52.84) v3(222.75,52.9)
SW_LAN0_10_GRN#: length 15.2
  TOP w0.102: UL4.41 274.89,83.56 275.97,84.64 v3(276.84,84.64) 282.63,84.64 283.1,84.17 283.1,83.2 282.84,82.94 282.84,81.02 v2(282.95,80.91)
  BOTTOM w0.102: RL30.2 284.21,79.43 283.33,80.31 QL2.1 282.93,80.89 v2(282.95,80.91)
SW_LAN0_100_ORG#: length 17.9
  TOP w0.102: v2(282.05,77.65) 280.35,75.95 280.35,74.1 279.54,73.28 277.82,73.28 277.4,72.86 277.4,72.25 275.74,70.59 v3(274.46,70.59) 273.97,70.59 273.5,71.06 273.5,72.42 273.82,72.75 RL29.2 274.39,72.89 UL4.18
  BOTTOM w0.102: v2(282.05,77.65) 282.15,77.75 QL1.4
SW_LAN0_ACTLED_YEL#: length 12.1
  TOP w0.102: UL4.17 272.85,74.72 272.68,74.55 272.68,74.17 273.29,73.56 v2(273.29,72.85)
  BOTTOM w0.102: QL1.1 281.03,76.3 279.7,74.97 275.41,74.97 v2(273.29,72.85)
SW_LAN0_MDIN0: length 22.3
  TOP w0.094: UL4.25 277.38,76.22 277.5,76.11 278.39,76.11 278.54,76.25 279.23,76.25 279.34,76.37 v2(279.34,76.65)
  BOTTOM w0.094: TL1.11 267.29,85.24 266.8,84.75 266.8,83.59 267.44,82.96 269.45,82.96 269.99,82.41 269.99,80.61 v4(270.73,79.87) 272.49,78.11 275.87,78.11 277.75,76.23 279.15,76.23 279.34,76.42 v2(279.34,76.65)
SW_LAN0_MDIN1: length 16.1
  TOP w0.094: v2(279.51,78.49) 279.51,78.37 279.3,78.16 277.53,78.16 277.47,78.22 UL4.29
  BOTTOM w0.094: TL1.7 272.37,85.49 271.9,85.02 271.9,84.74 272.06,84.59 272.99,84.59 273.5,84.08 273.5,83.69 274.25,82.95 v4(274.25,81.37) 274.25,80.88 275.96,79.16 276.75,79.16 277.7,78.21 279.44,78.21 279.51,78.29 v2(279.51,78.49)
SW_LAN0_MDIN2: length 10.1
  TOP w0.094: v2(278.04,80.89) 278.04,80.74 277.91,80.61 277.52,80.61 277.4,80.72 UL4.34
  BOTTOM w0.094: TL1.5 274.91,85.43 274.4,84.92 274.4,84.55 274.91,84.04 276.71,84.04 277.31,83.44 v4(277.31,81.17) 277.31,80.72 277.49,80.53 277.94,80.53 278.04,80.64 v2(278.04,80.89)
SW_LAN0_MDIN3: length 10.6
  TOP w0.094: UL4.38 277.55,82.72 277.61,82.67 280.71,82.67 281.14,82.24 281.14,81.61 v2(281.16,81.59)
  BOTTOM w0.094: v2(281.16,81.59) 281.14,81.61 281.14,81.99 280.73,82.4 280.41,82.4 280.33,82.48 v4(280.33,83.98) 280.33,84.28 280.03,84.58 279.68,84.58 279.58,84.68 279.58,84.88 279.99,85.3 TL1.1
SW_LAN0_MDIP0: length 22.2
  TOP w0.094: UL4.24 278.55,75.72 278.7,75.87 v2(279.36,75.87)
  BOTTOM w0.094: v2(279.36,75.87) 279.34,75.85 277.59,75.85 275.71,77.73 272.34,77.73 269.61,80.45 v4(269.61,81.25) 269.61,82.25 269.29,82.57 267.28,82.57 266.42,83.43 266.42,84.8 266.02,85.2 TL1.12
SW_LAN0_MDIP1: length 16.2
  TOP w0.094: UL4.28 277.51,77.72 277.56,77.78 v2(279.46,77.78)
  BOTTOM w0.094: TL1.8 271.1,85.35 271.52,84.93 271.52,84.59 271.9,84.21 272.83,84.21 273.12,83.92 273.12,83.54 273.87,82.79 273.87,80.72 v4(274.87,79.72) 275.8,78.78 276.59,78.78 277.55,77.83 279.41,77.83 v2(279.46,77.78)
SW_LAN0_MDIP2: length 10.1
  TOP w0.094: v2(278.03,80.13) 277.93,80.22 UL4.33
  BOTTOM w0.094: TL1.6 273.64,85.33 274.02,84.96 274.02,84.39 274.75,83.66 276.55,83.66 276.93,83.28 v4(276.93,82.52) 276.93,80.56 277.33,80.15 278,80.15 278,80.16 v2(278.03,80.13)
SW_LAN0_MDIP3: length 10.5
  TOP w0.094: v2(280.4,81.61) 280.7,81.61 280.76,81.68 280.76,82.08 280.56,82.28 277.61,82.28 277.55,82.22 UL4.37
  BOTTOM w0.094: v2(280.4,81.61) 280.7,81.61 280.76,81.68 280.76,81.83 280.57,82.02 280.25,82.02 279.95,82.32 v4(279.95,82.76) 279.95,84.12 279.87,84.2 279.52,84.2 279.2,84.52 279.2,84.81 278.72,85.28 TL1.2
SW_LAN1_10_GRN#: length 198.9
  TOP w0.102: UL4.40 275.39,83.6 275.71,83.91 276.7,83.91 276.97,83.64 278.88,83.64 279.43,84.19 281.31,84.19 282.45,83.05 282.45,80.15 v2(282.13,79.84)
  IN1 w0.089: v2(248.68,91.58) 248.89,91.58 249.28,91.18 249.96,91.18 251.01,90.13 251.98,90.13 252.62,90.77 252.92,90.77 253.69,90.01 253.69,87.77 253.88,87.58 258.92,87.58 259.17,87.33 260.4,87.33 261,86.73 261,86.05 262.73,84.33 264.14,84.33 265.21,83.25 265.21,81.28 269.33,77.17 271.72,77.17 274.31,74.58 275.08,74.58 275.5,74.16 276.91,74.16 277.21,73.86 278.41,73.86 278.53,73.98 280.15,73.98 280.34,74.17 280.34,75.01 280.72,75.39 280.72,78.43 v2(282.13,79.84)
  IN3 w0.122: v2(135.32,99.24) 137.21,101.13 140.87,101.13 145.75,106.02 148.9,106.02 149.35,106.47 160.55,106.47 162.27,104.75 163.49,104.75 165.19,103.05 165.19,101.65 166.17,100.68 171.02,100.68 175.43,96.27 188.42,96.27 192.36,92.32 200.12,92.32 200.95,93.15 202.02,93.15 208.29,99.42 208.29,100.58 209.54,101.83 213.76,101.83 214.63,102.7 227.22,102.7 229.09,100.83 232.04,100.83 232.54,100.33 243.14,100.33 243.89,99.58 244.95,99.58 245.4,99.13 248.18,96.35 248.18,95.94 248.18,93.03 248.7,92.51 248.7,91.6 v2(248.68,91.58)
  BOTTOM w0.102: JDOCK1.3 135,99.86 135.32,99.54 v2(135.32,99.24) 135.02,99.24 134.53,98.76 v3(134.53,98.27)
SW_LAN1_100_ORG#: length 177.9
  TOP w0.102: v2(274.99,72.65) 275.35,73 275.35,73.55 275.39,73.59 UL4.20
  IN2 w0.122: v2(274.99,72.65) 274.74,72.65 272.59,74.8 271.39,74.8 270.6,75.59 270.6,84.61 268.11,87.1 268.11,89.56 263.5,94.18 263.5,94.89 260.89,97.49 257.29,97.49 249.86,104.92 231.72,104.92 229.85,103.04 207.96,103.04 200.97,96.05 193.52,96.05 187.99,101.59 185.42,101.59 181.81,105.2 181.81,109.38 181.47,109.73 179.4,111.79 179.2,111.79 178.89,111.79 178.14,111.79 177.93,111.79 151.79,111.79 135.5,111.79 v2(134.73,111.03)
  BOTTOM w0.102: JDOCK1.4 135,110.76 v2(134.73,111.03)
SW_LAN1_ACTLED_YEL#: length 165.9
  TOP w0.102: UL4.19 274.89,73.28 v2(274.94,73.23) ; v2(247.97,101.86) 247.92,101.81 246.44,101.81 245.52,102.73 225.69,102.73 225.09,102.14 218.79,102.14 217.82,103.11 217.82,104.36 216.29,105.89 216.29,108.76 214.94,110.11 209.75,110.11 206.18,106.55 206.18,101.09 200.92,95.83 193.27,95.83 189.24,99.86 184.06,99.86 181.11,102.8 181.11,107.94 178.08,110.98 164.32,110.98 v3(163.95,110.6) 161.76,108.41 v2(161.76,107.36)
  IN2 w0.122: v2(247.97,101.86) 248.16,102.05 248.16,102.06 248.4,102.3 252.13,102.3 257.19,97.24 260.79,97.24 263.19,94.84 263.19,92.85 264.81,91.22 265.44,91.22 267.71,88.95 267.71,86.83 270.17,84.38 270.17,75.64 271.3,74.51 272.35,74.51 273.99,72.87 273.99,72.13 274.48,71.65 275.23,71.65 275.47,71.89 275.47,72.76 275,73.23 v2(274.94,73.23)
  BOTTOM w0.102: JDOCK1.100 161,107.96 161.59,107.36 v2(161.76,107.36)
SW_LAN1_MDIN0: length 150.8
  TOP w0.094: UL4.23 278.03,75.22 278.15,75.35 278.83,75.35 279.23,74.95 279.23,74.55 v2(279.31,74.48)
  IN1 w0.081: v2(163.13,105.9) 163.13,104.55 163.79,103.89 163.79,101.53 164.96,100.36 169.79,100.36 173.53,96.62 189.43,96.62 192.5,93.55 201,93.55 202.06,93.55 206.96,98.45 224.01,98.45 224.77,99.21 249.07,99.21 250.38,100.52 252.75,100.52 255.66,97.61 257.38,97.61 258.05,96.95 260.52,96.95 261.48,95.99 261.48,91.87 261.86,91.49 261.86,90.43 263.03,89.26 263.03,88.7 262.44,88.12 262.44,85.81 263.08,85.17 264.55,85.17 266.06,83.67 266.06,81.64 269.66,78.03 275.77,78.03 278.18,75.62 278.77,75.62 279.31,75.08 v2(279.31,74.48)
  BOTTOM w0.094: v2(163.13,105.9) 163.13,106.63 162.62,107.14 162.62,107.69 162.5,107.82 JDOCK1.106
SW_LAN1_MDIN1: length 145
  TOP w0.094: UL4.27 277.35,77.22 277.47,77.11 278.15,77.11 v2(278.4,77.35)
  IN1 w0.081: v2(164.6,105.9) 164.27,105.56 164.27,105.24 165.39,104.12 165.39,101.86 166.03,101.22 170.14,101.22 173.91,97.46 189.78,97.46 192.85,94.39 193.55,94.39 201.71,94.39 206.74,99.42 222.06,99.42 223.45,100.81 246.22,100.81 246.96,100.08 248.72,100.08 250.02,101.37 253.09,101.37 256.01,98.45 257.73,98.45 258.39,97.79 260.87,97.79 262.32,96.34 262.32,92.25 262.83,91.74 262.83,90.66 264.56,88.93 266.15,88.93 266.66,88.41 266.66,84.46 266.92,84.21 266.92,83.58 268.85,81.65 273.35,81.65 277.96,77.04 278.09,77.04 v2(278.4,77.35)
  BOTTOM w0.094: JDOCK1.112 164,107.85 163.97,107.82 163.97,107.15 164.45,106.67 164.45,106.05 v2(164.6,105.9)
SW_LAN1_MDIN2: length 142.9
  TOP w0.094: UL4.32 277.64,79.72 277.71,79.66 277.76,79.66 278.12,79.66 278.56,79.22 278.82,79.22 v2(279.03,79.43)
  IN1 w0.081: v2(166.43,105.13) 166.18,104.88 166.18,104.75 167.9,103.02 169.53,103.02 173.62,98.93 189.57,98.93 193.28,95.23 201.36,95.23 207.33,101.19 211.55,101.19 212.33,100.41 221.45,100.41 223.21,102.18 246.18,102.18 246.95,101.4 248.72,101.4 249.56,102.24 253.42,102.24 256.36,99.29 258.08,99.29 258.74,98.63 261.38,98.63 263.44,96.57 263.44,92.32 264.58,91.18 264.58,90.68 265.46,89.79 266.53,89.79 267.53,88.8 267.53,85.48 270.5,82.51 276.05,82.51 277.05,81.51 277.05,80.5 278.46,79.09 278.64,79.09 278.98,79.43 v2(279.03,79.43)
  BOTTOM w0.094: JDOCK1.124 167,107.71 166.95,107.66 166.95,106.95 166.36,106.35 166.36,105.21 v2(166.43,105.13)
SW_LAN1_MDIN3: length 141.9
  TOP w0.094: UL4.36 277.47,81.72 277.54,81.65 279.67,81.65 280,81.33 v2(280,80.83)
  IN1 w0.081: v2(168.16,106.63) 168.16,105.92 167.8,105.56 167.8,104.45 168.37,103.89 169.86,103.89 173.98,99.78 189.92,99.78 193.63,96.07 201.01,96.07 207.13,102.19 221.64,102.19 222.58,103.13 253.72,103.13 256.71,100.14 261.14,100.14 264.35,96.92 264.35,93.35 268.42,89.28 268.42,86.08 269.15,85.35 278.44,85.35 280,83.79 v2(280,80.83)
  BOTTOM w0.094: v2(168.16,106.63) 168.16,107.11 168.44,107.39 168.44,107.6 168.5,107.66 JDOCK1.130
SW_LAN1_MDIP0: length 150.8
  TOP w0.094: v2(278.7,74.48) 278.85,74.63 278.85,74.79 278.67,74.97 278.31,74.97 278.18,74.84 277.7,74.84 277.58,74.72 UL4.22
  IN1 w0.081: v2(162.52,105.9) 162.88,105.54 162.88,104.45 163.54,103.79 163.54,101.42 164.86,100.11 169.68,100.11 173.42,96.37 189.33,96.37 192.4,93.3 201.1,93.3 202.16,93.3 207.07,98.2 224.12,98.2 224.88,98.96 249.18,98.96 250.49,100.27 252.65,100.27 255.56,97.36 257.28,97.36 257.94,96.7 260.42,96.7 261.23,95.89 261.23,91.76 261.61,91.38 261.61,90.33 262.78,89.16 262.78,88.8 262.19,88.22 262.19,85.7 262.98,84.92 264.45,84.92 265.8,83.56 265.8,81.53 269.56,77.78 275.67,77.78 278.08,75.37 278.66,75.37 279.06,74.97 279.06,74.83 278.95,74.73 278.78,74.73 278.7,74.65 v2(278.7,74.48)
  BOTTOM w0.094: JDOCK1.104 162,107.78 162.24,107.54 162.24,106.98 162.75,106.48 162.75,106.13 v2(162.52,105.9)
SW_LAN1_MDIP1: length 145
  TOP w0.094: UL4.26 278.36,76.72 v2(278.4,76.76)
  IN1 w0.081: v2(164.02,105.9) 164.02,105.13 165.14,104.01 165.14,101.75 165.92,100.97 170.04,100.97 173.8,97.21 189.68,97.21 192.75,94.14 193.66,94.14 201.81,94.14 206.84,99.17 222.16,99.17 223.56,100.56 246.12,100.56 246.85,99.83 248.83,99.83 250.12,101.12 252.99,101.12 255.91,98.2 257.63,98.2 258.29,97.54 260.77,97.54 262.07,96.23 262.07,92.14 262.57,91.64 262.57,90.76 262.57,90.76 262.57,90.55 264.45,88.67 264.66,88.67 264.66,88.68 266.04,88.68 266.41,88.31 266.41,84.36 266.67,84.1 266.67,83.48 268.75,81.4 273.24,81.4 277.88,76.76 v2(278.4,76.76)
  BOTTOM w0.094: v2(164.02,105.9) 164.07,105.94 164.07,106.51 163.59,106.99 163.59,107.73 163.5,107.81 JDOCK1.110
SW_LAN1_MDIP2: length 143
  TOP w0.094: UL4.31 277.4,79.22 277.46,79.28 277.91,79.28 277.96,79.28 278.4,78.84 v2(278.99,78.84)
  IN1 w0.081: v2(278.99,78.84) 278.35,78.84 276.8,80.39 276.8,81.41 275.94,82.26 270.39,82.26 267.27,85.38 267.27,88.69 266.43,89.54 265.36,89.54 264.32,90.57 264.32,91.08 263.19,92.22 263.19,96.47 261.27,98.38 258.64,98.38 257.97,99.04 256.26,99.04 253.31,101.99 249.66,101.99 248.83,101.15 246.85,101.15 246.07,101.92 223.32,101.92 221.55,100.16 212.23,100.16 211.44,100.94 207.43,100.94 201.47,94.98 193.17,94.98 189.47,98.68 173.52,98.68 169.43,102.77 167.79,102.77 165.92,104.64 165.92,105.06 v2(165.85,105.13)
  BOTTOM w0.094: JDOCK1.122 166.5,107.73 166.57,107.66 166.57,107.11 165.98,106.51 165.98,105.26 v2(165.85,105.13)
SW_LAN1_MDIP3: length 141.9
  TOP w0.094: UL4.35 277.46,81.22 277.5,81.27 279.51,81.27 279.61,81.17 279.61,80.98 279.49,80.85 v2(279.31,80.85)
  IN1 w0.081: v2(279.31,80.85) 279.44,80.85 279.74,81.16 279.74,83.69 278.34,85.09 269.04,85.09 268.16,85.97 268.16,89.18 264.1,93.24 264.1,96.82 261.03,99.88 256.61,99.88 253.62,102.87 222.68,102.87 221.74,101.93 207.23,101.93 201.12,95.82 193.52,95.82 189.82,99.52 173.87,99.52 169.76,103.64 168.26,103.64 167.55,104.35 167.55,105.67 167.91,106.03 167.91,106.3 v2(167.58,106.63)
  BOTTOM w0.094: JDOCK1.128 168,107.75 168.06,107.69 168.06,107.55 167.78,107.27 167.78,106.84 v2(167.58,106.63)
SW_USB20_N1: length 9.5
  TOP w0.094: v2(283.99,68.57) 284.35,68.21 284.35,67.86 284.83,67.38 285.9,67.38 286.47,66.81 286.47,66.39 286.57,66.28 v4(286.57,65.12) 286.57,64.05 286.42,63.89 286.37,63.89 286,63.52 285.51,63.52 285.41,63.63 285.41,63.71 285.28,63.83 UI3.11
  BOTTOM w0.094: LI7.1 284.06,68 284.21,68.15 284.21,68.34 v2(283.99,68.57)
SW_USB20_P1: length 9.6
  TOP w0.094: v2(284.62,68.54) 284.54,68.46 284.54,67.94 284.91,67.57 285.98,67.57 286.66,66.89 286.66,66.47 286.77,66.36 286.77,65.43 286.8,65.4 286.8,64.83 286.77,64.8 286.77,63.97 v4(286.32,63.52) 286.13,63.33 UI3.10
  BOTTOM w0.094: LI7.4 284.56,68 284.41,68.16 284.41,68.33 v2(284.62,68.54)
SYS_LED_MASK#: length 63.2
  TOP w0.102: UE1.B48 252.14,78.61 v2(251.95,78.79) ; v2(254.39,76.74) 254.39,75.65 255.46,74.58 RE21.2 ; v2(284.21,77.52) 284.7,77.04 v2(284.7,70.64) 284.7,70.59 286.19,69.1 287.04,69.1 287.54,68.6 287.54,67.83 288.81,66.56 UZ10.1
  BOTTOM w0.102: v2(254.39,76.74) 254.01,76.74 v2(251.95,78.79) 252.39,79.23 252.39,80.11 252.64,80.37 253.33,80.37 255.59,78.11 259.88,78.11 260.13,77.85 262.65,77.85 263.05,77.45 264.22,76.28 264.22,75.83 265.04,75.01 271.11,75.01 271.38,74.74 273.14,74.74 273.6,75.2 279.55,75.2 280.45,76.1 280.45,76.56 281,77.1 QL1.2 QL1.5 283.79,77.1 v2(284.21,77.52) 283.43,78.31 283.43,79.38 283.14,79.66 QL2.2 ; QZ3.2 284.58,70.52 v2(284.7,70.64)
SYS_RESET#: length 187.5
  TOP w0.102: v3(297.51,35.51) 297.53,35.5 299.56,35.5 301.29,33.77 301.29,33.11 300.9,32.73 v2(300.9,32.72) 300.13,31.95 JAPS1.13
  IN1 w0.089: v2(300.9,32.72) 301.43,33.24 301.43,35.13 301.53,35.23 301.53,38.39 300.54,39.38 300.54,40.4 299.81,41.12 294.2,46.73 290.65,46.73 289.98,47.41 280.22,47.41 278.94,48.68 269.28,48.68 268.57,49.4 264.31,49.4 263.77,49.94 263.77,50.49 260.56,53.7 257.52,53.7 257.12,53.29 244.33,53.29 v2(243.25,54.37)
  IN2 w0.122: v2(243.25,54.37) 243.25,54.98 245.04,56.77 245.04,60.4 243.17,62.27 242.7,62.27 241.68,63.29 241.68,64.24 241.68,65.07 241.68,65.27 241.68,65.69 241.68,69.38 239.66,71.4 234.93,71.4 234.53,71.8 234.53,72.47 232.32,74.68 223.13,74.68 221.17,76.65 204.54,76.65 204.24,76.35 204.16,76.27 200.34,76.27 200.12,76.5 185.27,76.5 184.87,76.09 182.43,76.09 181.54,76.99 181.09,77.44 180.43,78.1 180.36,78.42 180.36,83.6 v2(178.94,85.02)
  BOTTOM w0.076: UC1.B5 171.42,76.84 172.58,76.84 172.74,76.99 174.79,76.99 175.19,77.39
  BOTTOM w0.102: 175.19,77.39 175.89,78.09 175.89,80 176.54,80.65 176.54,81.78 177.02,82.26 177.02,82.79 178.94,84.7 v2(178.94,85.02) 178.94,85.24 178.71,85.46 178.19,85.46 178.04,85.61 CC302.1 178.04,86.92 RC224.2 RC291.2
SYS_RESET#_R: length 7.3
  BOTTOM w0.102: RC290.2 181.65,91.27 181.93,90.99 181.93,89.59 181.36,89.02 UC12.4 181.36,87.62 180.68,86.95 v3(180.23,86.95) RC224.1
TDI_XDP: length 22.4
  TOP w0.102: RC229.1 102.5,39.61 v3(101.94,40.17) v2(101.48,40.62) 101.17,40.93 UC8.5 ; v2(95.34,48.71) 94.66,49.39 94.66,49.56 94.34,49.88 93.67,49.88 93.11,49.32 JXDP1.56
  IN2 w0.122: v2(95.34,48.71) 95.2,48.71 94.38,47.89 94.38,43.84 94.59,43.63 94.9,43.63 95.14,43.38 95.14,43.07 98.63,39.58 100.45,39.58 v2(101.48,40.62)
TDO_XDP: length 28
  TOP w0.102: RC230.1 v3(101.31,37.79) 100.84,37.79 99.53,39.09 v2(99.53,40.06) 99.67,40.2 UC8.2 ; JXDP1.52 92.11,49.34 92.4,49.62 92.4,49.9 92.83,50.34 97.2,50.34 97.58,49.96 97.58,49.17 v2(97.43,49.02)
  IN2 w0.122: v2(97.43,49.02) 97.69,48.76 97.69,48.51 100.39,45.81 101.99,45.81 103.22,44.58 103.22,43.75 v2(99.53,40.06)
THERMATRIP2#: length 186.2
  TOP w0.102: UE2.B34 261.9,66.28 261.3,66.88 261.05,66.88 260.15,67.78 260.15,68.46 259.96,68.65 259.96,71.25 v2(261.38,72.67) ; v2(135.32,98.63) 135.72,99.04 135.72,100.43 138.6,103.31 140.88,103.31 144.77,107.2 151.05,107.2 151.05,107.2 151.45,107.2 151.45,107.2 151.95,107.2 153.02,106.13 153.02,105.03 154.55,103.5 154.55,103.29 155.11,102.73 155.64,102.73 156.06,102.32 156.06,99.42 156.86,98.62 164.61,98.62 166.14,100.15 171.19,100.15 173.73,97.62 175.03,97.62 176.1,96.54 189.11,96.54 191.98,93.68 191.98,93.68 192.39,93.27 201.58,93.27 206.57,98.26 209.2,98.26 209.6,98.66 209.88,98.66 210.25,99.04 211.91,99.04 212.62,99.75 222.44,99.75 224.52,97.67 224.52,97.04 226.28,95.28 226.28,93.25 v3(227.41,92.12) 230.21,89.32 v2(230.21,88.7)
  IN1 w0.089: v2(230.21,88.7) 230.21,87.91 230.75,87.37 232.36,87.37 232.77,86.96 235.89,86.96 237.25,85.6 237.25,80.98 238.75,79.48 239.2,79.48 241.4,77.28 241.4,76.9 242.87,75.44 242.87,75.43 243.1,75.2 243.11,75.2 243.95,74.35 243.95,72.83 245.25,71.53 259.09,71.53 260.07,72.51 261.21,72.51 v2(261.38,72.67)
  BOTTOM w0.102: QE4.1 132.55,84.83 132.88,85.17 132.88,86.44 132.97,86.53 132.97,89.55 133.95,90.53 CE36.1 134.11,90.54 RE69.2 134.96,91.07 136.41,92.52 136.41,94.04 136.36,94.09 136.36,97.35 135.32,98.39 v2(135.32,98.63)
