# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_TP_SIO: length 68.7
  TOP w0.102: RZ23.2 218.35,34.47 CZ31.1 218.86,34.81 v2(218.86,35.08) 219.5,35.08 RZ19.2 ; UE2.A37 259.86,63.04 v2(259.76,62.95)
  IN2 w0.122: v2(218.86,35.08) 219.25,35.47 222.32,35.47 223.13,36.28 224.24,36.28 225.15,35.37 225.97,35.37 226.18,35.58 226.18,36.21 227.15,37.18 234.41,37.18 235.88,35.7 235.88,35.04 236.76,34.16 239.98,34.16 246.62,40.8 247.34,40.8 248.14,41.6 250.58,41.6 253.45,44.47 253.65,44.47 255.39,46.21 255.39,46.68 255.59,46.88 255.9,47.19 255.9,49.42 255.55,49.77 255.55,54.1 256.5,55.05 256.5,55.05 257.94,56.49 258.95,56.49 260.02,57.55 260.02,61.2 260.22,61.41 260.22,62.48 v2(259.76,62.95)
CLK_TP_SIO_R: length 16.7
  TOP w0.102: v3(217.27,26.69) 211.3,32.66 JKBTP1.14 211.3,34.14 211.91,34.75 212.19,35.03 216.73,35.03 RZ23.1
CLKDET#: length 18.5
  TOP w0.102: v2(175.42,49.6) 175.42,49.52 175.85,49.09 176.73,49.09 178.82,47 180.1,47 180.79,46.31 T121.1
  BOTTOM w0.076: 172.81,52.71 172.35,53.17 171.15,53.17 170.87,53.45 169.9,53.45 169.22,54.13 169.22,55.24 169.32,55.33 169.32,55.39 169.32,55.65 169.03,55.94 UC1.AY8
  BOTTOM w0.102: 172.81,52.71 173.18,52.34 174.09,52.34 174.84,51.59 174.84,51.58 174.84,50.78 174.84,50.18 v2(175.42,49.6)
CLKREQ_PCIE#0: length 142.3
  TOP w0.102: RC189.2 170.8,47.37 v3(170.8,52.29) 170.8,54.41 169.23,55.99 169.23,57.36 168.84,57.75 168.84,58.05 v2(168.41,58.47)
  IN2 w0.122: v2(168.41,58.47) 168.93,57.96 168.93,57.51 169.25,57.19 169.25,48.81 174.26,43.79 188.35,43.79 188.76,43.79 196.04,36.52 214.38,36.52 215.37,37.5 215.69,37.5 216.29,38.1 216.29,38.71 218.4,40.82 218.67,40.82 219.16,41.31 219.37,41.31 221.31,41.31 221.77,40.85 229.29,40.85 229.74,40.39 235.52,40.39 236.83,39.08 237.93,39.08 238.66,39.82 240.43,39.82 241.91,41.3 241.91,41.33 241.93,41.34 241.93,42.07 242.3,42.44 242.59,42.72 242.59,43.14 242.59,43.14 242.59,44.84 243.4,45.65 243.4,48.98 243.84,49.42 243.84,50.18 244.06,50.4 244.97,50.4 249.26,54.68 249.28,54.69 250.17,54.69 250.57,55.08 250.57,58.18 249.04,59.71 249.04,59.73 248.66,60.11 248.66,63.24 v2(248.53,63.38)
  BOTTOM w0.076: v2(168.41,58.47) 168.4,58.47 167.95,58.92 UC1.AR10
  BOTTOM w0.102: JNGFF2.44 242.56,64.8 242.99,64.37 244.08,64.37 245.02,65.31 245.96,65.31 247.89,63.38 v2(248.53,63.38)
CLKREQ_PCIE#1: length 140.3
  TOP w0.102: RC47.2 171.28,47.78 v3(171.28,54.17) 171.28,54.61 169.71,56.19 169.71,57.56 v2(169.32,57.95)
  IN1 w0.089: v2(169.32,57.95) 169.32,55.93 170.83,54.43 170.83,48.99 173.23,46.59 173.23,44.53 176.65,41.1 178.97,41.1 179.37,40.71 180.08,39.99 180.56,39.99 187.73,32.83 213.15,32.83 214.12,31.85 219.39,31.85 219.97,32.43 224.63,32.43 225.15,31.91 226.36,31.91 227.39,32.95 231.22,32.95 231.34,33.07 231.73,33.07 232.17,32.63 235.24,32.63 235.84,32.63 236.4,33.19 242.62,33.19 243.67,34.24 247.43,34.24 247.86,34.67 v2(247.86,35.61)
  BOTTOM w0.076: v2(169.32,57.95) 169.43,57.95 UC1.AT7
  BOTTOM w0.102: v2(247.86,35.61) 247.61,35.36 247.61,23.99 247.05,23.43 247.05,20.43 248.09,19.38 251.37,19.38 251.62,19.13 253.46,19.13 254.7,17.89 255.68,17.89 256.7,16.87 JNGFF1.45
CLKREQ_PCIE#2: length 139.9
  TOP w0.102: RC50.2 v3(168.9,44.78) 168.7,44.98 168.7,54.73 168.26,55.17 168.26,56.78 168.06,56.99 168.06,57.51 v2(168.44,57.89)
  IN1 w0.089: v2(259.73,19.01) 259.74,19 257.18,19 256.86,18.69 256.86,18.39 255.74,17.28 255.22,17.28 253.27,15.33 248.74,15.33 247.56,14.15 247.56,12.48 247.86,12.17 v2(247.86,11.38)
  IN4 w0.089: v2(247.86,11.38) 244.25,11.38 240.1,15.54 234.44,15.54 232.95,17.03 232.61,17.03 231.55,18.09 231.55,18.23 231.32,18.46 231.18,18.46 229.06,20.57 229.06,22.14 227.24,23.97 227.24,24.72 225.34,26.62 225.34,26.9 225.24,27 225.24,27.01 221.65,30.6 221.22,30.6 220.77,31.06 220.77,31.38 218.77,33.38 218.29,33.38 216.96,34.7 216.96,34.96 216.45,35.47 216.12,35.47 210.25,41.34 210.25,41.72 206.58,45.39 206.22,45.39 203.42,48.19 200.3,48.19 199.76,48.73 194.08,48.73 192.61,50.2 191.53,50.2 190.25,51.48 189.26,51.48 188.55,52.19 188.27,52.48 188.27,53.59 188.03,53.82 188.03,54.3 185.51,56.82 181.05,56.82 179.72,55.49 172.28,55.49 171.03,56.73 169.9,56.73 168.74,57.89 v2(168.44,57.89)
  BOTTOM w0.076: UC1.AT8 168.47,57.9 168.45,57.9 v2(168.44,57.89)
  BOTTOM w0.102: v2(259.73,19.01) 259.75,19.04 259.81,19.04 259.96,19.2 259.96,19.93 260.29,20.25 260.29,21.52 260.45,21.68 JNGFF1.60
CLKREQ_PCIE#3: length 135.2
  TOP w0.102: v3(169.08,42.89) 169.08,43.71 168.75,44.04 ; v3(169.08,42.89) 169.37,42.6 RC59.2 ; v3(169.08,42.89) 168.75,43.22 168.75,44.04 ; 168.75,44.04 168.36,44.44 168.36,48.42 168.36,48.82 168.36,49.22 168.36,54.36 167.08,55.64 167.08,57.49 167.5,57.91 v2(167.5,57.92)
  IN4 w0.089: v2(253.8,2.8) 253.73,2.87 253.73,4.56 248.04,10.25 244.72,10.25 239.9,15.07 236.77,15.07 236.77,15.07 234.5,15.07 234.5,15.07 234.07,15.07 232.58,16.56 232.42,16.56 231.31,17.66 230.99,17.66 228.59,20.06 228.59,21.95 227.16,23.38 226.58,23.38 225.72,24.25 225.72,25.12 224.85,25.99 224.85,26.72 221.44,30.13 221.02,30.13 220.26,30.9 220.26,31.04 219.87,31.44 219.49,31.44 216.49,34.44 216.49,34.76 216.26,35 215.93,35 209.54,41.39 209.54,41.77 206.38,44.92 206.12,44.92 206.03,44.92 203.23,47.72 200.1,47.72 199.57,48.26 193.82,48.26 192.37,49.71 190.37,49.71 188.35,51.72 187.8,52.28 187.8,53.39 187.56,53.63 187.56,54.11 185.32,56.35 181.25,56.35 179.91,55.02 172.08,55.02 171.26,55.85 169.32,55.85 167.96,57.2 167.96,57.46 v2(167.5,57.92)
  BOTTOM w0.076: v2(167.5,57.92) 167.5,57.91 167.89,58.3 UC1.AT10
  BOTTOM w0.102: JNGFF3.52 v2(253.8,2.8)
CLKREQ_PCIE#4: length 175.8
  TOP w0.102: RL4.1 259.29,92.28 v2(260.3,91.28) 261.2,90.38 261.81,90.38 261.89,90.29 UL1.48 ; v2(168.45,57.28) 168.74,56.98 168.74,55.66 169.23,55.17 169.23,45.34 RC51.2
  IN2 w0.122: v2(168.45,57.28) 168.74,56.98 168.74,48.6 174.06,43.29 188.56,43.29 195.83,36.01 214.59,36.01 215.58,37 215.9,37 217.76,38.86 218.36,38.86 218.95,39.45 218.95,40.18 219.57,40.8 219.58,40.81 219.99,40.81 219.99,40.8 221,40.8 221.46,40.34 229.08,40.34 229.53,39.89 235.31,39.89 236.62,38.58 238.14,38.58 238.87,39.32 241.48,39.32 242.43,40.26 242.43,41.86 242.8,42.23 242.8,42.23 243.09,42.52 243.09,43.35 243.09,44.63 243.9,45.44 243.9,46.99 244.21,47.31 245.29,47.31 245.58,47.59 245.58,48.4 245.58,48.41 245.58,48.6 245.86,48.87 245.86,49.86 249.67,53.68 252.87,53.68 253.17,53.97 253.19,53.99 253.19,54.58 256.1,57.5 256.1,57.57 257.01,58.48 257.01,63.44 257.67,64.1 258.39,64.1 259.2,64.91 259.2,65.42 259.86,66.09 259.86,70.61 261.22,71.96 262.32,71.96 263.26,72.9 263.26,81.7 262.88,82.08 262.88,84.1 261.64,85.34 261.64,86.04 261.3,86.38 261.3,87.26 260.41,88.15 259.58,88.15 259.16,88.58 259.16,90.14 v2(260.3,91.28)
  BOTTOM w0.076: v2(168.45,57.28) 168.81,57.65 UC1.AU8
CLKREQ_PCIE#5: length 140.9
  TOP w0.102: v2(263.41,44.75) 263.52,44.64 UR2.2 ; v2(170.24,57.8) 170.04,57.61 170.04,56.99 170.31,56.72 170.5,56.72 v3(171.04,56.18) 171.72,55.5 171.72,48.16 173.62,46.26 173.62,45.11 RC190.2
  IN1 w0.089: v2(170.24,57.8) 169.8,57.37 169.8,56.12 171.3,54.62 171.3,49.19 173.7,46.79 173.7,44.72 176.85,41.57 180.52,41.57 181.05,41.04 183.63,41.04 191.37,33.3 213.35,33.3 213.63,33.02 224.71,33.02 225.35,32.38 226.15,32.38 227.86,34.09 231.38,34.09 232.37,33.1 234.39,33.1 235.07,33.77 235.77,33.77 235.89,33.66 242.43,33.66 243.48,34.71 243.87,34.71 243.87,34.71 246.84,34.71 247.39,35.27 247.39,35.81 247.67,36.08 248.06,36.08 248.54,35.6 249.66,35.6 250,35.27 254.59,35.27 255.06,34.8 257.39,34.8 259.51,36.92 262.65,36.92 v2(263.37,36.2)
  IN2 w0.122: v2(263.41,44.75) 264.83,43.33 264.83,40.32 263.37,38.87 v2(263.37,36.2)
  BOTTOM w0.076: UC1.AU7 170.08,57.65 v2(170.24,57.8)
CLKRUN#: length 195.2
  TOP w0.102: UE2.A32 262.15,67.15 261.81,67.49 261.15,67.49 260.75,67.89 260.75,68.55 v2(260.44,68.85) ; UE1.B20 245.51,85.63 245.59,85.55 245.96,85.55 v2(246.37,85.96) ; RC27.1 174.1,44.71 174.1,46.46 172.32,48.24 172.32,49.92 v2(172.17,50.07)
  IN1 w0.089: v2(172.17,50.07) 172.17,49.28 174.55,46.91 174.55,45.17 177.46,42.26 180.81,42.26 181.34,41.73 183.91,41.73 191.65,33.98 213.63,33.98 213.91,33.7 219.79,33.7 220.64,34.55 222.33,34.55 222.53,34.34 225.49,34.34 226.1,34.95 227.76,34.95 231.51,34.95 232.68,33.79 234.06,33.79 234.9,34.62 235.89,34.62 236.17,34.35 242.14,34.35 243.19,35.4 244.15,35.4 244.15,35.4 246.33,35.4 246.71,35.78 246.71,36.09 247.39,36.77 248.47,36.77 248.65,36.94 249.24,36.94 249.42,36.76 249.91,36.76 v2(250.22,36.45)
  IN4 w0.089: v2(246.37,85.96) 246.84,86.43 246.84,87.14 246.96,87.26 249,87.26 249.46,86.79 249.46,85.34 249.85,84.95 251.73,84.95 252.4,84.29 252.4,79.5 252.39,79.49 252.39,79.16 252.4,79.16 252.4,78.91 252.39,78.9 252.39,77.48 255.72,74.16 258.82,74.16 260.06,72.91 260.06,69.94 260.46,69.54 260.46,68.87 v2(260.44,68.85)
  BOTTOM w0.076: 171.52,51.59 170.49,52.62 169.56,52.62 167.5,54.68 167.5,56.02 167.18,56.34 UC1.AW11
  BOTTOM w0.102: 171.52,51.59 171.72,51.39 171.72,50.52 v2(172.17,50.07) ; v2(250.22,36.45) 250.22,37.09 247.51,39.81 247.51,39.99 247.23,40.27 245.32,40.27 244.97,40.63 244.97,41.49 247.2,43.72 247.2,45.72 248.04,46.56 248.04,48.82 v3(248.84,49.62) 249.26,50.04 249.26,50.39 249.02,50.63 248.58,50.63 247.46,51.74 247.46,54.03 247.97,54.54 247.97,57.01 248.26,57.29 249.61,57.29 251.48,59.16 251.86,59.16 252,59.29 252.26,59.56 252.26,61.57 251.88,61.95 251.88,63.55 249.89,65.54 249.89,66.06 250.31,66.48 251.45,66.48 252.31,65.61 254.62,65.61 255.99,66.98 257.44,66.98 258.74,65.69 259.6,65.69 260.46,66.55 260.46,68.83 v2(260.44,68.85)
CMPIN: length 5.4
  TOP w0.254: v2(62.72,91.44) v3(62.08,91.44) 61.61,91.92 PR832.1 61.61,93.27 PC833.1 61.56,93.27 PR831.2 PR830.2
  BOTTOM w0.203: v2(62.72,91.44) 62.5,91.22 PU801.13
CMPOUT: length 5.6
  TOP w0.102: v2(63.31,91.57) 64.06,91.57 v3(64.2,91.43)
  TOP w0.254: v2(63.31,91.57) 63.31,92.38 PR834.1 63.33,93.27 PR833.2 63.28,93.27 PC834.2 62.44,92.49 PR832.2
  BOTTOM w0.203: v2(63.31,91.57) 63.31,91.29 62.9,90.88 PU801.14
COMP_IA: length 3.1
  TOP w0.203: PU602.16 86.16,65.87 v2(86.22,65.82)
  BOTTOM w0.254: v2(86.22,65.82) 86.19,65.79 PR639.2 85.38,66.63 PC636.2
COMP_VSA: length 3.9
  TOP w0.203: PC628.1 PR630.1 82.03,70.69 83.03,69.69 PU602.24
CONTACTLESS_DET#: length 137.5
  TOP w0.102: JUSH1.4 261.46,9.13 260.15,10.44 260.15,11.06 259.87,11.34 v3(259.53,11.34) 259.1,11.34 258.59,11.85 258.59,15.43 258.03,15.99 256.54,15.99 v2(256.22,16.31)
  IN1 w0.089: v2(167.7,66.6) 167.68,66.6 168.76,67.69 170.03,67.69 172.36,70.02 174.14,70.02 176.87,72.75 180.73,72.75 181.09,72.39 181.71,72.39 183.3,70.8 v2(183.3,70.47)
  IN4 w0.089: v2(183.3,70.47) 184.07,69.7 186.39,69.7 187.72,68.37 190.82,68.37 193.58,65.61 195.11,65.61 196.11,64.61 196.11,63.34 200.02,59.43 200.54,59.43 201.14,58.83 203.67,58.83 206.49,56 206.49,55.11 206.49,53.77 206.84,53.42 206.97,53.42 206.97,53.42 207.15,53.42 207.57,53 207.57,53 207.88,52.69 207.88,51.02 208.01,50.9 208.01,48.83 210.48,46.35 212.85,46.35 216.13,43.07 216.13,42.96 217.76,41.33 221.46,41.33 225.18,37.6 225.18,35.59 225.61,35.16 226.34,35.16 227.73,33.77 227.73,29.79 231.73,25.79 231.73,24.13 237.77,18.08 241.15,18.08 241.94,17.29 242.39,17.29 243.23,16.45 243.67,16.45 244.6,15.52 251.35,15.52 251.94,14.93 254.84,14.93 v2(256.22,16.31)
  BOTTOM w0.076: UC1.W11 167.37,66.91 167.68,66.6 v2(167.7,66.6)
  BOTTOM w0.102: v2(183.3,70.47) 182.76,69.93 RPC5.8
CORE_SW:
  vias: v2(94.45,74)
CORE_VID0: length 62.2
  IN4 w0.089: v2(189.34,49.83) 189.34,50.07 188.16,51.25 188.16,51.25 187.33,52.09 187.33,52.09 187.33,52.48 187.33,52.48 187.33,53.2 187.09,53.43 187.09,53.91 185.12,55.88 181.44,55.88 180.03,54.47 171.97,54.47 171.07,55.37 169.4,55.37 168.08,56.69 167.86,56.92 167.36,56.92 167.12,57.16 167.12,59.67 167.35,59.9 v2(167.47,59.9)
  BOTTOM w0.102: v2(189.34,49.83) 189.34,50.38 188.91,50.81 188.91,51.75 188.9,51.76 188.9,52.27 188.89,52.28 188.89,52.79 188.67,53.81 188.56,54.08 188.56,54.82 189.37,55.63 189.37,58.3 190.37,59.3 190.37,60.79 191.17,61.59 193.22,61.59 193.41,61.77 193.41,63.17 193.95,63.71 194.62,63.71 194.83,63.91 194.86,63.91 195.2,63.91 195.2,63.91 195.75,63.91 196.18,64.34 196.18,65.9 197.19,66.92 197.19,69.54 197.22,69.57 v3(197.22,70.04) 197.22,70.5 196.75,70.97 196.75,72.92 196.84,73.01 196.84,74.17 PR408.1
  BOTTOM w0.254: UC1.AN11 167.39,59.9 v2(167.47,59.9)
CORE_VID1: length 66.4
  IN4 w0.089: v2(188.99,49.36) 188.7,49.06 187.94,49.06 186.85,50.15 186.85,53.06 186.66,53.25 186.66,53.73 184.95,55.45 181.62,55.45 180.11,53.94 171.89,53.94 171.08,54.74 168.35,54.74 166.13,56.96 165.52,56.96 165.24,57.24 165.24,58.94 166.16,59.86 v2(166.56,59.86)
  BOTTOM w0.102: PR411.1 197.3,73.07 196.98,72.75 196.98,71.15 197.63,70.5 197.63,69.59 197.42,69.38 197.42,66.81 196.56,65.95 196.56,64.4 195.84,63.69 195.3,63.69 194.93,63.69 194.72,63.48 194.04,63.48 193.64,63.07 193.64,61.67 193.5,61.54 193.32,61.36 191.27,61.36 190.6,60.69 190.6,59.02 190.28,58.7 190.28,57.38 189.79,56.89 189.79,55.62 188.78,54.61 188.78,54.13 188.89,53.88 189.1,52.9 189.12,52.89 189.17,52.84 189.17,50.9 189.64,50.42 189.64,50.12 189.8,49.95 189.8,49.36 189.6,49.15 189.19,49.15 v2(188.99,49.36)
  BOTTOM w0.254: UC1.AN13 166.17,60.25 v2(166.56,59.86)
CPU_B+: length 33.4
  TOP w0.254: v2(78.19,68.46) 78.02,68.63 PR603.2
  IN2 w1.016: 88.38,75.14 88.38,77.75 90.59,79.96 95.46,79.96 97.23,78.2 104.31,78.2 104.79,77.71
  IN4 w0.254: v2(87.77,71.72) 87.63,71.59 87.63,70.58 85.89,68.84 79.06,68.84 79,68.9 78.55,68.9 78.19,68.54 v2(78.19,68.46)
  vias: v2(87.77,72.38) v2(88.31,72.7) v2(88.28,72) v2(88.28,71.42) v2(88.26,70.86) v2(88.4,73.27) v2(91.79,64.07) v2(92.11,65.18) v2(92.1,64.55) v2(92.12,63.57) v2(92.09,62.98) v2(92.82,65.46) v2(104.46,76.76) v2(105.14,76.79) v3(87.67,69.69)
CPU_DP1_AUXN: length 1.8
  TOP w0.102: v2(144.63,73.4) 144.69,73.34 144.69,72.75 RC179.2
  BOTTOM w0.076: v2(144.63,73.4) 144.63,73.4 144.63,73.4 145.09,73.14 UC1.G50
CPU_DP1_AUXP: length 12.9
  TOP w0.102: v2(144.63,74.03) 144.63,74.2 144.18,74.65 144.18,78.21 143.42,78.97 143.42,80.29 143.72,80.6 143.72,82.55 v3(143.28,83) 142.93,83.34 RC180.2
  BOTTOM w0.076: v2(144.63,74.03) 144.63,74.03 145.09,73.8 UC1.F50
CPU_DP1_CTRL_CLK: length 87
  TOP w0.102: RC175.1 178.76,70.6 v4(177.73,70.6) 175.76,70.6 175.2,70.04 174.28,70.04 173.29,70.04 172.23,71.1 172.23,71.1 171.83,71.1 171.83,71.1 171.27,71.66 167.41,71.66 166.51,70.75 v2(166.44,70.75)
  IN1 w0.089: v2(108.8,91.88) 108.96,92.04 108.96,92.05 109.24,92.32 109.63,92.32 109.99,91.96 120.88,91.96 122.75,90.09 122.79,90.05 125.29,90.05 125.91,89.42 126.77,89.42 127.59,88.61 129.19,88.61 135.4,82.41 138.43,82.41 138.62,82.6 140.51,82.6 143.53,79.58 143.53,79.14 144.39,78.29 144.39,77.82 145.62,76.59 153.48,76.59 153.76,76.31 154.68,76.31 154.77,76.22 155.92,76.22 156.22,75.92 156.22,73.64 156.19,73.61 156.19,73.13 157.16,72.17 157.28,72.17 157.28,72.17 157.74,72.17 158.37,72.17 158.37,72.17 158.48,72.17 158.86,71.78 158.86,71.28 160.46,69.68 160.46,69.5 160.73,69.23 165.62,69.23 165.94,69.54 165.94,70.09 166.21,70.37 166.61,70.37 166.66,70.42 166.66,70.53 v2(166.44,70.75)
  BOTTOM w0.076: UC1.L13 166.09,71.19 166.35,70.86 v2(166.44,70.75)
  BOTTOM w0.102: QV3.1 108.56,92.12 v2(108.8,91.88)
CPU_DP1_CTRL_DATA: length 88.8
  TOP w0.102: RC178.1 178.43,70.12 175.99,70.12 175.43,69.56 174.48,69.56 173.08,69.56 172.03,70.62 171.63,70.62 171.33,70.91 171.33,70.91 171.07,71.17 167.49,71.17 v2(167.07,70.75)
  IN1 w0.089: v2(167.07,70.75) 166.84,70.52 166.84,70.35 166.68,70.19 166.29,70.19 166.12,70.02 166.12,69.47 165.7,69.05 160.66,69.05 160.23,69.47 160.23,69.65 158.69,71.2 158.69,71.71 158.41,71.99 158.3,71.99 158.3,71.99 157.99,71.99 157.99,71.99 157.66,71.99 157.09,71.99 156.01,73.06 156.01,73.68 156.04,73.71 156.04,75.85 155.85,76.05 154.78,76.05 154.58,75.84 153.56,75.84 153.29,76.12 145.42,76.12 143.92,77.63 143.92,78.09 143.06,78.95 143.06,79.39 140.32,82.13 138.82,82.13 138.62,81.94 135.2,81.94 129,88.14 127.39,88.14 126.58,88.95 125.72,88.95 125.09,89.58 122.6,89.58 122.51,89.66 120.68,91.49 109.79,91.49 v2(109.43,91.85)
  BOTTOM w0.076: v2(167.07,70.75) 166.74,71.19 UC1.L12
  BOTTOM w0.102: v2(109.43,91.85) 109.43,92.97 109,93.4 108.52,93.4 107.26,94.66 QV3.4
CPU_DP1_HPD: length 107.9
  TOP w0.102: QV5.3 94.71,94.15 v2(93.79,93.22) ; v2(168.93,70.73) 169.48,70.18 172.14,70.18 172.99,69.33 174.57,69.33 174.57,69.33 175.58,69.33 176.14,69.89 177.79,69.89 RC312.2 ; RV22.1 91.38,93.57 v2(91.76,93.2)
  IN1 w0.089: v2(91.76,93.2) 91.78,93.22 v2(93.79,93.22) 93.79,91.16 94.27,90.68 99.15,90.68 101.14,92.68 105.78,92.68 106.08,92.38 107.4,91.06 120.39,91.06 122.47,88.98 122.76,88.98 124.9,88.98 127.15,86.73 129.37,86.73 134.59,81.51 138.8,81.51 138.99,81.7 139.58,81.7 140.69,80.59 140.69,79.61 145.2,75.11 146.23,75.11 146.54,75.41 147.22,75.41 147.5,75.13 148.47,75.13 149.34,74.27 149.34,73.38 150.02,72.7 155.1,72.7 155.52,72.28 155.52,71.48 156,71 157.95,71 158.94,70.01 158.94,69.14 159.18,68.9 159.71,68.9 159.93,68.68 165.84,68.68 166.41,69.26 167.41,69.26 167.75,69.61 167.75,70.1 167.99,70.34 168.52,70.34 168.91,70.73 v2(168.93,70.73)
  BOTTOM w0.076: v2(168.93,70.73) 168.93,70.93 UC1.L9
CPU_DP1_N0: length 76.5
  TOP w0.094: CV18.2 81.9,93.6 81.9,92.97 82.1,92.76 82.28,92.76 82.38,92.87 82.38,93.07 v2(82.33,93.12)
  IN4 w0.089: v2(141.91,74.65) 141.75,74.65 141.7,74.7 141.7,74.99 140.64,76.05 139.91,76.05 139.51,76.46 137.82,76.46 136.56,77.72 136.56,78.2 135.99,78.77 135.99,78.98 135.99,81.13 132.94,84.17 132.94,85.2 130.33,87.82 130.33,88.7 128.23,90.79 121.3,90.79 120.39,91.7 111.55,91.7 110.55,90.71 107.09,90.71 105.79,92.01 105.41,92.01 105.21,92.2 101.37,92.2 99.85,90.68 90.02,90.68 88.84,91.86 88.84,92.78 87.69,93.93 83.93,93.93 82.74,92.74 82.41,92.74 82.23,92.92 82.23,93.02 v2(82.33,93.12)
  BOTTOM w0.076: v2(141.91,74.65) 142.13,74.65 UC1.E55
CPU_DP1_N1: length 73.1
  TOP w0.094: CV22.2 84.66,92.61 84.66,92.21 v2(84.85,92.03)
  IN4 w0.089: v2(84.85,92.03) 84.61,91.79 84.61,91.58 85.43,90.76 87.44,90.76 88.85,89.35 94.7,89.35 95.92,88.12 99.65,88.12 102.35,85.42 105.52,85.42 107.78,87.69 115.65,87.69 116.51,86.83 119.02,86.83 121.29,89.1 127.12,89.1 127.75,88.47 128.59,88.47 129.02,88.04 129.02,87.19 131.39,84.82 131.39,82.68 132.7,81.37 133.32,81.37 134.02,80.67 134.02,80.66 134.03,80.65 134.03,80.11 134.02,80.11 134.02,80.1 133.77,79.85 133.77,77.09 135.37,75.49 136.49,75.49 137.08,74.9 137.49,74.9 138.19,74.21 139.69,74.21 139.87,74.38 139.87,74.47 v2(140.06,74.66)
  BOTTOM w0.076: UC1.E58 v2(140.06,74.66)
CPU_DP1_N2: length 69.2
  TOP w0.094: CV29.2 90.2,92.63 90.2,92.26 v2(90.48,91.98)
  IN4 w0.089: v2(142.86,74.12) 142.86,74.07 142.63,73.84 142.54,73.84 142.45,73.92 142.45,74.4 142.48,74.43 142.48,75.13 140.34,77.27 137.93,77.27 137.23,77.98 137.23,78.46 136.64,79.04 136.64,79.48 136.64,81.43 133.6,84.47 133.6,85.47 131.08,87.99 131.08,88.87 128.13,91.82 121.19,91.82 120.66,92.36 110.99,92.36 110.05,91.42 107.35,91.42 107.3,91.42 106.06,92.66 105.68,92.66 105.48,92.85 102.53,92.85 101.22,94.17 95.34,94.17 92.61,91.44 90.31,91.44 90.11,91.64 90.11,91.79 90.3,91.98 v2(90.48,91.98)
  BOTTOM w0.076: v2(142.86,74.12) 142.86,74.1 143.17,73.79 UC1.F53
CPU_DP1_N3: length 70.7
  TOP w0.094: CV14.2 87.44,93.2 87.44,92.83 v2(87.69,92.58)
  IN4 w0.089: v2(141.06,74.1) 141.06,74.02 140.83,73.79 140.72,73.79 140.68,73.83 140.68,74.96 140.29,75.36 138.97,75.36 138.72,75.11 138.21,75.11 137.67,75.65 137.35,75.65 136.8,76.2 135.6,76.2 134.43,77.37 134.43,79.16 135.04,79.76 135.04,81.14 132.29,83.89 132.29,84.84 129.68,87.46 129.68,88.43 128.69,89.41 127.77,89.41 127.41,89.77 120.48,89.77 119.69,88.98 117.11,88.98 116.32,89.77 107.1,89.77 105.52,91.35 105.13,91.35 104.94,91.55 101.64,91.55 100.12,90.03 89.57,90.03 87.39,92.21 87.39,92.36 87.61,92.58 v2(87.69,92.58)
  BOTTOM w0.076: v2(141.06,74.1) 141.37,73.79 UC1.F56
CPU_DP1_P0: length 76.5
  TOP w0.094: v2(82.26,92.36) 82.24,92.36 81.7,92.89 81.7,93.5 CV17.2
  IN4 w0.089: v2(82.26,92.36) 82.46,92.56 82.82,92.56 84.01,93.75 87.62,93.75 88.66,92.7 88.66,91.78 89.94,90.5 99.93,90.5 101.45,92.02 105.13,92.02 105.33,91.82 105.71,91.82 107.01,90.52 110.63,90.52 111.62,91.52 120.31,91.52 121.22,90.61 128.16,90.61 130.15,88.62 130.15,87.74 132.76,85.12 132.76,84.1 135.8,81.05 135.8,79.13 135.8,78.7 136.38,78.12 136.38,77.64 137.75,76.27 139.43,76.27 139.84,75.87 140.56,75.87 141.52,74.91 141.52,74.4 v2(141.89,74.03)
  BOTTOM w0.076: UC1.F55 142.33,73.8 v2(141.89,74.03)
CPU_DP1_P1: length 73.1
  TOP w0.094: v2(84.26,92.03) 84.47,92.24 84.47,92.66 CV21.2
  IN4 w0.089: v2(84.26,92.03) 84.43,91.87 84.43,91.51 85.36,90.58 87.37,90.58 88.78,89.16 94.62,89.16 95.85,87.94 99.57,87.94 102.27,85.24 105.59,85.24 107.86,87.5 115.58,87.5 116.44,86.64 119.09,86.64 121.37,88.92 127.04,88.92 127.67,88.29 128.52,88.29 128.84,87.96 128.84,87.11 131.21,84.74 131.21,82.61 132.62,81.19 133.25,81.19 133.84,80.6 133.84,80.58 133.84,80.58 133.84,80.19 133.84,80.18 133.84,80.18 133.59,79.92 133.59,77.02 135.29,75.31 136.41,75.31 137,74.72 137.42,74.72 138.11,74.03 v2(140.06,74.03)
  BOTTOM w0.076: UC1.F58 v2(140.06,74.03)
CPU_DP1_P2: length 69.2
  TOP w0.094: v2(89.75,91.98) 90.01,92.24 90.01,92.58 CV28.2
  IN4 w0.089: v2(89.75,91.98) 89.76,91.98 89.92,91.81 89.92,91.56 90.23,91.25 92.68,91.25 95.41,93.98 101.15,93.98 102.46,92.67 105.4,92.67 105.6,92.48 105.98,92.48 107.22,91.24 107.43,91.24 110.13,91.24 111.07,92.17 120.58,92.17 121.12,91.64 128.05,91.64 130.9,88.8 130.9,87.91 133.41,85.4 133.41,84.4 136.46,81.36 136.46,79.4 136.46,78.97 137.04,78.38 137.04,77.9 137.86,77.09 140.27,77.09 142.3,75.06 142.3,74.5 142.27,74.48 142.27,73.85 142.46,73.66 142.54,73.66 v2(142.8,73.39)
  BOTTOM w0.076: v2(142.8,73.39) 143.01,73.39 UC1.G53
CPU_DP1_P3: length 70.8
  TOP w0.094: v2(87.03,92.56) 87.25,92.78 87.25,93.18 CV13.2
  IN4 w0.089: v2(141.06,73.46) 140.91,73.61 140.65,73.61 140.5,73.76 140.5,74.89 140.21,75.17 139.04,75.17 138.8,74.93 138.13,74.93 137.59,75.47 137.27,75.47 136.72,76.02 135.53,76.02 134.25,77.3 134.25,79.23 134.86,79.84 134.86,81.06 132.11,83.81 132.11,84.76 129.49,87.38 129.49,88.35 128.62,89.23 127.7,89.23 127.34,89.59 120.56,89.59 119.77,88.8 117.03,88.8 116.24,89.59 107.02,89.59 105.44,91.17 105.06,91.17 104.86,91.37 101.72,91.37 100.2,89.85 89.49,89.85 87.21,92.13 87.21,92.38 v2(87.03,92.56)
  BOTTOM w0.076: v2(141.06,73.46) 141.38,73.14 UC1.G56
CPU_DP2_AUXN: length 93
  IN4 w0.089: v2(145.55,74.66) 145.71,74.5 146.02,74.5 146.24,74.27 146.24,73.75 146.11,73.61 146.11,73.18 146.44,72.85 148.34,72.85 148.91,73.42 148.91,75.99 147.45,77.45 147.45,80.8 147.92,81.26 147.92,87 150.24,89.32 156.58,89.32 160.66,93.4 165.1,93.4 166.31,93.4 166.79,93.89 169.65,93.89 170.8,92.74 171.99,92.74 172.58,92.16 179.49,92.16 180.16,92.83 180.22,92.83 185.18,92.83 185.72,92.3 185.72,92.29 186.35,91.66 187.62,91.66 188.11,91.17 190.29,91.17 191.27,90.2 191.5,89.97 200.75,89.97 203.82,93.05 204.38,93.05 204.68,92.74 204.68,92.51 v2(204.89,92.31)
  BOTTOM w0.076: v2(145.55,74.66) 145.76,74.45 145.99,74.45 UC1.E48
  BOTTOM w0.094: v2(204.89,92.31) 204.78,92.2 204.78,91.82 204.63,91.67 204.63,90.99 RC181.2 204.66,89.95 204.66,89.54 204.32,89.19 204.32,86.56 203.76,86.01 202.25,86.01 CV80.1
CPU_DP2_AUXN_C: length 2.3
  BOTTOM w0.094: CV80.2 200.64,85.99 200.22,85.99 200.06,85.83 199.71,85.83 199.6,85.73 UV26.25
CPU_DP2_AUXP: length 93
  IN4 w0.089: v2(204.25,92.36) 204.43,92.36 204.5,92.43 204.5,92.66 204.3,92.87 203.9,92.87 200.82,89.79 191.42,89.79 191.14,90.07 190.22,90.99 188.04,90.99 187.55,91.48 186.27,91.48 185.53,92.22 185.11,92.65 180.9,92.65 180.24,92.65 179.56,91.97 172.51,91.97 171.92,92.56 170.72,92.56 169.57,93.71 166.87,93.71 166.38,93.22 165.17,93.22 160.74,93.22 156.66,89.14 150.32,89.14 148.1,86.92 148.1,81.19 147.64,80.73 147.64,77.52 149.09,76.07 149.09,73.34 148.42,72.67 146.37,72.67 145.93,73.11 145.93,73.69 146.06,73.82 146.06,74.2 145.94,74.32 145.73,74.32 145.55,74.14 v2(145.55,74.03)
  BOTTOM w0.076: UC1.F48 146.01,73.92 145.86,74.07 145.59,74.07 v2(145.55,74.03)
  BOTTOM w0.094: CV79.1 202.23,86.2 203.68,86.2 204.12,86.64 204.12,89.27 204.47,89.62 204.47,89.91 RC182.2 204.44,90.97 204.44,91.75 204.59,91.9 204.59,91.99 204.46,92.12 204.46,92.29 204.4,92.36 v2(204.25,92.36)
CPU_DP2_AUXP_C: length 2.3
  BOTTOM w0.094: CV79.2 200.62,86.19 200.14,86.19 199.98,86.02 199.67,86.02 199.56,86.13 UV26.24
CPU_DP2_CTRL_CLK: length 59.3
  TOP w0.102: RC176.1 183.3,71.71 183.09,71.92 v2(183.09,72.34) 183.09,72.94 181.84,74.2 181.05,74.2 177.99,77.26 177.99,81 177.99,81 177.99,81.18 178.17,81.36 178.17,81.92 181.38,85.13 186.52,85.13 187.66,83.99 189.24,82.4 190.3,82.4 191.57,83.68 193.41,83.68 193.84,84.1 193.84,85.09 194.73,85.98 198.61,85.98 v2(199.83,87.2)
  IN1 w0.076: v2(170.29,70.74) 170.7,71.15 170.77,71.15 172.78,73.16 172.85,73.16
  IN1 w0.089: v2(183.09,72.34) 183.09,72.89 182.18,73.8 179.94,73.8 178.34,75.4 173.6,75.4 172.95,74.75 172.95,73.26 172.85,73.16
  BOTTOM w0.076: UC1.N7 170.29,70.56 v2(170.29,70.74)
  BOTTOM w0.102: UV26.22 199.71,86.93 199.83,87.05 v2(199.83,87.2)
CPU_DP2_CTRL_DATA: length 62.4
  TOP w0.102: RC177.1 184.36,72.32 v2(183.68,72.32) 183.68,73.04 182.04,74.68 181.25,74.68 178.47,77.46 178.47,80.81 178.47,80.98 178.65,81.16 178.65,81.72 181.58,84.65 186.32,84.65 187.32,83.65 189.04,81.92 190.5,81.92 191.77,83.19 193.62,83.19 194.32,83.9 194.32,84.89 194.93,85.5 198.81,85.5 200.32,87 200.32,87.08 v2(200.44,87.2)
  IN1 w0.076: v2(169.71,70.76) 170.44,71.49 170.55,71.49 172.48,73.42 172.48,73.53
  IN1 w0.089: 172.48,73.53 172.48,74.95 173.57,76.03 178.38,76.03 180.14,74.27 182.63,74.27 183.68,73.22 v2(183.68,72.32)
  BOTTOM w0.076: UC1.N8 169.32,70.38 v2(169.71,70.76)
  BOTTOM w0.102: v2(200.44,87.2) 200.37,87.13 200.37,86.77 200.12,86.53 UV26.23
CPU_DP2_HPD: length 47.1
  TOP w0.094: v2(170.24,72.17) 169.76,72.64 169.76,74.9 170.05,75.18 170.8,75.18 171.02,75.4 172.34,75.4 173.04,74.7 173.04,74.25 173.37,73.92 174.04,73.92 175,72.96 176.9,72.96 177.56,73.62 177.56,76.49 177.28,76.77 177.28,77.55 177.14,77.69 173.99,80.84 173.97,80.84 173.61,81.19 173.61,82.79 177.81,86.99 183.63,86.99 v3(184.06,86.55) 184.42,86.19 189.26,86.19 189.57,86.5 189.57,87.53 RC242.2 190.49,88.19 v2(191.35,89.05)
  BOTTOM w0.076: v2(170.24,72.17) 170.29,72.11 170.29,71.58 169.98,71.26 UC1.L7
  BOTTOM w0.094: v2(191.35,89.05) 191.45,88.95 UV26.3
CPU_DP2_N0: length 69.3
  IN4 w0.089: v2(144.84,81.65) 145.08,81.89 145.22,81.89 145.43,82.1 145.43,82.5 144.79,83.14 144.79,84.68 145.34,85.24 145.34,87.72 145.02,88.05 145.02,89.06 148.98,93.01 149.74,93.01 151.87,95.14 165.45,95.14 166.51,96.19 169.87,96.19 169.9,96.17 169.91,96.17 170.88,95.2 170.88,94.97 171.44,94.41 172.47,94.41 173.02,94.41 186.07,94.41 187.01,93.47 188.31,93.47 188.74,93.04 189.08,93.04 189.29,93.25 v2(189.5,93.25)
  BOTTOM w0.076: UC1.C50 144.99,75.86 144.96,75.9 144.96,76.14 145.01,76.2 145.18,76.2 145.27,76.29 145.32,76.42 145.32,76.61 145.28,76.7 145.28,76.95 145.32,77.05 145.32,77.72 145.44,77.84 145.44,78.11 145.33,78.22 145.33,78.44 145.44,78.55 145.44,78.92 145.62,79.1 145.62,79.31
  BOTTOM w0.094: v2(189.5,93.25) 189.42,93.32 189.27,93.32 189.11,93.17 189.11,92.99 189.7,92.41 190.92,92.41 191.19,92.14 191.19,91.73 191.54,91.38 CV607.1 ; v2(144.84,81.65) 145.08,81.65 145.15,81.72 145.15,81.96 145.24,82.04 145.36,82.04 145.71,81.7 145.71,81.39 145.63,81.31 145.63,81.03 145.71,80.95 145.71,80.72 145.62,80.63 145.62,80.37 145.53,80.28 145.53,79.96 145.62,79.87 145.62,79.31
CPU_DP2_N0_C: length 3.8
  BOTTOM w0.094: CV607.2 191.37,90.18 191.37,90.08 191.45,90 192.29,90 192.82,89.47 192.82,88.83 193.05,88.6 UV26.7
CPU_DP2_N1: length 75.5
  IN4 w0.089: v2(194.5,92.76) 194.47,92.76 193.81,92.1 192.47,92.1 189.01,95.56 175.41,95.56 175.41,95.56 173.5,95.56 173.5,95.56 172.95,95.56 171.13,97.39 165.72,97.39 164.63,96.29 148.59,96.29 147.05,94.75 147.05,92.8 143.78,89.53 143.78,89.05 143.78,86.81 142.96,85.99 142.96,82.55 142.56,82.15 142.56,81.92 142.75,81.72 142.84,81.72 143.09,81.97 v2(143.09,82.02)
  BOTTOM w0.076: 143.57,79.43 143.57,78.47 143.85,78.19 143.85,77.52 143.66,77.33 143.66,77.05 143.72,76.94 143.72,76.79 143.66,76.59 143.66,76.42 143.72,76.22 143.79,76.15 143.95,76.15 144.02,76.09 144.02,75.95 UC1.C52
  BOTTOM w0.094: v2(143.09,82.02) 143.12,82.02 143.44,81.7 143.64,81.7 143.9,81.44 143.9,80.44 143.57,80.12 143.57,79.43 ; v2(194.5,92.76) 194.5,92.74 194.3,92.54 194.3,92.18 194.1,91.98 194.1,91.66 CV609.1
CPU_DP2_N1_C: length 2.6
  BOTTOM w0.094: UV26.10 194.25,88.38 194.11,88.52 v4(194.11,89.32) 194.11,90.06 CV609.2
CPU_DP2_N2: length 73.9
  IN4 w0.089: v2(144.33,81.33) 144.33,81.26 144.21,81.13 143.95,81.13 143.72,81.36 143.72,85.93 144.36,86.57 144.36,89.29 150.79,95.72 165.21,95.72 166.27,96.77 170.93,96.77 172.71,94.99 173.26,94.99 173.26,94.99 175.65,94.99 175.65,94.99 188.67,94.99 189.78,93.88 190.98,92.68 192.14,91.52 195.47,91.52 195.9,91.95 195.9,92.35 196.31,92.76 v2(196.38,92.76)
  BOTTOM w0.076: UC1.A50 144.88,77.16 144.79,77.25 144.79,77.65 145.02,77.88 145.02,78.74 145.22,78.95 145.22,79.31
  BOTTOM w0.094: v2(196.38,92.76) 196.14,92.53 196.14,92.26 195.88,92 195.88,91.66 CV611.1 ; v2(144.33,81.33) 144.59,81.33 144.76,81.16 144.76,80.88 144.94,80.7 144.94,79.97 145.22,79.69 145.22,79.31
CPU_DP2_N2_C: length 2.8
  BOTTOM w0.094: UV26.13 195.45,88.48 195.34,88.59 195.34,88.93 195.39,88.99 195.44,88.99 195.86,89.4 195.86,89.45 195.94,89.53 195.94,90.12 CV611.2
CPU_DP2_N3: length 76
  IN4 w0.089: v2(144,79.43) 144.06,79.43 144.23,79.26 144.23,79.01 144.42,78.81 144.81,78.81 145.55,79.56 145.55,80.29 146.26,81 146.26,82.52 145.38,83.41 145.38,83.93 146.55,85.1 146.55,87.62 147.15,88.22 147.15,88.78 150.34,91.97 157.73,91.97 160.32,94.56 165.69,94.56 166.74,95.62 169.64,95.62 170.11,95.14 170.11,94.92 171.2,93.83 172.23,93.83 185.78,93.83 186.82,92.8 187.86,92.8 188.51,92.14 190.7,92.14 191.9,90.94 197.15,90.94 198.24,92.03 198.24,92.73 v2(198.23,92.74)
  BOTTOM w0.076: 144.13,79.31 144.19,79.24 144.19,78.4 144.26,78.33 144.26,76.37 144.2,76.31 144.2,76.01 144.49,75.72 UC1.D51
  BOTTOM w0.094: CV613.1 197.66,91.66 197.66,92.01 198,92.36 198,92.51 v2(198.23,92.74) ; 144.13,79.31 v2(144,79.43)
CPU_DP2_N3_C: length 3.1
  BOTTOM w0.094: UV26.16 196.65,88.36 196.55,88.46 196.55,88.66 196.9,89.01 196.95,89.01 197.36,89.43 197.36,89.47 197.65,89.75 197.65,90.05 CV613.2
CPU_DP2_P0: length 69.3
  IN4 w0.089: v2(144.84,82.24) 145.01,82.07 145.15,82.07 145.25,82.17 145.25,82.42 144.61,83.06 144.61,84.76 145.16,85.31 145.16,87.65 144.84,87.97 144.84,89.13 148.9,93.2 149.67,93.2 151.79,95.32 165.38,95.32 166.43,96.38 169.95,96.38 169.98,96.35 169.99,96.35 171.06,95.27 171.06,95.04 171.51,94.59 172.55,94.59 173.09,94.59 186.14,94.59 187.09,93.65 188.39,93.65 188.81,93.22 189.01,93.22 189.09,93.3 189.09,93.65 v2(189.06,93.68)
  BOTTOM w0.076: 145.82,79.31 145.82,79.06 145.6,78.85 145.6,77.77 145.48,77.65 145.48,77.02 145.45,76.92 145.45,76.73 145.48,76.64 145.48,76.4 145.47,76.35 145.42,76.2 145.37,76 145.37,75.88 145.27,75.54 UC1.D50
  BOTTOM w0.094: v2(144.84,82.24) 145.44,82.24 145.64,82.03 145.9,81.78 145.9,80.64 145.82,80.55 145.82,79.31 ; CV606.1 190.99,91.61 190.99,92.06 190.84,92.22 189.62,92.22 188.92,92.91 188.92,93.25 189.06,93.39 v2(189.06,93.68)
CPU_DP2_P0_C: length 3.8
  BOTTOM w0.094: CV606.2 190.83,90.46 191.17,90.12 191.17,90 191.37,89.8 192.21,89.8 192.63,89.39 192.63,88.03 UV26.6
CPU_DP2_P1: length 75.5
  IN4 w0.089: v2(143.14,81.44) 143.04,81.54 142.68,81.54 142.37,81.84 142.37,82.22 142.78,82.63 142.78,86.06 143.6,86.88 143.6,88.97 143.6,89.6 146.87,92.87 146.87,94.83 148.52,96.48 164.55,96.48 165.65,97.57 171.2,97.57 173.03,95.75 173.57,95.75 173.57,95.75 175.33,95.75 175.34,95.75 189.08,95.75 192.54,92.29 193.74,92.29 193.89,92.44 v2(193.89,92.76)
  BOTTOM w0.076: UC1.D52 143.71,75.54 143.63,75.8 143.63,75.92 143.62,75.97 143.55,76.2 143.5,76.37 143.49,76.39 143.49,76.62 143.55,76.81 143.55,76.9 143.49,77.01 143.49,77.4 143.69,77.59 143.69,78 143.5,78.19
  BOTTOM w0.094: v2(143.14,81.44) 143.21,81.5 143.56,81.5 143.7,81.36 143.7,80.52 143.38,80.2 143.38,78.31 143.5,78.19 ; CV608.1 193.91,91.66 193.91,92.06 194.1,92.26 194.1,92.55 v2(193.89,92.76)
CPU_DP2_P1_C: length 2.6
  BOTTOM w0.094: CV608.2 193.91,90.05 193.91,89.65 193.88,89.61 193.88,89.02 193.91,88.99 193.91,88.54 193.85,88.47 UV26.9
CPU_DP2_P2: length 73.9
  IN4 w0.089: v2(195.72,92.76) 195.71,92.76 195.71,92.03 195.39,91.7 192.21,91.7 191.11,92.81 189.85,94.06 188.75,95.17 175.57,95.17 172.79,95.17 171,96.95 166.19,96.95 165.14,95.9 150.71,95.9 144.18,89.36 144.18,86.64 143.54,86.01 143.54,81.28 143.88,80.95 144.16,80.95 v2(144.36,80.75)
  BOTTOM w0.076: 145.03,79.31 145.03,79.27 145.05,79.25 145.05,79.21 145.06,79.2 145.06,79.02 144.86,78.81 144.86,77.94 144.63,77.72 144.63,77.18 144.78,77.02 144.78,77 145.05,76.74 UC1.B50
  BOTTOM w0.094: v2(195.72,92.76) 195.95,92.54 195.95,92.34 195.69,92.08 195.69,91.66 CV610.1 ; v2(144.36,80.75) 144.62,80.75 144.75,80.62 144.75,79.89 145.03,79.61 145.03,79.31
CPU_DP2_P2_C: length 2.8
  BOTTOM w0.094: CV610.2 195.75,89.99 195.75,89.61 v4(195.49,89.35) 195.14,89.01 195.14,88.55 195.05,88.45 UV26.12
CPU_DP2_P3: length 75.9
  IN4 w0.089: v2(197.62,92.74) 198.06,92.31 198.06,92.1 197.08,91.13 191.97,91.13 190.77,92.33 188.59,92.33 187.94,92.98 186.89,92.98 185.86,94.02 176.05,94.02 171.27,94.02 170.29,95 170.29,95.22 169.71,95.8 166.67,95.8 165.61,94.75 160.25,94.75 157.66,92.16 150.27,92.16 146.97,88.86 146.97,88.29 146.37,87.69 146.37,85.18 145.19,84 145.19,83.33 146.08,82.45 146.08,81.08 145.37,80.37 145.37,79.64 144.73,79 144.5,79 144.41,79.09 144.41,79.35 144.51,79.46 v2(144.61,79.46)
  BOTTOM w0.076: UC1.C51 144.44,76.14 144.44,76 144.56,75.88 144.67,75.88 144.79,76 144.79,76.38 144.66,76.51 144.49,76.51 144.43,76.57 144.43,78.4 144.36,78.46 144.36,79.2 144.47,79.31
  BOTTOM w0.094: CV612.1 197.46,91.66 197.46,92.09 197.81,92.44 197.81,92.55 v2(197.62,92.74) ; 144.47,79.31 v2(144.61,79.46)
CPU_DP2_P3_C: length 3
  BOTTOM w0.094: UV26.15 196.25,88.36 196.36,88.47 196.36,88.74 v4(197,89.38) 197.23,89.61 197.45,89.83 197.45,90.06 CV612.2
CPU_DP3_AUXN: length 13.1
  TOP w0.102: v2(146.54,73.47) 146.85,73.77 146.85,74.67 146.85,74.67 146.85,75.26 147.07,75.49 147.07,79.74 147.26,79.92 147.26,81.8 147.43,81.97 147.43,84.38 T1.1
  BOTTOM w0.076: UC1.G46 146.88,73.14 v2(146.54,73.47)
CPU_DP3_AUXP: length 1.9
  TOP w0.102: T2.1 146.5,72.71 147.2,73.41 v2(147.38,73.41)
  BOTTOM w0.076: UC1.F46 147.01,73.79 v2(147.38,73.41)
CPU_ID: length 14.3
  TOP w0.102: UE1.B60 253.63,82.63 253.22,82.22 v2(253.22,81.91) ; v2(260.56,77.14) 261.17,76.53 RE299.1 RE298.1
  IN1 w0.089: v2(253.22,81.91) 253.02,81.91 252.75,81.64 252.75,81.09 256.4,77.45 257.87,77.45 258.61,76.71 260.34,76.71 260.56,76.94 v2(260.56,77.14)
CPU_POPIRCOMP: length 12.8
  TOP w0.381: v2(163.84,57.95) 163.94,57.95 164.63,57.26 v3(164.63,53.53) 164.63,51.25 165.19,50.69 RC88.1
  BOTTOM w0.254: UC1.AT16 v2(163.84,57.95)
CPU_XDP_PRDY#: length 89.1
  TOP w0.102: JXDP1.5 80.61,43.82 81.78,44.99 85.66,44.99 85.99,45.32 86.82,45.32 87.25,45.75 95.56,45.75 95.74,45.57 97,45.57 97.31,45.88 97.73,45.88 98.72,46.87 100.36,46.87 101.46,47.97 110.77,47.97 113.45,50.65 v3(113.45,52.39) 113.45,52.63 113.99,53.17 113.99,55.93 121.19,63.13 121.19,64.05 123.69,66.55 124.88,66.55 127.49,69.17 127.49,73.38 129.83,75.72 129.83,78.06 130.21,78.44 130.21,78.69 130.52,79 136.24,79 137.86,80.62 139.15,80.62 139.85,79.91 v2(140.17,79.91)
  BOTTOM w0.076: v2(140.17,79.91) 140.17,79.89 140.49,79.57 140.49,78.78 141.21,78.06 141.21,77.59 141.01,77.4 141.01,77.01 141.07,76.9 141.07,76.81 141.01,76.62 141.01,76.39 141.02,76.37 141.15,75.92 141.15,75.8 141.23,75.54 UC1.D56
CPU_XDP_PREQ#: length 91.1
  TOP w0.102: RC138.2 81.06,40.47 80.91,40.47 80.11,41.26 JXDP1.3 80.11,43.82 81.51,45.22 85.57,45.22 85.9,45.55 86.73,45.55 87.16,45.98 95.66,45.98 95.83,45.8 96.91,45.8 97.21,46.1 97.63,46.1 98.62,47.1 100.27,47.1 101.57,48.4 v3(110.02,48.4) 110.88,48.4 113.06,50.58 113.06,52.56 113.76,53.26 113.76,56.03 120.96,63.23 120.96,64.15 123.59,66.78 124.78,66.78 127.26,69.26 127.26,73.48 129.6,75.82 129.6,78.16 129.93,78.49 129.93,78.73 130.42,79.22 133.16,79.22 134.46,80.52 v2(134.46,80.52)
  BOTTOM w0.076: v2(134.46,80.52) 134.71,80.78 136.61,80.78 137.88,79.5 137.88,79.04 138.24,78.68 138.44,78.68 138.73,78.39 139.09,78.39 139.37,78.11 139.37,77.56 139.24,77.43 139.24,76.06 139.26,76.04 139.26,75.68 139.24,75.66 139.24,75.48 UC1.D61
CPU_XDP_TCLK: length 84
  TOP w0.102: RC328.1 v3(130.63,83.05) 130.63,81.33 131.4,80.56 132.06,80.56 132.32,80.81 132.94,80.81 v2(133.37,80.38) ; JXDP1.57 93.61,41.52 94.5,40.62 v2(94.5,40.58) 94.75,40.33 RC139.2
  IN1 w0.089: v2(129.5,73.44) 129.5,73.26 129.51,73.25 129.51,72 128.97,71.45 128.97,70.07 113.7,54.8 113.7,53.06 106.37,45.73 101.16,45.73 99.17,43.74 94.67,43.74 93.81,42.89 93.81,41.63 94.5,40.94 v2(94.5,40.58)
  IN4 w0.089: v2(129.5,73.44) 129.5,78.06 129.02,78.54 129.02,79.67 129.25,79.9 132.89,79.9 v2(133.37,80.38)
  BOTTOM w0.076: UC1.B61 138.76,76.72 138.76,76.94 138.7,77.05 138.7,77.66 138.63,77.73 138.63,78.25 138.37,78.52 138.13,78.52 137.72,78.93 137.72,79.43 136.73,80.42 134.94,80.42 134.63,80.11 133.65,80.11 v2(133.37,80.38)
CPU_XDP_TDI: length 64.7
  TOP w0.102: UC8.6 101.67,41.14 102.7,40.12 103.96,40.12 RC134.2 104.69,40.85 v3(105.97,40.85) 107.45,40.85 109.95,43.35 111.62,43.35 116.74,48.47 116.74,54.42 116.73,54.42 116.73,54.8 123.93,62 123.93,62.92 124.75,63.73 126.04,63.73 130.75,68.44 130.75,71.16 131.98,72.39 132.04,72.39 132.04,72.39 132.13,72.39 132.75,73.02 132.75,73.16 133.56,73.97 133.56,74.85 134.79,76.08 135.61,76.08 136.91,77.38 136.91,77.43 138.15,78.67 138.7,78.67 138.99,78.96 v2(139.06,78.96)
  BOTTOM w0.076: v2(139.06,78.96) 139.06,78.94 139.7,78.3 139.7,77.42 139.64,77.36 139.64,76.49 139.82,76.31 139.82,76.06 139.53,75.77 UC1.D60
CPU_XDP_TDO: length 63.2
  TOP w0.102: v2(139,77.88) 138.44,77.32 137.65,77.32 135.95,75.62 135.73,75.62 134.83,74.72 134.83,74.6 133.21,72.97 133.21,72.83 132.32,71.94 132.17,71.94 131.2,70.97 131.2,68.25 126.23,63.28 124.94,63.28 124.39,62.73 124.39,61.81 117.19,54.61 117.19,48.28 108.11,39.2 v3(107.2,39.2) 106.26,39.2 106.09,39.03 102.29,39.03 RC135.2 101.59,39.73 101.15,39.73 100.17,40.71 UC8.3
  BOTTOM w0.076: v2(139,77.88) 138.97,77.85 UC1.A61
CPU_XDP_TMS: length 62.9
  TOP w0.102: UC8.8 102.89,43.07 102.96,43.01 102.96,42.37 103.08,42.24 103.66,42.24 RC131.2 104.6,41.65 v3(107.59,41.65) 107.69,41.65 109.67,43.63 111.57,43.63 116.51,48.56 116.51,54.32 116.51,54.89 123.71,62.09 123.71,63.01 124.65,63.96 125.94,63.96 130.52,68.54 130.52,71.26 131.88,72.62 131.91,72.62 132.03,72.62 132.52,73.11 132.52,73.27 133.34,74.08 133.34,74.94 134.83,76.43 135.64,76.43 136.68,77.47 136.68,77.52 138.05,78.9 138.19,78.9 v2(138.37,79.07)
  BOTTOM w0.076: v2(138.37,79.07) 138.89,78.55 139.16,78.55 139.53,78.18 139.53,77.49 139.47,77.42 139.47,76.25 UC1.C60
CPU_XDP_TRST#: length 78.4
  TOP w0.102: 137.25,79.4 137.24,79.39 137.24,79.25 136.22,78.23 136.22,77.66 135.63,77.08 134.82,77.08 132.88,75.13 132.88,74.61 132.19,73.92 131.85,73.92 131.33,73.39 131.33,72.72 130.06,71.45 130.06,68.73 125.75,64.42 124.46,64.42 123.25,63.2 123.25,62.28 116.05,55.08 116.05,54.13 116.05,48.75 112.38,45.08 v3(103.42,45.08) 101.51,45.08 101.19,44.77 100.81,44.77 100.67,44.63 UC8.11 ; 137.25,79.4 v2(137.25,79.38) ; 137.25,79.4 137.25,79.43 v2(137.93,80.12) 138.21,80.39 139.03,80.39 139.92,79.51 140.34,79.51 140.91,80.07 140.91,82.78 141.82,83.69 141.82,85.24 RC136.2
  BOTTOM w0.076: v2(137.25,79.38) 137.25,79.17 138.06,78.35 138.3,78.35 138.47,78.19 138.47,77.66 138.54,77.59 138.54,77.01 138.55,76.99 138.57,76.92 138.57,76.38 138.97,75.98 UC1.C61 ; 139.86,78.41 139.86,77.35 139.8,77.29 139.8,76.8 UC1.B59
  BOTTOM w0.102: v2(137.93,80.12) 137.93,79.84 138.32,79.46 138.52,79.46 138.62,79.36 139.19,79.36 139.44,79.12 139.44,78.83 139.86,78.41
CS_1.2V: length 6.9
  BOTTOM w0.203: 92.44,51.72 92.48,51.76 PU201.13
  BOTTOM w0.254: 92.44,51.72 92.44,51.67 91.61,50.83 91.32,50.83 91.12,51.03 PR203.2 90.4,51.33 90.4,51.51 90.2,51.71 88.34,51.71 v3(87.76,51.12)
CSI2_COMP: length 16.5
  TOP w0.102: v2(167.65,77.65) 167.65,78.63 168.93,79.91 170.69,79.91 172.3,81.52 172.3,83.16 172.24,83.23 172.24,84.75 172.65,85.16 v3(173.12,85.16) 174.06,85.16 RC3.1
  BOTTOM w0.076: UC1.E13 166.51,75.09 166.66,75.24 166.91,75.24 167.08,75.41 167.08,75.66 167.06,75.68 167.06,76.04 167.08,76.06 167.08,77.31 167.42,77.65 v2(167.65,77.65)
CSS_GC: length 15.4
  TOP w0.254: PR804.1 40.72,74.71 40.24,74.22 v3(35.32,74.22) 33.28,74.22 32.01,75.49 32.01,76.99 31.76,77.25 31.19,77.25 30.29,78.15 30.29,79.03 30.03,79.29 PU901.10
CSSN_1: length 20.5
  TOP w0.254: PQ803.3 48.32,78.72 47.79,79.25 v2(47.79,79.79)
  IN1 w0.254: v2(54.01,86.9) 53.99,86.92 51.42,86.92 47.79,83.29 47.79,82.17 46.6,80.98 46.6,80.06 46.87,79.79 v2(47.79,79.79)
  BOTTOM w0.254: PR807.1 PR805.1 54.67,87.23 54.42,87.23 54.09,86.9 v2(54.01,86.9) ; v2(47.79,79.79) 47.71,79.71 PR809.1 47.71,77.8 PQ805.3
CSSP_1: length 25.3
  TOP w0.254: PQ801.3 45.88,75.98 45.63,76.23 44.46,76.23 44.03,76.66 44.03,78.01 v2(45.25,79.23)
  IN1 w0.254: v2(45.25,79.23) 45.63,79.23 46.21,79.81 46.21,81.21 47.41,82.4 47.41,83.45 51.34,87.38 53.89,87.38 v2(54.01,87.51)
  BOTTOM w0.254: v2(45.25,79.23) PR808.1 43.47,77.96 PQ804.3 ; v2(54.01,87.51) 54.16,87.51 54.64,87.99 PR805.2 54.85,87.96 PR806.1
CV2_ON: length 74.5
  TOP w0.102: RPE10.1 276.56,62.15 v2(276.19,61.78) 275.6,61.78 275.14,61.32 273.19,61.32 272.96,61.54 UE2.A9 ; JUSH1.24 271.46,7.55 271.69,7.32 273.16,7.32 276.16,10.32 276.16,12.82 275.63,13.35 275.63,14.08 276.13,14.58 276.13,15.32 v3(276.16,15.35) 276.84,15.35 v2(276.87,15.32)
  IN3 w0.122: v2(276.19,61.78) 276.31,61.65 276.31,59.47 276.36,59.42 276.36,58.27 275.86,57.77 275.86,54.64 272.53,51.31 272.53,49.64 269.35,46.46 269.35,43.39 268.49,42.52 268.49,40.59 268.13,40.24 268.13,34.41 268.82,33.72 268.82,29.2 269.11,28.91 269.11,26.87 270.9,25.07 270.9,23.78 272.08,22.6 272.08,20.74 272.93,19.89 272.93,18.39 273.87,17.45 275.42,17.45 276.34,16.54 276.34,15.85 v2(276.87,15.32)
D_CLKRUN#: length 100.8
  TOP w0.102: RPE8.4 242.48,84.14 242.58,84.24 242.58,84.54 v2(242.2,84.92) 242.2,85.13 v3(242.56,85.49) 242.78,85.49 242.89,85.38 UE1.A19
  IN2 w0.122: v2(242.2,84.92) 240.13,82.85 238.76,82.85 238.42,82.5 234.43,82.5 232.91,80.98 231.05,80.98 229.67,79.6 224.41,79.6 223.87,80.15 204.13,80.15 204.12,80.15 203.92,80.15 203.3,80.15 202.77,79.62 202.2,79.62 201.46,80.36 201.46,80.98 198.52,83.92 188.42,83.92 185,87.33 184.01,87.33 184.01,87.33 183.12,88.22 182.19,89.15 182.07,89.27 181.09,90.25 180.36,90.25 178.17,92.44 174.51,92.44 172.59,94.36 168.27,94.36 163.59,99.04 163.59,102.59 163.13,103.06 163.12,103.06 v2(162.95,103.23)
  BOTTOM w0.102: JDOCK1.111 164,101.53 163.87,101.66 163.87,102.32 v2(162.95,103.23)
D_DLDRQ1#: length 105.3
  TOP w0.102: RPE8.2 242.53,83.14 v2(242.78,83.39) ; UE1.B24 245.46,83.63 v2(245.67,83.43)
  IN1 w0.089: v2(245.67,83.43) 244.47,83.43 244.44,83.39 v2(242.78,83.39)
  IN2 w0.122: v2(164.35,103.2) 163.91,103.65 162.78,103.65 162.51,103.38 162.51,99.41 168.06,93.86 172.39,93.86 174.31,91.94 177.96,91.94 180.15,89.75 180.88,89.75 181.79,88.85 183.7,86.93 183.71,86.93 183.8,86.84 184.62,86.84 189.01,82.45 191.61,82.45 192.58,83.42 197.49,83.42 199.25,81.65 199.82,81.65 200.96,80.52 200.96,80.16 201.99,79.12 202.98,79.12 203.51,79.65 203.71,79.65 203.92,79.65 223.63,79.65 224.18,79.1 230.98,79.1 231.79,79.91 232.54,79.91 234.64,82.01 238.79,82.01 239.13,82.35 241.74,82.35 v2(242.78,83.39)
  BOTTOM w0.102: v2(164.35,103.2) 165.5,102.05 JDOCK1.117
D_LAD0: length 111.4
  TOP w0.102: UE1.B29 246.3,81.13 v2(246.68,80.75)
  IN2 w0.122: v2(160.34,102.06) 160.25,102.06 159.81,102.51 159.81,102.89 160.91,103.99 162.22,103.99 162.57,104.34 164.25,104.34 165.12,103.47 165.32,103.27 165.32,100.55 165.93,99.94 165.93,98.36 167.61,96.67 173.76,96.67 176.7,93.73 179.23,93.73 179.53,93.43 180.76,92.2 180.77,92.2 180.78,92.19 181.02,92.19 184.99,88.22 185.32,88.22 187.86,85.68 198.08,85.68 201.96,81.8 207.81,81.8 208.69,80.91 222.79,80.91 222.79,80.91 224.23,80.91 224.79,80.35 229.36,80.35 230.77,81.76 231.23,81.76 232.63,81.76 234.12,83.25 238.11,83.25 239.19,84.33 239.69,84.33 241.21,85.86 241.66,85.86 242.16,86.35 243.44,86.35 244.42,85.37 244.42,84.81 244.86,84.37 246.29,84.37 246.96,83.71 246.96,81.82 246.68,81.54 v2(246.68,80.75)
  BOTTOM w0.102: v2(160.34,102.06) 160.5,101.9 JDOCK1.97
D_LAD1: length 108.3
  TOP w0.102: v2(246.32,82) 246.32,81.72 246.16,81.56 245.49,81.56 245.43,81.63 UE1.B28
  IN2 w0.122: v2(160.27,102.69) 161.3,103.72 162.3,103.72 162.67,104.09 164.15,104.09 165.02,103.22 165.02,100.45 165.62,99.84 165.62,98.31 167.51,96.42 173.29,96.42 176.52,93.2 178.37,93.2 179.63,91.94 180.92,91.94 184.89,87.97 185.16,87.97 187.7,85.43 197.98,85.43 201.86,81.55 207.61,81.55 208.49,80.66 222.89,80.66 224.1,80.66 224.67,80.1 229.47,80.1 230.88,81.51 231.24,81.51 231.75,81.51 231.75,81.51 232.73,81.51 234.22,83 238.21,83 239.29,84.08 239.79,84.08 241.32,85.61 242.47,85.61 242.72,85.36 243.48,85.36 244.73,84.12 246.2,84.12 246.7,83.62 246.7,82.66 246.32,82.27 v2(246.32,82)
  BOTTOM w0.102: v2(160.27,102.69) 160.36,102.69 160.74,102.31 160.74,101.83 161,101.58 JDOCK1.99
D_LAD2: length 100
  TOP w0.102: v2(242.73,82.01) 243.32,82.59 243.81,82.59 244.02,82.38 UE1.A25
  IN2 w0.122: v2(242.73,82.01) 241.49,80.77 237.85,80.77 237.35,80.27 234.3,80.27 232.9,78.87 231.71,78.87 231.2,78.36 224.13,78.36 223.35,79.15 203.71,79.15 203.19,78.63 201.79,78.63 201.32,79.09 201.18,79.24 200.46,79.95 200.46,80.27 199.69,81.04 199,81.04 197.36,82.67 192.57,82.67 191.83,81.94 188.81,81.94 184.48,86.27 183.66,86.27 182.67,87.26 181.59,88.34 180.98,88.95 180.68,89.25 179.95,89.25 177.76,91.44 174.1,91.44 172.5,93.05 168.17,93.05 161.01,100.21 161.01,102.2 v2(161.45,102.65)
  BOTTOM w0.102: v2(161.45,102.65) 161.45,102.59 162,102.05 JDOCK1.103
D_LAD3: length 101.1
  TOP w0.102: v2(241.97,81.89) 241.97,82.16 242.15,82.34 242.42,82.34 242.5,82.41 242.81,82.41 243.28,82.88 UE1.A24
  IN2 w0.122: v2(241.97,81.89) 241.09,81.01 237.74,81.01 237.25,80.52 233.79,80.52 232.55,79.28 231.61,79.28 231.1,78.77 224.08,78.77 223.45,79.4 203.82,79.4 203.82,79.4 203.61,79.4 203.08,78.88 201.89,78.88 201.43,79.34 200.71,80.06 200.71,80.4 199.7,81.41 199.15,81.41 197.39,83.17 192.69,83.17 191.72,82.2 188.91,82.2 184.52,86.59 183.7,86.59 183.57,86.72 181.54,88.74 180.78,89.5 180.05,89.5 177.86,91.69 174.2,91.69 172.28,93.62 167.96,93.62 162.01,99.56 162.01,102.72 v2(161.45,103.28)
  BOTTOM w0.102: JDOCK1.105 162.5,102.36 162.14,102.72 162.01,102.72 v2(161.45,103.28)
D_LFRAME#: length 102.2
  TOP w0.102: v2(246.26,83.44) 246.26,83.83 245.96,84.13 UE1.B23
  IN2 w0.122: v2(162.95,102.65) 163.34,102.25 163.34,98.93 168.16,94.11 172.49,94.11 174.41,92.19 178.07,92.19 180.26,90 180.99,90 181.46,89.53 183.72,87.27 183.84,87.14 183.85,87.14 183.9,87.09 184.9,87.09 188.32,83.67 198.42,83.67 201.21,80.88 201.21,80.7 201.21,80.26 202.1,79.37 202.88,79.37 203.27,79.76 203.4,79.9 203.82,79.9 203.82,79.9 204.02,79.9 223.75,79.9 224.3,79.35 229.78,79.35 231.08,80.65 232.93,80.65 234.53,82.25 238.57,82.25 238.91,82.59 241.27,82.59 243.3,84.62 243.77,84.62 244.53,83.86 245.84,83.86 v2(246.26,83.44)
  BOTTOM w0.102: v2(162.95,102.65) 163.5,102.1 JDOCK1.109
D_SERIRQ: length 95.2
  TOP w0.102: UE1.A20 243.5,84.88 243.31,85.07 242.93,85.07 v2(242.79,84.93) 243.01,84.71 243.01,84.2 242.46,83.64 RPE8.3
  IN2 w0.122: v2(242.79,84.93) 242.37,85.36 241.42,85.36 239.89,83.83 239.4,83.83 238.31,82.75 234.33,82.75 232.8,81.23 230.95,81.23 229.57,79.85 224.54,79.85 223.98,80.42 208.23,80.42 207.35,81.3 201.76,81.3 198.89,84.17 188.52,84.17 185.11,87.58 184.11,87.58 181.49,90.2 181.19,90.5 180.46,90.5 178.27,92.69 175.1,92.69 174.64,93.15 174.64,94.72 173.18,96.18 166.84,96.18 164.66,98.35 v2(164.66,99.26)
  BOTTOM w0.102: v2(164.66,99.26) 165,99.6 JDOCK1.115
DAI_12MHZ#: length 225.9
  TOP w0.076: v2(275.78,26.75) 275.8,26.72 276.47,26.72 276.91,27.16 277.2,27.16 RA30.1
  TOP w0.102: R41.1 155.15,108.44 155.33,108.61 155.55,108.61 155.56,108.61 157.69,108.61 158.63,107.67 158.79,107.67 159.97,106.49 160.41,106.05 160.7,105.76 161.33,105.76 161.61,105.47 161.61,105.07 161.33,104.79 161.31,104.79 v2(161.2,104.68)
  IN2 w0.122: v2(275.78,26.75) 275.22,27.31 275.22,28.12 276.75,29.65 276.75,35.95 276.85,36.05 276.85,40.46 276.49,40.82 276.49,41.63 277.02,42.17 280.67,42.17 289.55,51.05 289.55,54.2 288.54,55.22 288.54,59.39 289.47,60.33 289.47,69.53 288.79,70.21 288.79,71.68 v2(288,72.47)
  IN4 w0.089: v2(288,72.47) 286.7,73.77 277.78,73.77 276.07,75.48 275.62,75.48 274.65,76.45 274.25,76.45 269.87,80.84 269.12,80.84 266.87,83.09 266.87,84.8 267.94,85.87 267.94,87.98 265.54,90.38 264.68,90.38 264.51,90.55 264.51,90.96 262.95,92.52 262.95,93.65 262.11,94.48 262.11,94.94 262.11,95.32 259.67,97.77 257.95,97.77 255.05,100.66 249.36,100.66 248.84,100.14 233.15,100.14 231.79,101.5 v2(231.14,101.5) 230.57,100.93 230.08,100.93 227.19,103.82 224.49,103.82 222.86,102.19 207.02,102.19 200.86,96.03 193.6,96.03 192.66,96.97 189.79,99.84 173.82,99.84 169.97,103.69 165.21,103.69 164.58,104.32 161.56,104.32 v2(161.2,104.68)
  BOTTOM w0.102: v2(161.2,104.68) 160.97,104.44 158.81,102.29 158.23,102.29 157.5,101.56 JDOCK1.89
DAI_BCLK#: length 229.3
  TOP w0.076: v2(278.73,26.82) 278.73,26.82 278.74,26.81 278.74,26.8 278.31,27.23 RA31.1
  TOP w0.102: v2(161.13,105.27) 160.5,105.27 159.77,106.01 159.77,106.01 158.95,106.82 157.3,106.82 R6.1
  IN2 w0.122: v2(278.73,26.82) 278.74,26.82 278.74,26.81 278.72,26.79 278.29,26.79 278,27.08 278,27.85 277.25,28.6 277.25,35.51 277.35,35.61 277.35,37.7 277.72,38.06 277.72,40.3 276.99,41.03 276.99,41.42 277.2,41.63 280.88,41.63 v2(289.04,49.8) 290.05,50.81 290.05,54.69 289.22,55.53 289.22,59.36 289.98,60.13 289.98,69.73 289.37,70.34 v2(289.37,72.47)
  IN4 w0.089: v2(289.37,72.47) 288.58,71.68 285.61,71.68 285.12,72.18 283.14,72.18 282.02,73.3 277.58,73.3 275.87,75.01 274.82,75.01 269.6,80.23 268.01,80.23 266.99,81.25 266.99,82.04 266.37,82.65 266.37,85.07 267.47,86.16 267.47,87.78 265.69,89.56 264.5,89.56 262.39,91.67 262.39,92.92 261.64,93.67 261.64,95.13 259.48,97.3 257.75,97.3 254.95,100.11 250.02,100.11 249.59,99.67 230.42,99.67 229.76,100.33 229.76,100.58 226.99,103.35 224.68,103.35 223.04,101.71 207.2,101.71 201.06,95.56 193.41,95.56 192.33,96.64 192.19,96.78 189.6,99.37 174.01,99.37 173.62,99.37 169.77,103.22 165.02,103.22 164.38,103.85 161.36,103.85 161.01,104.21 160.73,104.48 160.73,104.87 161.01,105.15 v2(161.13,105.27) 160.4,106 158.02,106 157.35,105.33 157.35,103.17 157.04,102.86 156.7,102.86 156.44,102.59 155.51,102.59 v2(154.95,102.04)
  BOTTOM w0.102: v2(154.95,102.04) 154.5,101.58 JDOCK1.77
