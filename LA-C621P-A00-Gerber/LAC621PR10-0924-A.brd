# Allegro board LAC621PR10-0924-A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 141.79,88.8 141.79,87.2 141.67,87.08 141.26,87.08 140.52,86.34 140.52,84.2 138.67,82.35 134.91,82.35 133.74,83.52 133.74,87.61 135.27,89.13 141.46,89.13
GND on BOTTOM (solid shape): 200.93,58.75 200.93,57.38 200.77,57.23 198.64,57.23 198.56,57.31 198.56,58.5 198.69,58.63 199.48,58.63 199.86,59.01 200.67,59.01
GND on BOTTOM (solid shape): 216.06,101.56 216.06,100.53 216.07,100.52 216.07,100.18 215.89,100 214.2,100 214.06,100.14 214.06,101.46 214.25,101.65 215.96,101.65
GND on BOTTOM (solid shape): 236.31,84.43 236.31,78.24 236.08,78.01 233.39,78.01 233.06,78.34 233.06,81.21 234.35,82.5 234.35,84.46 234.5,84.61 236.13,84.61
GND on BOTTOM (solid shape): 23.05,94.62 23.05,91.93 22.41,91.29 20.94,91.29 20.51,91.72 20.51,94.14 20.18,94.47 20.18,95.13 20.46,95.41 22.26,95.41
GND on BOTTOM (solid shape): 29.22,83.34 29.22,82.94 29.12,82.83 27.54,82.83 27.53,82.82 27.48,82.82 27.19,82.53 26.35,82.53 26.24,82.64 26.24,83.18 26.53,83.47 29.09,83.47
GND on BOTTOM (solid shape): 70.57,77.25 83.7,77.25 83.98,76.97 83.98,75.77 83.63,75.42 76.77,75.42 76.75,75.44 76.39,75.44 76.36,75.42 70.67,75.42 70.46,75.63 70.46,77.18 70.55,77.27
GND on BOTTOM (solid shape): 75.4,51.44 75.4,47.43 75.29,47.33 74.63,47.33 74.28,47.68 73.39,47.68 73.34,47.73 73.34,51.41 73.52,51.59 75.25,51.59
GND on BOTTOM (solid shape): 86.7,53.24 86.7,52.24 86.88,52.06 86.88,51.06 85.71,49.89 83.35,49.89 83.18,50.06 83.18,51.1 82.87,51.41 82.87,53.04 83.3,53.47 86.47,53.47
GND on BOTTOM (solid shape): 221.7,84.92 221.7,83.39 221.45,83.14 220.48,83.14 220.26,83.37 220.26,84.99 219.8,85.45 219.8,85.6 219.87,85.68 220.94,85.68
GND on BOTTOM (solid shape): 223.05,100.05 223.23,99.88 224.32,99.88 224.52,99.68 224.52,99.25 224.3,99.03 222.11,99.03 221.02,97.93 220.31,97.93 220.03,98.21 220.03,99.74 220.36,100.07 223.05,100.07
GND on BOTTOM (solid shape): 263.59,88.13 263.59,85.51 263.03,84.95 261.61,84.95 261.56,85 261.56,86.01 261.72,86.18 261.72,87.23 261.51,87.44 261.51,88.1 261.94,88.54 263.19,88.54
GND on BOTTOM (solid shape): 269.71,52.23 269.71,50.25 269.52,50.05 266.18,50.05 265.27,50.97 265.27,51.27 265.34,51.35 265.52,51.35 265.98,51.8 266.25,52.08 266.63,52.08 266.86,52.31 269.63,52.31
GND on BOTTOM (solid shape): 202.26,63.37 203.4,63.37 203.4,63.39 203.54,63.39 203.54,63.37 204.6,63.37 204.67,63.29 204.67,62 204.6,61.93 200.97,61.93 200.84,62.05 200.84,63.23 200.99,63.39 202.26,63.39
GND on BOTTOM (solid shape): 213.93,49.97 213.93,48.65 213.48,48.2 213.22,48.2 213.21,48.19 210.17,48.19 209.74,48.62 209.74,50.12 209.94,50.32 213.58,50.32
GND on BOTTOM (solid shape): 221.8,62.13 221.8,62.01 221.75,61.95 220.99,61.95 220.94,61.9 220.94,61.9 220.76,61.73 220.76,61.73 220.13,61.09 219.95,61.09 219.77,61.27 219.77,61.59 220.41,62.23 221.7,62.23
GND on BOTTOM (solid shape): 79.23,30.18 80.15,30.18 80.33,30 80.33,27.33 81.11,26.55 81.11,25.28 80.82,24.98 77.04,24.98 76.54,25.48 76.54,30 76.77,30.23 79.18,30.23
GND on BOTTOM (solid shape): 101.71,82.48 101.71,81.69 101.64,81.61 100.39,81.61 100.21,81.44 100.21,80.65 100.14,80.57 99.71,80.57 99.66,80.62 99.66,82.45 99.86,82.66 101.53,82.66
GND on BOTTOM (solid shape): 108.87,79.72 110.24,79.72 110.24,79.71 110.77,79.18 110.77,78.04 110.24,77.51 110.24,76.61 109.67,76.03 107.41,76.03 106.79,76.66 106.79,79.04 107.61,79.86 108.73,79.86
GND on BOTTOM (solid shape): 147.03,95.14 147.03,93.36 146.9,93.23 145.56,93.23 145.38,93.41 145.38,93.59 145.6,93.81 145.6,94.16 145.25,94.51 145.25,95.29 145.3,95.34 146.83,95.34
GND on BOTTOM (solid shape): 203.6,56.84 203.6,55.73 203.41,55.54 203.41,54.25 203.35,54.19 203.22,54.19 203.14,54.28 203.14,55.05 202.81,55.37 202.81,56.83 202.9,56.92 203.52,56.92
GND on BOTTOM (solid shape): 218.96,71.53 220.05,71.53 220.1,71.48 220.1,71.3 220.03,71.23 219.04,71.23 218.91,71.1 218.91,70.49 218.86,70.44 218.4,70.44 218.27,70.57 218.27,71.4 218.43,71.56 218.93,71.56
GND on BOTTOM (solid shape): 90.74,90.5 90.74,87.86 90.44,87.56 86.85,87.56 86.4,87.1 86.4,85.88 86.32,85.81 85.23,85.81 85.13,85.91 85.13,87.96 84.7,88.4 84.7,90.22 85.71,91.24 90,91.24
GND on BOTTOM (solid shape): 107.91,90.25 107.91,86.47 106.84,85.4 101.74,85.4 100.67,86.47 99.48,86.47 99.47,86.48 99.26,86.48 98.06,87.68 98.06,88.86 98.46,89.27 98.46,89.67 98.72,89.92 99.09,89.92 101.4,92.23 105.93,92.23
GND on BOTTOM (solid shape): 81.98,74.81 81.98,71.87 81.39,71.28 80.37,71.28 80.27,71.3 80.17,71.29 79.86,71.29 79.55,71.61 78.9,71.61 78.65,71.86 78.65,75.01 78.83,75.19 81.6,75.19
GND on BOTTOM (solid shape): 289.21,64.52 289.21,62.28 289.03,62.09 288.41,62.09 288.22,61.91 288.19,61.88 288.16,61.85 285.58,61.85 285.46,61.97 285.46,63.2 285.56,63.3 286.94,63.3 287.3,63.66 287.3,63.67 288.43,64.8 288.93,64.8
GND on BOTTOM (solid shape): 210.76,109.83 210.76,109.55 210.6,109.4 210.6,108.72 210.45,108.56 210.45,107.17 210.4,107.12 209.76,107.12 209.71,107.17 209.71,108.11 209.64,108.18 209.64,109.86 209.74,109.96 210.63,109.96
GND on BOTTOM (solid shape): 165.27,91.19 165.27,91 165.2,90.92 165.2,90.04 164.75,89.6 164.59,89.6 164.47,89.72 164.47,89.89 164.38,89.99 164.04,89.99 163.49,89.43 163.49,88.37 163.39,88.26 162.95,88.26 162.88,88.33 162.88,89.42 162.6,89.7 162.6,90.69 163.25,91.33 165.13,91.33
GND on BOTTOM (solid shape): 295.69,22.23 295.69,21.77 295.82,21.64 297.52,21.64 297.52,21.64 297.69,21.64 297.87,21.46 297.87,20.49 297.68,20.3 296.35,20.3 295.9,20.76 294.47,20.76 294.32,20.91 294.32,22.1 294.47,22.25 295.67,22.25
GND on BOTTOM (solid shape): 62.4,81.67 62.4,80.2 62.22,80.01 58.88,80.01 58.56,79.7 58.56,78.25 58.4,78.08 54.36,78.08 54.19,78.25 54.19,81.3 54.42,81.52 56.4,81.52 56.82,81.11 57.53,81.11 57.95,81.52 58.66,81.52 59.05,81.91 62.16,81.91
GND on BOTTOM (solid shape): 211.77,57.43 211.77,56.68 211.56,56.46 209.78,56.46 208.24,54.92 207.61,54.92 207.35,55.17 207.35,55.76 207.43,55.83 208.01,55.83 208.27,56.09 208.27,56.77 207.5,57.53 206.72,57.53 206.59,57.66 206.59,58.86 206.79,59.06 210.15,59.06
GND on BOTTOM (solid shape): 90.41,87.02 90.41,85.68 90.64,85.45 90.64,85.21 90.61,85.07 90.64,84.93 90.64,84.38 90.49,84.23 89.72,84.23 89.55,84.41 89.55,85.42 89.64,85.51 90.02,85.51 90.11,85.6 90.11,87.02 90.21,87.13 90.31,87.13
GND on BOTTOM (solid shape): 227.24,64.06 227.85,64.06 227.85,64.06 228.17,63.74 228.17,62.54 227.35,61.73 225.23,61.73 225.03,61.93 224.01,61.93 223.56,61.47 222.5,61.47 222.38,61.6 222.38,62.6 222.46,62.69 224.04,62.69 224.04,62.69 224.84,62.69 224.98,62.69 225.21,62.92 225.21,64.42 225.39,64.6 226.71,64.6
GND on BOTTOM (solid shape): 92.26,77.27 92.26,76.25 92.34,76.18 93.31,76.18 93.36,76.13 93.36,76 93.31,75.95 92.34,75.95 92.26,75.87 92.26,73.46 92.37,73.35 92.37,71.4 92.11,71.15 92.11,69.5 91.91,69.3 89.88,69.3 89.67,69.5 89.67,72.54 90.03,72.9 90.03,75.8 90.03,77.32 92.21,77.32
GND on BOTTOM (solid shape): 92.59,57.89 92.59,55.27 92.67,55.2 93.31,55.2 93.38,55.12 93.38,53.5 93.32,53.43 91.64,53.43 91.58,53.5 91.58,56.26 91.63,56.32 91.73,56.32 91.81,56.24 91.81,55.43 91.99,55.25 92.34,55.25 92.37,55.27 92.37,56.37 91.81,56.93 91.81,57.94 91.86,57.99 92.49,57.99
GND on BOTTOM (solid shape): 215.26,85.9 215.26,84.48 215.35,84.39 215.35,81.54 215.87,81.02 218.41,81.02 218.58,80.84 218.58,80.53 218.26,80.21 211.55,80.21 210.42,81.34 210.42,84.46 210.57,84.61 212.15,84.61 212.51,84.26 213.36,84.26 213.71,84.6 213.71,85.96 213.81,86.06 215.1,86.06
GND on BOTTOM (solid shape): 232.35,62.86 232.35,60.84 231.96,60.45 231.01,60.45 231,60.45 230.88,60.47 230.75,60.45 230.75,60.45 230.2,60.45 229.95,60.69 229.95,61.51 230.58,62.14 230.58,62.69 230.48,62.8 229.16,62.8 229.02,62.94 229.02,64.1 229.16,64.24 230.98,64.24
GND on BOTTOM (solid shape): 283.14,63.74 283.14,63.41 282.64,62.92 282.64,61.74 282.48,61.58 281.7,61.58 281.46,61.34 281.02,61.34 280.95,61.41 280.95,62.46 281.11,62.62 281.29,62.62 282.25,63.59 282.59,63.62 282.86,63.82 283.05,63.82
GND on BOTTOM (solid shape): 217.36,94.95 217.36,94.28 217.56,94.08 219.43,94.08 219.7,93.81 219.7,91.91 219.59,91.81 219.08,91.81 218.84,92.04 218.84,93.02 218.74,93.12 217.2,93.12 217.19,93.13 215.39,93.13 215.35,93.17 214.84,93.17 214.72,93.04 214.01,93.04 213.83,92.87 213.83,91.39 213.45,91.39 213.19,91.65 213.19,93.76 214.51,95.08 217.24,95.08
GND on BOTTOM (solid shape): 225.11,57.46 225.11,54.99 224.83,54.72 224.83,52.2 224.67,52.05 222.82,52.05 222.8,52.07 222.8,52.3 222.82,52.33 224.09,52.33 224.14,52.38 224.14,53.93 224.09,53.98 222.49,53.98 222.31,54.16 222.31,55.81 223.15,56.65 223.15,57.2 223.18,57.23 223.99,57.23 224.29,57.53 225.03,57.53
GND on BOTTOM (solid shape): 225.49,73.33 225.49,70.31 224.45,69.27 224.42,69.28 224.27,69.31 224.12,69.27 224.11,69.27 223.79,69.27 223.68,69.37 223.68,70.9 223.48,71.1 223.4,71.1 223.3,71.2 222.31,71.2 221.93,70.82 220.69,70.82 220.61,70.9 220.61,71.89 220.71,71.99 223.76,71.99 223.96,72.19 223.96,73.34 224.1,73.47 225.34,73.47
GND on BOTTOM (solid shape): 231.05,31.3 231.05,28.83 230.34,28.12 230.34,25.99 229.73,25.38 226.02,25.38 226.02,30.33 226.49,30.5 226.39,30.98 227.13,31.73 230.62,31.73
GND on BOTTOM (solid shape): 189.19,68.74 189.19,68.35 189.37,68.18 190.08,68.18 190.24,68.02 190.24,67.39 190.69,66.94 190.69,66.4 190.84,66.25 191.47,66.25 191.54,66.17 191.54,65.92 191.37,65.75 189.07,65.75 188.65,65.33 187.6,65.33 187.47,65.45 187.47,66.08 187.19,66.36 187.19,66.76 187.32,66.89 188.47,66.89 188.79,67.21 188.79,67.22 188.89,67.32 188.89,67.91 188.5,68.29 188.26,68.29 188.19,68.36 188.19,68.91 188.42,69.14 188.8,69.14
GND on BOTTOM (solid shape): 205.77,74.55 205.77,73.38 205.45,73.05 205.45,69.83 205.14,69.52 203.92,69.52 203.54,69.14 202.73,69.14 202.58,69.3 202.58,69.5 202.4,69.68 200.7,69.68 200.6,69.78 200.6,71.45 200.65,71.5 202.35,71.5 202.4,71.45 202.4,70.69 202.6,70.49 204.08,70.49 204.43,70.84 204.43,73.13 204.1,73.46 203.51,73.46 203.34,73.64 203.34,75.33 203.38,75.37 204.96,75.37
GND on BOTTOM (solid shape): 196.3,63.33 196.3,62.31 197.06,61.55 197.57,61.55 197.83,61.29 197.83,59.27 197.63,59.07 197.55,59.07 197.47,59.05 197.25,59.05 196.94,59.08 196.71,58.87 196.7,58.88 196.05,58.88 195.79,59.14 195.79,60.53 194.02,62.31 194.02,62.82 194.27,63.07 194.65,63.07 195.03,63.45 196.18,63.45
GND on BOTTOM (solid shape): 284.52,58.94 284.52,58.31 284.25,58.04 284.24,58.03 284.2,57.99 283.67,57.82 283.17,57.58 283,57.58 282.79,57.37 282.08,57.37 281.96,57.5 281.96,58.14 282.17,58.36 282.77,58.36 283.05,58.27 283.31,58.41 283.88,58.98 284.49,58.98
GND on BOTTOM (solid shape): 103.46,84.17 104,84.13 104.53,84.17 104.53,84.17 105.53,84.17 105.68,84.03 105.68,83.83 105.68,83.79 105.68,83.49 105.73,83.44 105.73,83.39 105.78,83.34 105.78,83.01 105.73,82.96 103.87,82.96 103.31,83.52 102.45,83.52 102.25,83.72 102.25,84.04 102.28,84.08 102.38,84.08 102.38,84.12 102.39,84.15 102.43,84.17 103.46,84.17
GND on BOTTOM (solid shape): 83.98,90.13 83.98,88.35 84.39,87.94 84.39,85.86 84.29,85.75 83.73,85.75 83.63,85.86 83.63,87.28 83.3,87.61 83.3,88.19 82.89,88.6 81.32,88.6 80.1,87.38 78.73,87.38 78.37,87.02 78.37,85.88 78.32,85.83 78.17,85.83 78.12,85.88 78.12,87.3 78.65,87.84 79.01,87.84 79.23,88.07 79.23,88.5 78.92,88.81 78.38,88.81 77.86,88.29 77.86,87.84 76.62,86.59 74.79,86.59 74.54,86.85 74.54,90.71 75.68,91.85 82.26,91.85
GND on BOTTOM (solid shape): 247.71,102.24 247.71,102.14 247.62,101.7 248.01,101.48 248.09,101.45 248.12,101.38 248.12,100.51 247.97,100.36 246.67,100.36 246.29,100.74 246.29,101.61 246.21,101.69 246.21,102.03 246.65,102.47 247.48,102.47
GND on BOTTOM (solid shape): 80.96,68.94 80.96,68.2 81.06,68.1 81.26,68.1 81.46,67.9 82.98,67.9 83.18,68.1 84.75,68.1 85,68.36 85,68.94 85.08,69.02 85.66,69.02 85.76,68.91 85.76,67.31 85.64,67.19 84.19,67.19 84.03,67.03 84.03,65.36 84.16,65.23 84.67,65.23 84.77,65.13 84.77,63.68 84.67,63.58 83.17,63.58 83.17,64.32 82.94,64.55 81.55,64.55 81.29,64.29 81.29,63.71 81.22,63.63 79.74,63.63 79.64,63.73 79.64,64.34 79.74,64.44 79.92,64.44 80.17,64.7 80.17,68.99 80.27,69.09 80.81,69.09
GND on BOTTOM (solid shape): 98.56,68.1 98.56,67.14 98.64,67.06 98.64,67.07 98.75,67.07 98.8,67.07 99.75,67.07 99.76,67.07 99.99,67.07 100.14,67.22 101.03,67.22 101.11,67.15 101.11,66.34 101.01,66.23 100.22,66.23 99.72,66.73 99.72,66.75 98.57,66.75 98.57,66.69 98.52,66.64 98.5,66.62 98.5,64.29 97.54,63.33 97.54,62.08 97.16,61.71 97.16,60.83 96.71,60.38 96.35,60.38 95.95,60.79 95.95,61.65 96.02,61.73 96.02,63.96 96.28,64.22 96.28,64.3 96.29,64.31 96.29,66.67 96.28,66.68 96.28,68.03 96.43,68.18 98.49,68.18
GND on BOTTOM (solid shape): 279.51,19.46 279.51,19.34 279.51,18.98 279.18,18.65 279.18,16.67 279.31,16.54 280.15,16.54 280.33,16.72 280.33,18.11 280.45,18.24 281.75,18.24 281.8,18.19 281.8,16.62 281.29,16.11 280.66,16.11 279.67,15.12 279.21,15.12 279.13,15.19 279.13,15.7 278.6,16.23 277.2,16.23 277.02,16.06 276.62,16.06 276.57,16.11 276.57,16.41 276.85,16.69 276.85,18.06 276.95,18.16 277.07,18.16 277.18,18.06 277.18,16.89 277.35,16.72 278.68,16.72 278.83,16.87 278.83,18.83 279.08,19.08 279.08,19.51 279.18,19.61 279.36,19.61
GND on BOTTOM (solid shape): 132.83,93.86 134.28,93.86 134.3,93.88 134.63,93.88 134.94,93.58 134.94,92.56 134.12,91.75 132.52,91.75 132.35,91.93 132.35,92.43 132.19,92.59 131.36,92.59 131.13,92.36 130.44,92.36 130.24,92.56 130.24,93.15 130.36,93.27 130.39,93.27 130.79,93.73 130.23,93.99 130.22,93.98 130.06,93.98 130.05,93.99 129.84,94.06 129.62,94 129.59,93.97 129.42,94.14 129.42,94.75 129.53,94.85 131.84,94.85
GND on BOTTOM (solid shape): 149.95,73.87 149.95,73.84 149.31,73.21 149.31,72.98 149.31,72.98 149.31,72.8 149.36,72.7 149.3,72.55 149.13,72.54 149.08,72.59 149.05,72.67 149.06,72.71 149.02,72.91 148.83,72.99 148.81,72.99 148.75,72.98 148.72,72.99 148.62,73.01 148.6,73.03 148.23,73.03 148.23,73.04 147.96,73.04 147.92,73.01 147.84,72.98 147.77,73 147.7,73.07 147.66,73.13 147.66,73.23 147.69,73.28 147.7,73.32 147.93,73.55 147.99,73.59 148.04,73.64 148.5,73.64 148.58,73.56 148.63,73.56 148.64,73.56 148.75,73.53 148.86,73.56 148.87,73.56 148.91,73.56 149.06,73.71 149.06,73.97 149.16,74.07 149.74,74.07
GND on BOTTOM (solid shape): 232.83,68.76 232.85,68.76 232.87,68.75 232.99,68.62 232.99,68.17 232.92,68.07 232.81,68.1 232.23,68.12 232.29,67.55 232.34,67.47 232.3,67.39 232.53,66.82 232.74,67.4 232.7,67.48 232.74,67.56 232.78,67.59 232.81,67.62 232.92,67.65 232.99,67.56 232.99,66.45 232.84,66.3 230.96,66.3 230.2,67.06 230.2,68.4 230.56,68.76
GND on BOTTOM (solid shape): outline of 226 points within 201.33,48.24 208.36,53.98
GND on BOTTOM (solid shape): outline of 241 points within 267.33,12.6 275.04,19.19
GND on BOTTOM (solid shape): outline of 511 points within 0.2,84.08 59.32,112.3
GND on BOTTOM (solid shape): outline of 100 points within 69.61,96.69 231.4,112.9
GND on BOTTOM (solid shape): outline of 955 points within 4.48,0.2 305.8,80.15
GND on BOTTOM (solid shape): outline of 3155 points within 121.68,10.09 143.8,22.63
GND on BOTTOM (solid shape): outline of 3252 points within 204.08,10.09 226.27,23.37
GND on BOTTOM (solid shape): outline of 3592 points within 78.24,10.01 105.44,21.64
GND on BOTTOM (solid shape): outline of 4001 points within 145.53,10.03 187.55,23.73
GND on BOTTOM (solid shape): outline of 5136 points within 242.61,18.2 306.1,112.46
GND on IN1 (solid shape): 98.79,67.16 98.79,64.34 98.41,63.96 96.18,63.96 95.57,64.57 95.57,66.76 96.25,67.44 97.85,67.44 97.88,67.47 98.49,67.47
GND on IN1 (solid shape): 269.72,50 265.97,50 265.82,50.14 265.82,51.79 266.1,52.07 266.55,52.07 266.74,52.26 269.72,52.26
GND on IN1 (solid shape): 92.72,76.71 92.72,73.51 92.37,73.16 90.79,73.16 90.54,73.41 90.54,75.03 90.4,75.16 90.4,76.79 90.58,76.96 90.78,76.96 90.79,76.97 92.47,76.97
GND on IN1 (solid shape): outline of 491 points within 0.2,90.31 65.91,112.3
GND on IN1 (solid shape): outline of 894 points within 133.23,10.14 156.32,22.41
GND on IN1 (solid shape): outline of 157 points within 4.61,0.2 305.8,80.15
GND on IN1 (solid shape): outline of 2650 points within 184.12,13.47 224.45,23.42
GND on IN1 (solid shape): outline of 6642 points within 69.61,18.2 306.1,112.9
GND on IN2 (solid shape): 92.47,76.79 92.47,73.31 92.14,72.98 90.72,72.98 90.33,73.36 90.33,76.79 90.61,77.07 92.19,77.07
GND on IN2 (solid shape): 98.62,66.6 98.62,63.93 96.65,61.95 96.33,61.95 95.69,62.59 95.69,66.81 96.23,67.34 97.88,67.34
GND on IN2 (solid shape): 269.72,50 266.37,50 265.89,50.47 265.89,51.94 266.08,52.12 266.81,52.12 266.95,52.26 269.72,52.26
GND on IN2 (solid shape): 260.21,82.74 260.21,81.58 260.9,80.89 260.9,80.66 260.82,80.58 260.59,80.58 260.39,80.39 260.39,80.24 260.37,80.12 260.39,79.99 260.39,79.56 259.93,79.1 256.48,79.1 256.22,79.35 256.22,80.45 256.45,80.67 256.45,82.68 257.11,83.34 259.6,83.34
GND on IN2 (solid shape): outline of 363 points within 0.2,90.31 59.32,112.3
GND on IN2 (solid shape): outline of 163 points within 4.61,0.2 305.8,80.15
GND on IN2 (solid shape): outline of 2334 points within 69.61,18.2 306.1,112.9
GND on IN2 (solid shape): outline of 10946 points within 78.65,10.11 225.82,21.66
GND on IN3 (solid shape): 92.47,76.74 92.47,73.59 92.01,73.13 90.66,73.13 90.46,73.33 90.46,76.84 90.64,77.02 92.19,77.02
GND on IN3 (solid shape): 98.69,66.81 98.69,64.27 98.44,64.01 96.4,64.01 96.05,64.37 96.05,66.98 96.4,67.34 98.16,67.34
GND on IN3 (solid shape): 269.72,50.4 269.44,50.11 268.89,50.11 268.78,50 266.04,50 265.95,50.09 265.95,52.15 266.69,52.15 266.8,52.26 269.72,52.26
GND on IN3 (solid shape): outline of 364 points within 0.2,90.31 59.32,112.3
GND on IN3 (solid shape): outline of 2287 points within 69.61,18.2 306.1,112.9
GND on IN3 (solid shape): outline of 12012 points within 4.48,0.2 305.8,80.15
GND on IN4 (solid shape): 98.69,66.09 98.69,60.84 98.11,60.25 96.38,60.25 96,60.63 96,66.78 96.2,66.98 97.8,66.98
GND on IN4 (solid shape): 92.54,75.85 92.54,70.84 92.11,70.41 90.38,70.41 89.57,71.23 89.57,75.05 90.79,76.26 92.14,76.26
GND on IN4 (solid shape): 269.62,51.97 269.62,50.14 269.48,50 266.02,50 265.83,50.18 265.83,51.45 265.89,51.6 265.87,51.77 265.87,51.95 266.05,52.13 266.53,52.13 266.66,52.26 269.33,52.26
GND on IN4 (solid shape): outline of 364 points within 0.2,90.31 59.32,112.3
GND on IN4 (solid shape): outline of 172 points within 4.61,0.2 305.8,80.15
GND on IN4 (solid shape): outline of 2592 points within 69.61,18.2 306.1,112.9
GND on GND1: outline of 496 points within 0.2,0.2 306.1,112.9
GND on GND2: outline of 492 points within 0.2,0.2 306.1,112.9
GND on VCC: outline of 89 points within 1.17,69.74 102.48,111.33
GND on VCC: 60.26,85.96 58.84,87.38 58.84,87.41 58.77,87.45 58.71,87.51 58.69,87.51 58.59,87.57 58.58,87.6 58.41,87.71 58.38,87.71 58.38,87.71 57.95,88.06 57.95,90.05 59.24,91.34 64.02,91.34 64.3,91.06 64.3,86.37 63.89,85.96
GND on VCC: 78.64,50.4 78.29,50.74 78.29,57.87 75.2,60.97 75.2,64.79 74.36,65.62 74.36,68.94 73.21,70.09 73.21,74.85 74.36,76 74.84,76 75.89,74.94 75.89,73.52 79.59,69.83 85.76,69.83 87.19,68.4 87.19,68.04 86.27,67.13 86.27,66.07 86.57,65.76 86.57,64.75 86.45,64.62 86.45,63.53 87.03,62.94 87.03,62.11 86.85,61.93 83.52,61.93 82.43,60.84 82.43,57.73 82.89,57.28 87.12,57.27 88.87,59.02 90.77,59.02 91.43,59.68 93.71,59.68 94.61,58.79 94.61,55.26 94.53,55.18 93.48,55.18 93.18,54.88 93.18,51.87 91.7,50.4
GND on VCC: 45.25,9.97 43.96,10.5 43.42,11.8 43.42,12.55 43.84,13.72 44.92,14.35 53.79,17.51 61.19,23.33 61.95,23.33 69.97,15.31 76.89,15.31 78.35,16.77 78.35,28.13 78.83,28.61 78.86,28.61 78.87,28.63 88.25,28.63 98.34,38.71 100.02,38.71 113.68,52.38 113.68,55.86 121.22,63.4 126.63,63.4 128.23,65 131.89,65 133.01,63.88 137.32,63.88 137.6,63.6 137.6,61.82 138.67,60.76 144.67,60.76 144.8,60.89 145.75,60.89 145.88,60.76 161.68,60.76 163.16,60.75 163.26,60.75 163.72,60.29 163.72,57.65 165.19,56.18 165.62,56.18 168.78,53.02 169.13,53.04 171.31,53.04 171.94,52.4 177.15,52.4 180.7,48.85 188.57,48.85 190.45,46.97 203.18,46.97 203.71,46.44 203.73,46.42 203.89,46.26 203.89,46.26 209.78,40.37 209.79,40.37 223.92,26.24 223.92,24.77 224.19,24.49 224.3,24.24 224.55,24.13 226.34,22.34 226.34,10.32 225.99,9.97
GND on GND3: outline of 508 points within 0.2,0.2 306.1,112.9
GNDA on TOP (solid shape): 291.24,44.05 291.24,42.3 291.06,42.11 289.87,42.11 289.72,42.27 289.72,44.11 289.87,44.26 291.03,44.26
GNDA on TOP (solid shape): 288.01,41.38 288.49,41.38 288.49,41.91 288.78,41.91 288.78,40.62 288.66,40.49 287.79,40.49 287.72,40.57 287.72,41.91 288.01,41.91
GNDA on TOP (solid shape): 282.78,37.29 282.78,36.96 282.61,36.78 281.46,36.78 281.41,36.73 281.41,36.16 281.34,36.1 281.28,36.1 281.21,36.17 281.21,36.94 281.62,37.35 282.72,37.35
GNDA on TOP (solid shape): 292.23,31.75 292.23,30.25 291.84,29.87 291.2,29.87 290.41,29.08 288.65,29.08 288.28,29.45 288.28,31.57 288.52,31.81 292.16,31.81
GNDA on TOP (solid shape): 282.96,31.68 283.14,31.68 283.72,31.09 283.72,30.84 283.58,30.69 283.42,30.69 283.02,31.1 283.02,31.15 282.66,31.51 282.6,31.51 282.53,31.58 281.8,31.58 281.76,31.62 281.76,31.76 281.79,31.79 282.85,31.79
GNDA on TOP (solid shape): 285.76,27.84 285.76,27.59 285.77,27.58 285.77,27 285.71,26.94 285.13,26.94 285.12,26.93 284.69,26.93 284.5,27.12 284.3,27.12 284.29,27.13 283.91,27.13 283.88,27.16 283.88,27.61 283.91,27.64 284.75,27.64 284.82,27.72 284.82,28.05 284.97,28.2 285.41,28.2
GNDA on GND1: outline of 137 points within 279.26,7.83 305.8,41.76
GNDA on GND2: outline of 129 points within 279.26,7.83 305.8,41.76
GNDA on VCC: outline of 97 points within 279.26,7.83 304.78,41.76
GNDA on GND3: outline of 128 points within 279.26,7.83 305.8,41.76
VCCSA_B+ on TOP (solid shape): 106.46,81.59 106.46,80.83 106.41,80.78 105.88,80.78 105.8,80.7 105.8,79.66 105.68,79.53 103.57,79.53 103.21,79.89 103.21,81.56 103.29,81.64 106.41,81.64
VCCSA_B+ on BOTTOM (solid shape): 106.54,81.44 106.54,80.88 106.5,80.84 105.84,80.84 105.8,80.8 105.8,78.36 105.55,78.11 105.29,78.11 105.29,78.64 104.8,78.64 104.8,78.11 104.3,78.11 103.82,78.59 103.82,81.33 103.95,81.46 106.51,81.46
VDD_1.2V on BOTTOM (solid shape): 94.97,52.14 94.97,51.83 95.03,51.77 95.03,51.74 95.06,51.74 95.29,51.52 96.84,51.52 96.84,50.66 97.14,50.36 97.14,50.27 97.07,50.19 94.83,50.19 94.65,50.37 94.65,50.98 94.35,51.29 93.46,51.29 93.22,51.52 93.22,51.7 93.28,51.79 93.31,51.89 93.33,52.17 93.15,52.38 93.15,53.17 93.2,53.22 93.89,53.22
VIN_1.8VALW on TOP (solid shape): 211.67,106.37 211.67,101.23 211.34,101.23 211.34,101.78 210.79,101.78 210.79,101.23 210.54,101.23 210.54,101.79 209.99,101.79 209.99,101.23 209.28,101.23 209.23,101.27 209.23,102.44 210.02,103.23 210.02,106.24 210.3,106.52 211.52,106.52
VIN_1.8VALW on BOTTOM (solid shape): 211.68,106.24 211.68,104.13 211.57,104.02 210.48,104.02 210.3,104.19 210.3,104.42 210.58,104.7 210.58,106.23 210.72,106.37 211.56,106.37
VIN_1V_PRIM on TOP (solid shape): 203.08,75.39 203.08,73.84 202.83,73.59 202.71,73.59 202.5,73.38 201.23,73.38 201.03,73.59 201.03,73.84 201.31,74.12 201.31,75.21 201.59,75.49 202.98,75.49
VIN_1V_PRIM on BOTTOM (solid shape): 203.06,75.3 203.06,73.61 202.42,72.98 202.42,71.78 202.35,71.71 201.15,71.71 201.05,71.81 201.05,72.55 201.07,72.57 201.08,72.58 201.29,72.8 201.27,73.1 201.26,73.11 201.26,73.3 201.26,73.31 201.26,73.36 201.04,73.57 201.04,73.81 201.21,73.98 201.21,74.49 200.7,74.49 200.66,74.5 200.65,74.54 200.65,74.67 200.66,74.7 200.7,74.72 201.21,74.72 201.21,75.06 201.25,75.1 201.34,75.1 201.6,75.36 201.64,75.36 203,75.36
VIN_1VS_VCCIO on TOP (solid shape): 207.29,54.46 207.8,54.46 208.27,54 208.27,52.71 208.16,52.61 206.13,52.61 206.13,54.05 206.55,54.46 207.06,54.46 207.06,55.02 207.29,55.02
VIN_1VS_VCCIO on BOTTOM (solid shape): 208.32,54.45 208.32,52.79 208.16,52.63 207.2,52.63 207.17,52.61 205.95,52.61 205.47,52.12 204.71,52.12 204.56,52.28 204.56,53.34 204.68,53.47 205.88,53.47 206.11,53.7 206.11,53.92 206.64,54.45 206.64,54.47 206.85,54.68 208.09,54.68
+BL_PWR_SRC on TOP (solid shape): 90.87,86.24 90.87,85.63 90.77,85.53 89.87,85.53 89.87,85.52 89.83,85.48 89.81,85.47 89.8,85.47 89.4,85.18 89.63,84.74 89.65,84.72 89.66,84.7 89.66,83.58 89.68,83.56 89.68,82.82 89.45,82.6 87.84,82.6 87.61,82.82 87.61,83.71 88.13,84.23 88.13,84.55 88.12,84.55 88.12,84.87 88.15,84.91 88.18,84.97 88.23,85.02 88.21,85.03 88.2,85.06 88.2,85.07 88.09,85.38 87.78,85.49 87.77,85.48 87.75,85.49 87.58,85.66 87.58,86.17 87.71,86.3 88.15,86.3 88.26,86.41 90.69,86.41
+BL_PWR_SRC on BOTTOM (solid shape): 89.42,87.02 89.42,85.48 89.42,85.48 89.42,85.24 89.39,85.09 89.42,84.96 89.42,84.96 89.42,84.36 89.67,84.1 90.1,84.1 90.24,84.08 90.37,84.1 90.38,84.1 90.54,84.1 90.72,84.28 92.14,84.28 92.39,84.03 92.39,82.71 92.11,82.43 88.66,82.43 88.55,82.43 88.07,82.9 88.07,84.22 88.18,84.33 88.18,85.07 88.18,85.07 88.16,85.22 88.08,85.36 88.07,85.38 88.07,87.02 88.2,87.15 89.29,87.15
+CRT_VCC on BOTTOM (solid shape): 250.13,103.38 250.13,99.27 249.62,98.76 246.49,98.76 246.32,98.94 246.32,99.93 246.6,100.22 247.15,100.22 247.23,100.21 247.37,100.23 247.68,100.23 247.68,100.23 247.81,100.21 247.94,100.23 247.95,100.23 248.6,100.23 248.96,100.59 248.96,101.93 248.96,102.52 248.8,102.67 246.87,102.67 246.7,102.85 246.7,104.75 247,105.06 248.45,105.06
+CRT_VCC on IN4 (solid shape): outline of 541 points within 236.05,103.61 248.04,107.49
+DC_IN on TOP (solid shape): 42.86,92.23 42.86,90.35 42.73,90.22 41.64,90.22 41.34,89.92 41.34,88.24 41.87,87.71 42.33,87.71 42.68,87.35 42.68,86.06 42.51,85.88 41.9,85.88 41.74,86.03 41.74,86.19 41.06,86.87 37.86,86.87 37.48,86.49 37.48,85.7 37.32,85.55 35.62,85.55 35.5,85.68 35.5,86.36 35.95,86.82 35.95,88.98 36.02,89.04 36.02,91.15 37.22,92.36 42.73,92.36
+DC_IN_SS on TOP (solid shape): 60.14,10.99 60.14,10.38 59.93,10.18 58.43,10.18 58.31,10.29 58.31,10.97 58.5,11.16 59.96,11.16
+DC_IN_SS on TOP (solid shape): outline of 98 points within 33.31,76.53 39.31,85.22
+DCIN on BOTTOM (solid shape): 60.59,86.9 60.59,86.09 60.57,86.06 60.51,86.03 60.13,85.65 60.13,85.65 60.03,85.55 60.03,84.13 59.98,84.08 57.19,84.08 56.93,84.33 56.93,86.03 57.11,86.21 57.97,86.21 57.99,86.22 58.03,86.22 58.33,86.08 58.63,86.22 59.54,86.22 60.24,86.92 60.57,86.92
+DCIN_JACK on TOP (solid shape): 51.55,92.04 51.55,89.45 50.98,88.88 45.27,88.88 45.1,89.06 45.1,90 44.82,90.28 43.42,90.28 43.17,90.53 43.17,91.98 43.55,92.36 51.23,92.36
+DCIN_JACK on BOTTOM (solid shape): 45.78,91.34 52.77,91.34 52.87,91.24 52.87,88.95 52.78,88.86 43.02,88.86 42.86,89.02 42.86,92.1 43.17,92.41 44.72,92.41
+DOCK_PWR_BAR on TOP (solid shape): 77.44,19.38 77.53,19.05 77.84,18.93 77.84,16.95 77.79,16.9 77.1,16.6 76.8,15.91 76.69,15.8 74.15,15.8 73.98,15.98 73.98,19 74.36,19.38 77.43,19.38
+DOCK_PWR_BAR on TOP (solid shape): outline of 87 points within 172.81,101.43 179.79,107.27
+DOCK_PWR_BAR on TOP (solid shape): outline of 859 points within 95.49,87.43 133.97,107.75
+DOCK_PWR_BAR on BOTTOM (solid shape): outline of 258 points within 117.24,94.16 135.85,107.95
+DOCK_PWR_BAR on VCC: 126.94,97.11 126.33,97.72 126.33,100.64 124.4,102.57 117.54,102.57 117.71,103.4 117.8,104.25 117.82,104.27 117.82,107.57 119.26,107.57 119.26,108.78 122.23,108.78 122.28,108.83 123.99,109.71 124.87,111.42 124.92,111.47 124.92,111.93 181.58,111.93 181.58,110.72 181.63,110.67 182.51,108.96 184.22,108.08 184.27,108.03 188.68,108.03 188.68,104.27 188.7,104.25 188.87,102.95 189.25,101.69 188.1,100.54 175.19,100.54 172.45,97.79 171.25,97.79 170.76,98.28 165.13,98.28 164.32,97.47 148.55,97.47 148.19,97.11
+DOCK_PWR_BAR on VCC: 70.18,15.82 62.11,23.89 62.11,24.37 62.31,24.62 62.51,24.87 64.63,26.41 65.24,28.95 68.01,36.01 68.87,43.55 68.24,50.09 66.17,56.32 66.02,56.69 65.91,57.07 65.9,57.07 65.78,58.2 66.01,59.31 66.11,59.6 66.19,60.81 65.61,61.87 58.02,69.45 57.95,69.53 57.95,86.47 58.31,86.91 58.36,87 58.5,87 60.05,85.45 64.1,85.45 64.81,86.16 64.81,91.21 65.38,91.78 66.45,91.78 66.89,91.34 90.31,91.34 92.14,93.17 98.92,93.17 99.53,92.56 99.53,85.4 99.06,84.94 91.47,84.94 90.64,84.11 90.64,81.72 90.41,81.49 75.6,81.49 74.69,80.58 74.69,77.05 72.71,75.06 72.71,69.88 73.85,68.73 73.85,65.41 74.69,64.58 74.69,60.76 77.79,57.66 77.79,33.94 77.05,33.21 77.05,29.57 77.84,28.78 77.84,28.34 77.83,28.33 77.83,28.12 77.84,28.12 77.84,16.98 76.67,15.82
+EDP_VDD on BOTTOM (solid shape): 95.5,83.67 95.54,83.66 95.55,83.62 95.55,83.11 95.9,83.11 95.92,83.11 95.94,83.1 95.97,83.06 95.97,82.87 95.34,82.24 95.34,80.91 95.24,80.81 94.64,80.81 94.58,80.88 94.58,81.46 94.61,81.49 94.61,81.78 94.67,81.93 94.67,82.09 94.66,82.1 94.67,82.13 94.74,82.2 94.76,82.2 94.76,82.93 94.94,83.11 95.32,83.11 95.32,83.62 95.34,83.66 95.37,83.67
+LCDVDD on TOP (solid shape): 85.37,87.85 85.37,87.36 85.07,87.06 85.07,85.63 84.07,84.62 82.93,84.62 82.13,85.43 82.13,87.58 82.26,87.71 82.76,87.71 83.28,87.2 83.78,87.2 83.87,87.29 83.88,87.29 84,87.41 84,87.81 84.09,87.9 84.54,87.9 84.6,87.96 85.26,87.96
+LCDVDD on BOTTOM (solid shape): 82.89,87.58 82.89,85.81 83.15,85.55 83.65,85.55 83.78,85.42 83.78,84.92 83.65,84.79 82.64,84.79 82.56,84.87 82.55,84.88 82.46,85.02 82.32,85.11 82.31,85.11 82.13,85.3 82.13,87.58 82.26,87.71 82.76,87.71
+LCDVDD on BOTTOM (solid shape): 97.11,84.8 97.23,84.77 97.35,84.77 97.37,84.77 97.39,84.76 97.5,84.65 97.5,83.73 97.01,83.24 95.74,83.24 95.71,83.25 95.69,83.29 95.69,83.8 95.67,83.82 95.21,83.82 95.19,83.8 95.19,83.29 95.13,83.24 94.6,83.24 94.59,83.25 94.25,83.25 94.23,83.26 94.22,83.27 94.03,83.46 94.03,84.21 93.84,84.39 93.84,84.67 93.97,84.8 97.1,84.8
+LCDVDD on IN3 (solid shape): 83.35,87.25 83.35,86.29 84.74,84.9 84.8,84.78 84.9,84.69 84.9,84.49 85.39,84 90.66,84 91.48,84.81 95.26,84.81 95.49,84.59 95.49,83.47 94.8,82.78 92.77,82.78 92.24,82.25 84.57,82.25 84.38,82.44 84.38,83.62 84.03,83.97 83.23,83.97 83.22,83.95 82.86,83.95 82.47,84.35 82.44,84.42 82.47,84.49 82.51,84.54 82.54,84.59 82.52,84.95 82.2,85.13 82.17,85.15 82.16,85.18 82.16,87.51 82.33,87.68 82.92,87.68
+PBATT on TOP (solid shape): 72.6,28.51 72.6,22.35 71.68,21.43 69.73,21.43 68.21,22.95 64.61,22.95 64.13,23.43 64.13,25.44 64.53,25.85 64.56,25.85 67.87,29.16 71.96,29.16
+PBATT on BOTTOM (solid shape): 73.06,29.51 73.06,27.13 72.47,26.54 69.58,26.54 67.88,24.84 67.22,24.84 66.42,25.64 66.42,28.23 68.9,30.71 71.86,30.71
+PECI_VREF on TOP (solid shape): 261.66,57.36 261.66,57.1 261.28,56.72 261.28,55.41 260.97,55.1 260.97,54.31 260.84,54.18 260.31,54.18 260.18,54.06 259.68,54.06 259.64,54.09 259.05,54.09 258.8,54.34 258.8,55.72 258.92,55.85 259.49,55.85 261.1,57.46 261.56,57.46
+PWR_SRC on TOP (solid shape): 229.72,60.34 229.72,59.7 229.63,59.61 229.16,59.61 229.16,59.06 228.91,59.06 228.91,59.61 228.36,59.61 228.36,59.06 228.11,59.06 228.11,59.61 227.7,59.61 227.6,59.72 227.6,60.25 227.79,60.44 229.61,60.44
+PWR_SRC on TOP (solid shape): 85.94,60.39 85.94,58.76 85.54,58.35 84.71,58.35 84.71,57.8 84.46,57.8 84.46,58.35 83.91,58.35 83.91,57.8 83.66,57.8 83.66,58.35 83.17,58.35 83.15,58.38 83.15,59.3 84.55,60.7 85.64,60.7
+PWR_SRC on TOP (solid shape): 88.54,81.5 88.54,78.7 88.34,78.51 87.65,78.51 87.65,79.06 86.95,79.06 86.95,78.51 86.45,78.51 86.45,79.06 85.75,79.06 85.75,78.51 85.05,78.51 83.91,77.37 77.23,77.37 76.97,77.63 76.97,78.41 76.62,78.77 76.62,79.35 78,79.35 78.36,79.71 78,80.07 76.72,80.07 76.62,80.17 76.62,80.65 76.97,81 83.6,81 84.26,81.66 88.37,81.66
+PWR_SRC on BOTTOM (solid shape): 89.99,81.97 89.99,81.5 89.26,80.77 89.26,78.79 89.15,78.68 88.43,78.68 88.07,79.05 85.9,79.05 84.23,77.37 73.39,77.37 73.24,77.52 73.24,80.98 73.34,81.08 83.81,81.08 84.23,81.5 85.73,81.5 86.03,81.8 87.99,81.8 88.32,82.12 89.84,82.12
+PWR_SRC on BOTTOM (solid shape): 229.18,71.09 229.18,70.55 229.2,70.53 229.69,70.53 230.05,70.16 230.05,66.98 230.6,66.43 230.6,65.34 230.53,65.28 229.23,65.28 229.13,65.39 229.13,65.51 229.2,65.74 229.13,65.96 229.13,66.48 229.13,66.49 229.14,66.59 229.13,66.7 229.13,66.71 229.13,67.38 228.87,67.64 228.6,67.64 228.51,67.72 228.51,67.73 228.32,67.92 227.34,67.92 227.32,67.9 227.25,67.9 227.25,67.82 227.23,67.81 227.23,67.37 227.23,67.36 226.98,67.36 226.98,67.37 226.98,67.91 226.97,67.92 226.49,67.92 226.47,67.9 226.45,67.9 226.45,67.88 226.43,67.86 226.43,67.38 226.42,67.36 226.18,67.36 226.16,67.38 226.16,67.87 226.16,67.87 226.16,67.9 226.13,67.9 226.1,67.93 225.6,67.93 225.55,67.87 225.55,67.55 225.44,67.44 225.44,67.44 225,67.01 224.09,67.01 224.01,67.09 224.01,67.59 224.17,67.75 224.7,67.75 224.91,67.96 224.91,69.28 226.15,70.53 228.13,70.53 228.14,70.54 228.14,71.07 228.16,71.09 228.35,71.09 228.37,71.07 228.37,70.55 228.39,70.53 228.92,70.53 228.93,70.53 228.93,71.09 228.94,71.09 229.17,71.09
+PWR_SRC on BOTTOM (solid shape): outline of 3536 points within 77.74,23.5 239.62,51.11
+PWR_SRC on IN2 (solid shape): outline of 1607 points within 225.08,46.94 237.73,69.29
+PWR_SRC on IN3 (solid shape): outline of 1744 points within 224.65,46.92 242.49,70.36
+PWR_SRC on VCC: 102.83,54.67 102.83,44.55 102.84,42.25 99.8,39.22 98.13,39.22 88.04,29.14 78.2,29.14 77.56,29.78 77.56,32.99 78.29,33.73 78.29,49.56 78.63,49.89 91.55,49.89 92.08,49.45 92.16,50.14 93.69,51.66 93.69,54.67 93.69,54.68 94.74,54.68 95.11,55.05 95.11,59 93.92,60.19 91.22,60.19 90.56,59.53 88.66,59.53 86.91,57.78 83.1,57.79 82.94,57.94 82.94,60.63 83.73,61.42 87.06,61.42 87.54,61.9 87.54,63.15 86.96,63.74 86.96,64.41 87.08,64.54 87.08,65.97 86.78,66.28 86.78,66.92 87.69,67.83 87.69,68.61 85.97,70.34 79.8,70.34 76.4,73.73 76.4,75.15 75.2,76.35 75.2,80.37 75.81,80.98 90.41,80.98 92.82,78.57 100.44,78.57 100.6,78.41 100.6,70.38 101.08,69.9 101.08,69.89 101.11,69.86 101.12,69.83 101.18,69.79 101.23,69.74 101.24,69.74 101.25,69.73 101.29,69.73 101.32,69.71 101.39,69.73 101.46,69.73 101.48,69.74 102.56,69.74 102.83,69.47 102.83,60.02 102.83,55.05
+PWR_SRC_AC on TOP (solid shape): 53.57,83.48 53.57,80.79 53.33,80.55 47.18,80.55 46.98,80.75 46.98,81.49 47,81.51 48.36,81.51 48.72,81.87 48.36,82.22 46.98,82.22 46.85,82.35 46.85,83.9 47.2,84.26 52.79,84.26
+PWR_SRC_AC on TOP (solid shape): 118.24,102.98 119.3,102.59 120.43,102.49 120.5,102.46 120.53,102.38 120.53,99.85 120.74,99.65 122.26,99.65 122.36,99.55 122.36,96.42 122.2,96.26 117.42,96.26 117.31,96.37 117.31,97.74 116.65,98.4 116.65,100.14 116.95,100.44 116.95,100.77 117.15,100.97 117.15,101.28 117.49,101.62 117.49,102.16 117.73,102.4 117.73,102.85 117.86,102.98
+PWR_SRC_AC on BOTTOM (solid shape): 53.71,83.06 53.71,78.73 53.64,78.66 52.98,78.66 52.98,78.13 52.53,78.13 52.53,78.66 51.78,78.66 51.78,78.13 51.33,78.13 51.33,78.66 49.5,78.66 47.64,80.52 47.1,80.52 46.85,80.78 46.85,83.39 47.41,83.95 52.82,83.95
+PWR_SRC_AC on BOTTOM (solid shape): 118.2,103.01 119.78,102.51 121.43,102.65 121.79,102.65 121.82,102.62 121.82,100.83 120.79,99.8 117.21,99.8 116.98,100.03 116.98,100.73 117.16,100.91 117.16,101.24 117.45,101.53 117.45,101.99 117.69,102.24 117.69,102.77 117.92,103.01
+PWR_SRC_AC on VCC: 50.94,81.66 50.38,82.23 50.38,91.24 57.11,97.97 79.26,97.97 80.28,98.99 102.91,98.99 111.03,96.37 117.39,102.06 124.19,102.06 125.82,100.43 125.82,96.96 125.43,96.57 125.43,95.84 124.46,94.88 119.04,94.88 115.24,91.08 112.47,91.08 106.33,84.94 100.37,84.94 100.04,85.28 100.04,92.77 99.13,93.68 91.93,93.68 90.1,91.85 67.1,91.85 66.66,92.28 65.17,92.28 64.73,91.85 59.03,91.85 57.44,90.26 57.44,86.64 57.43,86.63 57.44,86.54 57.44,82.05 57.06,81.66 ; 1 cut-out
+REGCTL_PNP10 on BOTTOM (solid shape): 259.8,87.12 259.75,86.92 259.81,86.72 259.81,86.22 259.74,86.16 259.74,86.11 259.42,85.79 258.28,85.79 258.18,85.89 258.18,87.1 258.22,87.15 259.77,87.15
+RSVD_VCC3P3_1 on TOP (solid shape): 258.81,92.34 258.81,92.06 259.89,90.97 259.89,90.39 261,89.28 261.58,89.28 261.66,89.21 261.66,89.08 261.58,89.01 260.46,89.01 258.46,91.01 258.46,91.62 258.36,91.72 257.9,91.72 257.8,91.82 257.8,92.43 257.92,92.56 258.58,92.56
+RTC_CELL on TOP (solid shape): 279.24,58.21 279.24,57.43 278.85,57.04 278.3,57.04 277.95,56.7 276.26,56.7 276.24,56.72 276.24,57.2 276.29,57.26 277.83,57.26 278.38,57.8 278.38,58.23 278.49,58.34 279.11,58.34
+RTC_CELL on IN1 (solid shape): outline of 365 points within 161.28,55.63 163.16,61.4
+SDC_IN on TOP (solid shape): 46.01,83.49 46.01,82.28 45.96,82.22 44.6,82.22 44.25,81.87 44.6,81.51 45.99,81.51 45.99,80.55 43.65,78.21 43.65,76.94 43.12,76.41 41.48,76.41 41.47,76.41 41.34,76.43 41.21,76.41 41.2,76.41 41.11,76.41 40.63,75.92 40.55,75.92 40.55,75.93 40.34,75.93 40.34,75.92 38.87,75.92 38.54,76.25 38.54,79.91 38.78,80.15 41.01,80.15 41.97,81.11 41.97,83.26 42.38,83.67 45.83,83.67
+SDREG2 on TOP (solid shape): 264.12,40.03 264.17,40.02 264.22,40.01 264.43,40.01 264.61,39.83 264.61,39.83 265.19,39.25 265.19,39.25 265.32,39.13 265.85,39.13 266,38.98 266,38.41 265.14,37.55 264.71,37.55 264.5,37.75 264.5,38.71 264.1,39.12 263.99,39.12 263.79,39.32 263.79,39.96 263.87,40.03
+USB_LEFT_PWR on BOTTOM (solid shape): 20.28,94.06 20.28,91.44 19.77,90.94 19.77,90.12 17.61,87.96 15.15,87.96 14.74,88.37 14.74,90.81 15.48,91.55 15.48,94.21 16.09,94.82 19.52,94.82
+USB_REAR_PWR on TOP (solid shape): 76.85,104.3 76.85,101.32 74.87,99.34 74.87,95.86 74.03,95.03 74.03,92.18 73.62,91.77 72.53,91.77 72.2,92.1 72.2,93.55 71.67,94.09 71.67,96.75 70.24,98.17 67.73,98.17 67.47,98.43 67.47,100.1 67.76,100.38 72.78,100.38 73.37,100.97 73.37,102.8 73.34,102.82 73.34,104.32 73.65,104.63 76.52,104.63
+V_DDR_REF on BOTTOM (solid shape): 93.38,57.13 93.38,56.9 93,56.52 93,55.48 92.94,55.41 92.79,55.41 92.72,55.48 92.72,56.87 92.82,56.98 92.82,57.13 92.98,57.28 93.23,57.28
+VCHGR on TOP (solid shape): 72.47,36.16 72.47,29.59 72.4,29.52 68.84,29.52 68.46,29.9 68.46,36.45 69.11,37.1 71.53,37.1
+VCHGR on TOP (solid shape): 75.61,80.92 75.61,80.08 75.6,80.07 74.24,80.07 73.89,79.71 74.24,79.35 75.6,79.35 75.63,79.33 75.63,78.77 75.98,78.41 76.69,78.41 76.75,78.36 76.75,77.5 76.62,77.37 70.62,77.37 70.47,77.52 70.47,81.03 71,81.56 74.97,81.56
+VCHGR on BOTTOM (solid shape): 71.86,37.14 71.86,32.69 71.39,32.23 68.73,32.23 68.23,32.72 68.23,36.6 69.78,38.15 70.85,38.15
+VCHGR on IN3 (solid shape): outline of 2079 points within 64.1,33.38 81.57,83.58
+VHDMI_VCC on TOP (solid shape): 92.7,100.27 92.7,98.71 92.57,98.58 91.67,98.58 91.45,98.8 90.99,98.8 90.94,98.84 90.94,99.59 90.66,99.87 90.66,100 90.97,100.31 90.97,100.31 91.24,100.57 92.4,100.57
+VHDMI_VCC on BOTTOM (solid shape): outline of 163 points within 90.26,94.11 105.6,102.63
+VLDOIN_1.2V on BOTTOM (solid shape): 88.39,56.27 88.87,56.27 88.87,56.82 89.19,56.82 90.31,55.71 90.31,54.99 90.44,54.87 91.32,54.87 91.4,54.79 91.4,54.66 91.32,54.59 90.41,54.59 89.98,55.02 88.81,55.02 88.12,55.71 88.12,56.82 88.39,56.82
BOOT_1.2V on BOTTOM (solid shape): 90.23,54.46 91.3,54.46 91.38,54.39 91.38,54.26 91.32,54.21 90.54,54.21 90.49,54.26 90.34,54.26 90.31,54.28 90.24,54.28 90.24,54.29 90.11,54.31 89.98,54.29 89.97,54.28 89.66,54.28 89.65,54.29 89.52,54.31 89.39,54.29 89.38,54.28 89.29,54.28 89.11,54.11 89.09,54.08 89.09,53.88 89.06,53.85 88.45,53.85 88.38,53.93 88.38,54.79 88.43,54.84 89.85,54.84
BST_3V on BOTTOM (solid shape): 220.43,74.32 220.43,72.57 220.33,72.47 220.23,72.47 220.1,72.6 220.1,72.8 219.67,73.23 218.02,73.23 217.87,73.38 217.87,74.32 217.97,74.43 220.33,74.43
BST_5V on BOTTOM (solid shape): 221.69,66.58 221.69,66.27 222.16,65.79 222.16,63.22 222.08,63.15 221.96,63.15 221.86,63.25 221.86,64.06 221.22,64.7 221.19,64.73 221.19,65.61 221.12,65.68 221.12,66.62 221.29,66.78 221.49,66.78
BST_+1VALWP on TOP (solid shape): 226.96,52.66 226.96,51.97 226.62,51.64 226.62,50.84 226.57,50.78 225.35,50.78 224.93,51.2 224.93,52.62 225.07,52.76 226.86,52.76
BST_+1VALWP_C on TOP (solid shape): 226.96,54.07 226.96,53.56 226.94,53.39 226.93,53.2 226.83,53.1 225.08,53.1 224.98,53.2 224.98,54.14 225.03,54.19 226.83,54.19
CHAGER_SRC on TOP (solid shape): 60.44,77.96 60.44,74.71 60.21,74.48 53.68,74.48 53.45,74.71 53.45,77.4 53.94,77.88 58.53,77.88 58.71,78.06 60.34,78.06
CHAGER_SRC on BOTTOM (solid shape): 51.21,78 51.91,78 51.91,78.53 52.41,78.53 52.41,78 53.11,78 53.11,78.53 53.67,78.53 54.29,77.91 58.05,77.91 58.18,77.78 58.18,77.07 58.51,76.74 63.83,76.74 63.94,76.62 63.94,75.91 63.92,75.88 62.48,75.11 62.48,74.13 62.17,73.82 56.75,73.82 56.43,74.13 50.25,74.13 50.07,74.32 50.07,78.17 50.43,78.53 51.21,78.53
CHG_LGATE on BOTTOM (solid shape): 64.83,81.82 64.83,80.78 64.05,79.99 62.98,79.99 62.78,80.19 62.78,81.42 63.43,82.07 64.59,82.07
CHG_LGATE on BOTTOM (solid shape): 62.61,86.91 62.61,86.12 62.73,85.98 62.78,85.94 62.85,85.91 62.91,85.91 62.92,85.9 63.27,85.9 63.49,85.68 63.49,85.2 63.36,85.07 62.86,85.07 62.43,85.5 62.43,86.05 62.39,86.08 62.39,86.92 62.42,86.95 62.57,86.95
CHG_LGATE on IN4 (solid shape): 64.4,82.02 64.4,80.27 64.12,79.99 63.56,79.99 63.36,80.19 63.36,82.02 63.41,82.07 64.35,82.07
CHG_LGATE on IN4 (solid shape): 64.48,84.79 64.48,84.43 64.35,84.31 63.49,84.31 62.39,85.4 62.39,85.7 62.55,85.86 63.41,85.86
CHG_SNUB on TOP (solid shape): 63.66,79.02 63.66,77.35 63.66,77.34 63.66,76.61 63.29,76.24 61.26,76.24 61.02,76.48 61.02,78.36 61.12,78.46 62.32,78.46 62.42,78.57 62.42,78.97 62.55,79.1 63.59,79.1
CHG_SW on TOP (solid shape): 66.33,79.07 66.33,77.35 66.18,77.19 64.65,77.19 64.38,77.47 64.38,79.1 64.5,79.23 66.18,79.23
CHG_SW on BOTTOM (solid shape): 69.81,81.06 69.81,77.42 69.38,76.99 58.85,76.99 58.84,77.01 58.84,79.66 64.65,79.66 66.28,81.28 69.58,81.28
CHG_SW on BOTTOM (solid shape): 61.02,86.9 61.02,86.03 60.89,85.91 60.89,85.38 60.81,85.3 60.81,84.91 61.25,84.47 61.25,83.75 60.39,83.75 60.26,83.87 60.26,85.6 60.58,85.92 60.59,85.92 60.66,85.97 60.71,86.05 60.72,86.06 60.77,86.11 60.77,86.87 60.84,86.95 60.97,86.95
CHG_SW on IN2 (solid shape): 65,78.88 65,77.97 64.88,77.84 63.58,77.84 63.41,78.01 63.41,78.77 63.71,79.07 64.8,79.07
CHG_SW on IN2 (solid shape): 60.85,85.72 60.85,84.89 61.17,84.56 61.17,83.65 60.9,83.37 60.21,83.37 60.13,83.44 60.13,85.58 60.39,85.83 60.74,85.83
CHG_UGATE on BOTTOM (solid shape): 64.29,75.52 64.29,74.57 64.13,74.41 63.19,74.41 63.04,74.57 63.04,75.15 63.27,75.38 63.47,75.38 63.71,75.62 64.19,75.62
CHG_UGATE on IN4 (solid shape): 62.06,85.86 62.06,84.94 62.24,84.76 62.24,83.65 62.14,83.54 61.15,83.54 61.02,83.67 61.02,85.86 61.15,85.98 61.94,85.98
CHG_UGATE on IN4 (solid shape): 64.19,76.42 64.19,74.54 64.1,74.45 63.36,74.45 63.16,74.65 63.16,76.56 63.46,76.86 63.74,76.86
CORE_SNUB on BOTTOM (solid shape): 93.76,72.28 93.76,69.6 93.48,69.32 92.44,69.32 92.29,69.47 92.29,71.05 92.62,71.38 92.62,72.22 92.72,72.31 93.73,72.31
CORE_SW on BOTTOM (solid shape): 98.39,75.62 98.39,74.12 95.9,74.12 95.9,73.36 98.39,73.36 98.46,73.28 98.46,71.38 96.43,69.35 95.03,69.35 95.02,69.36 94.41,69.36 94.04,69.73 94.04,73.22 93.8,73.46 92.5,73.46 92.39,73.57 92.39,75.77 92.44,75.82 93.36,75.82 93.38,75.85 98.16,75.85
CPU_B+ on TOP (solid shape): 86.33,78.39 87.08,78.39 87.08,78.93 87.53,78.93 87.53,78.39 88.28,78.39 89.5,77.17 89.5,71.02 89.75,70.77 89.75,69.32 89.66,69.23 87.18,69.23 86.38,70.03 86.38,71.95 84.52,73.82 84.52,77.8 85.1,78.39 85.88,78.39 85.88,78.93 86.33,78.93
CPU_B+ on BOTTOM (solid shape): 105.16,77.98 105.57,77.98 105.65,77.9 105.65,76.62 105.4,76.37 104.05,76.37 103.85,76.57 103.85,77.73 104.07,77.96 104.51,77.96 104.53,77.98 104.93,77.98 104.93,78.52 105.16,78.52
CPU_B+ on BOTTOM (solid shape): 89.9,75.75 89.9,72.95 89.52,72.57 89.52,69.4 89.42,69.3 86.73,69.3 86.68,69.35 85.94,69.35 84.67,70.62 84.67,73.97 84.99,74.29 87.84,74.29 88.62,75.07 88.62,75.08 88.62,75.5 88.91,75.8 89.85,75.8
CPU_B+ on BOTTOM (solid shape): 93.2,65.56 93.2,64.74 93.18,64.72 92.68,64.72 92.68,64.21 93.2,64.21 93.2,63.92 92.68,63.92 92.68,63.41 93.2,63.41 93.2,62.95 92.87,62.61 91.43,62.61 91.13,62.91 91.13,65.5 91.43,65.79 92.98,65.79
CPU_B+ on IN2 (solid shape): 105.5,77.87 105.5,76.52 105.38,76.4 104.01,76.4 103.78,76.63 103.78,77.71 103.75,77.74 103.78,77.76 103.78,78.2 103.9,78.32 105.05,78.32
CPU_B+ on IN2 (solid shape): 88.94,75.47 88.94,72.87 88.53,72.47 88.17,72.47 87.82,72.82 87.82,75.34 88.02,75.54 88.86,75.54
CPU_B+ on IN3 (solid shape): outline of 152 points within 86.37,62.75 93.99,73.88
DH_1.2V on BOTTOM (solid shape): 82.33,58.45 82.33,58.17 81.74,57.58 81.52,57.49 81.39,57.36 81.39,57.36 81.32,57.28 81.32,56.9 81.24,56.82 80.89,56.82 80.73,56.98 80.73,57.66 81.67,58.6 82.18,58.6
DH_1.2V on BOTTOM (solid shape): 90.31,54.11 90.46,54.11 90.54,54.03 91.35,54.03 91.43,53.95 91.43,53.83 91.35,53.75 90.38,53.75 90.23,53.6 89.29,53.6 89.24,53.65 89.24,54.06 89.34,54.16 90.26,54.16
DH_1.2V on IN1 (solid shape): 89.45,54.39 90.23,54.39 90.33,54.28 90.33,53.75 90.28,53.7 88.9,53.7 88.82,53.78 88.56,53.78 88.05,54.28 88.05,54.41 88.66,55.02 88.81,55.02
DH_1.2V on IN1 (solid shape): 83.02,56.45 83.64,56.45 84.66,56.45 84.98,56.13 84.98,55.51 84.77,55.3 82.53,55.3 81.98,55.85 81.76,55.85 80.69,56.91 80.69,57.57 81.09,57.97 81.51,57.97
DL_1.2V on BOTTOM (solid shape): 82.61,52.99 82.61,51.79 82.46,51.64 81.67,51.64 81.6,51.72 81.6,52.99 81.74,53.13 82.47,53.13
DL_1.2V on BOTTOM (solid shape): 91.81,53.17 91.81,52.4 91.28,51.88 90.55,51.88 90.38,52.05 90.38,52.22 90.56,52.4 90.89,52.4 91.48,52.99 91.48,53.12 91.58,53.22 91.76,53.22
DL_1.2V on IN1 (solid shape): 82.71,52.07 82.71,51.44 83.02,51.13 83.02,50.78 82.79,50.55 81.98,50.55 81.6,50.93 81.6,52.1 81.8,52.3 82.49,52.3
DL_1.2V on IN1 (solid shape): 91.52,52.54 91.52,52.02 91.32,51.82 91.27,51.78 91.23,51.74 90.65,51.15 89.15,51.15 89.1,51.2 89.1,52.06 89.22,52.18 90.34,52.18 90.82,52.66 91.4,52.66
EDP_COMP on TOP (solid shape): 143.36,73.73 143.45,73.68 143.45,73.58 143.66,73.12 144.08,73.4 144.14,73.48 144.24,73.47 144.27,73.44 144.31,73.25 144.43,73.09 144.44,73.07 144.44,72.09 144.42,72.05 144.39,72.04 143.88,72.04 143.76,72.15 143.76,72.56 143.69,72.63 143.69,72.7 143.62,72.7 143.53,72.8 143.37,72.8 143.06,73.1 143.06,73.15 143.08,73.16 143.16,73.33 143.14,73.52 143.13,73.53 143.14,73.56 143.31,73.73
GPU_B+ on TOP (solid shape): 96.07,66.55 96.07,64.34 95.85,64.12 95.85,62.03 95.59,61.78 95.59,61.02 95.49,60.93 94.14,60.93 93.94,61.13 93.94,66.37 94.22,66.65 95.97,66.65
GPU_B+ on BOTTOM (solid shape): 96.16,66.62 96.16,64.37 95.9,64.1 95.9,62.08 95.59,61.78 95.59,60.96 95.54,60.91 93.53,60.91 93.13,61.32 93.13,62.69 93.33,62.89 93.33,62.93 93.34,62.93 93.34,63.52 93.33,63.52 93.33,63.54 92.81,63.54 92.81,63.79 93.33,63.79 93.33,63.81 93.34,63.81 93.34,64.32 93.33,64.32 93.33,64.34 92.81,64.34 92.81,64.59 93.23,64.59 93.25,64.61 93.34,64.61 93.34,65.67 93.48,65.82 94.17,65.82 95.01,66.65 96.13,66.65
GT_SNUB1 on BOTTOM (solid shape): 103.95,68.01 103.95,66.36 103.78,66.18 101.59,66.18 101.51,66.26 101.51,67.2 101.62,67.3 102.33,67.3 102.51,67.48 102.51,67.96 102.66,68.11 103.85,68.11
GT_SW1 on BOTTOM (solid shape): 107.31,68.14 107.31,61.92 106.52,61.13 103.65,61.13 103.52,61.26 103.52,64 103.44,64.07 102.78,64.07 102.66,63.95 102.66,61.2 102.51,61.05 99.97,61.05 99.53,61.48 99.53,63.47 99.23,63.77 98.72,63.77 98.64,63.85 98.64,66.59 98.67,66.61 99.61,66.61 100.17,66.06 104.19,66.06 104.56,66.43 104.56,67.25 105.27,67.96 106.61,67.96 106.82,68.17 107.27,68.17
INT_SPK_L+ on TOP (solid shape): 280.25,39.91 280.25,38.81 279.58,38.14 279.58,37.97 279.5,37.89 279.5,36.97 279.41,36.89 279.41,36.15 279.36,36.1 279.26,36.1 279.21,36.15 279.21,37.19 279.21,37.2 279.21,38.1 279.26,38.15 279.26,38.74 279.59,39.07 279.59,39.86 279.67,39.93 280.22,39.93
INT_SPK_L+ on BOTTOM (solid shape): 284.52,20.54 284.52,18.06 284.42,17.96 283.5,17.96 283.3,18.16 283.3,20.5 283.56,20.77 284.29,20.77
INT_SPK_L+ on IN4 (solid shape): 284.49,21.39 284.49,19.79 284.44,19.74 284.05,19.74 282.69,21.1 282.69,21.44 282.99,21.75 284.14,21.75
INT_SPK_L+ on IN4 (solid shape): 280.35,39.17 280.35,38.28 279.61,37.55 279.61,35.72 279.47,35.57 278.65,35.57 278.53,35.69 278.53,36.08 278.9,36.45 278.9,37.52 279.44,38.05 279.44,39.04 279.67,39.27 280.25,39.27
INT_SPK_L- on TOP (solid shape): 279.36,39.91 279.36,39.12 279.11,38.87 279.11,38.18 279.08,38.16 279.08,36.92 279.08,36.87 279.08,36.19 279.08,36.14 279.08,36.1 279.06,36.07 278.83,36.07 278.78,36.12 278.78,38.1 278.65,38.23 278.65,39.88 278.7,39.93 279.34,39.93
INT_SPK_L- on BOTTOM (solid shape): 286.14,19.53 286.14,18.09 286.04,17.99 285.13,17.99 284.92,18.19 284.92,19.62 285.05,19.75 285.92,19.75
INT_SPK_L- on IN4 (solid shape): 286.09,19.16 286.09,18.57 285.76,18.24 283.83,18.24 283.63,18.44 283.63,19.13 283.81,19.31 285.94,19.31
INT_SPK_L- on IN4 (solid shape): 279.23,39.15 279.23,38.85 279.19,38.67 279.23,38.49 279.23,38.18 278.7,37.65 278.7,36.84 277.6,35.73 277.52,35.73 276.95,36.31 276.95,36.6 278.57,38.23 278.57,38.38 278.57,38.43 278.57,38.49 278.57,39.07 278.78,39.27 279.11,39.27
INT_SPK_R+ on TOP (solid shape): 277.61,39.88 277.61,38.56 277.73,38.43 277.73,38.3 278.14,37.9 278.14,37.09 278.19,37.04 278.19,36.07 277.96,36.07 277.92,36.11 277.93,36.15 277.94,36.19 277.94,36.87 277.93,36.93 277.91,36.97 277.91,37.21 277.85,37.28 277.85,37.41 276.97,38.28 276.97,39.86 277.02,39.91 277.58,39.91
INT_SPK_R+ on BOTTOM (solid shape): 287.87,19.6 287.87,18.06 287.77,17.96 286.85,17.96 286.65,18.16 286.65,19.7 286.76,19.8 287.67,19.8
INT_SPK_R+ on IN4 (solid shape): 287.95,18.98 287.95,17.91 287.54,17.5 286.78,17.5 286.65,17.63 286.65,19.1 286.75,19.21 287.72,19.21
INT_SPK_R+ on IN4 (solid shape): 277.56,39.05 277.56,38.29 277.41,38.14 277.06,38.14 276.27,37.35 275.83,37.35 275.41,37.77 275.41,38.35 276.31,39.24 277.38,39.24
INT_SPK_R- on TOP (solid shape): 278.52,39.93 278.52,38.13 278.65,38 278.65,36.1 278.62,36.07 278.37,36.07 278.33,36.12 278.33,36.15 278.34,36.19 278.34,36.87 278.33,36.92 278.32,36.96 278.32,37.9 277.86,38.36 277.86,39.91 277.91,39.96 278.5,39.96
INT_SPK_R- on BOTTOM (solid shape): 289.5,19.73 289.5,18.09 289.39,17.99 288.48,17.99 288.28,18.19 288.28,19.9 288.38,20.01 289.22,20.01
INT_SPK_R- on IN4 (solid shape): 289.44,18.95 289.44,17.35 289.24,17.15 288.48,17.15 288.25,17.38 288.25,19 288.38,19.13 289.27,19.13
INT_SPK_R- on IN4 (solid shape): 278.42,40.21 278.42,38.36 278.32,38.26 278.04,38.26 277.86,38.43 277.86,39.3 277.68,39.48 276.54,39.48 276.34,39.68 276.34,40.24 276.62,40.52 278.12,40.52
INT_SPKR_L+ on BOTTOM (solid shape): 283.22,8 283.22,5.52 282.82,5.11 282.51,5.11 282.1,5.52 282.1,7.9 282.28,8.08 283.15,8.08
