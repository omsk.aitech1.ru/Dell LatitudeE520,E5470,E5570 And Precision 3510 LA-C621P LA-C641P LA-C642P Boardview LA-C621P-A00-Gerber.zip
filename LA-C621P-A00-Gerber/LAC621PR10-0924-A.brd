# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PLTRST#_AND_R: length 11.3
  TOP w0.102: RZ115.2 RZ114.2 263.88,16.09 v2(264.48,15.49) 264.77,15.49 v1(265,15.73) ; JUSH1.6 262.46,9.17 261.51,10.13 v2(261.51,10.61)
  IN1 w0.089: v2(264.48,15.49) 264.88,15.09 264.88,14.41 263.02,12.55 263.02,12.21 261.51,10.7 v2(261.51,10.61)
PCH_PLTRST#_EC: length 100.8
  TOP w0.102: UE2.B30 263.9,65.41 v2(263.71,65.23) ; JLPDE1.8 v2(250.3,65.89)
  IN1 w0.089: v2(249.87,63.25) 249.58,63.25 248.84,62.51 247.26,62.51 246.74,63.03 244.62,63.03 243.51,61.92 239.06,61.92 238.8,61.66 234.82,61.66 234.49,61.66 233.25,62.91 233.25,68.58 233.07,68.76 233.07,72.65 231.61,74.11 231.61,74.31 227.91,78 222.5,78 221.76,78.74 220.29,78.74 199.04,78.74 198.1,77.8 192.62,77.8 192.15,77.34 191.03,77.34 187.54,73.85 187.54,72.27 187.84,71.96 v2(188.17,71.96) ; v2(250.3,65.89) 251.01,66.61 251.83,66.61 252.21,66.99 253.11,66.99 253.18,67.06 261.88,67.06 v2(263.71,65.23)
  IN2 w0.122: v2(250.3,65.89) 250.3,63.68 v2(249.87,63.25)
  BOTTOM w0.102: v2(188.17,71.96) 188.17,71.67 187.91,71.4 RC244.1
PCH_POPIRCOMP: length 11.8
  TOP w0.381: v2(163.84,57.32) 163.74,57.22 v3(163.74,51.53) 163.74,50.54 164.3,49.98 RC89.1
  BOTTOM w0.254: UC1.AU16 v2(163.84,57.32)
PCH_PWROK: length 232.5
  IN1 w0.089: v2(73.95,62.59) 72.98,62.59 69.59,59.2 69.59,51.58 70.29,50.88 70.29,46.56 74.5,42.35 74.5,41.01 80.7,34.82 88.09,34.82 92.42,39.15 96.63,39.15 98.87,41.38 v2(98.89,41.38)
  IN3 w0.122: v2(98.89,41.38) 99.02,41.38 99.58,41.94 102.91,41.94 103.17,41.67 128.19,41.67 131.16,38.71 162.26,38.71 162.7,38.27 165.47,38.27 165.92,38.71 171.05,38.71 171.89,39.56 174.31,39.56 175.16,38.71 209.46,38.71 210.77,40.02 v2(212.14,40.02)
  BOTTOM w0.076: UC1.BA20 162.12,54.92 162.12,53.14 163.36,51.89 163.36,51.3 164.45,50.21 164.45,48.91
  BOTTOM w0.102: PR614.1 v2(73.95,62.59) ; v2(212.14,40.02) 211.8,39.68 175.73,39.68 173.55,41.86 170.95,41.86 170.95,41.86 170.55,41.86 170.55,41.86 170.19,41.86 164.45,47.6 164.45,48.91
PCH_RSMRST#: length 69.1
  TOP w0.102: UZ6.1 220.79,29.28 221.24,29.72 221.24,29.93 221.79,30.48 221.79,32.16 222.05,32.43 223.12,32.43 223.28,32.59 226.12,32.59 226.53,33 226.53,34.14 226.27,34.4 226.27,34.4 225.59,35.08 v2(225.59,35.94) 225.59,39.25 225.31,39.53 v3(225.31,39.81) ; UE2.A45 259.84,59.04 v2(259.47,58.68) 258.58,59.57 258.48,59.57 258.07,59.98 RE88.1
  IN2 w0.122: v2(259.47,58.68) 258.96,58.17 258.84,58.17 257.61,56.95 257.61,56.87 256.29,55.55 254.7,53.96 254.7,53.37 254.68,53.35 253.5,52.17 253.5,52.17 252.87,51.54 251.83,51.54 249.49,49.2 249.49,46.94 248.98,46.44 248.98,46.21 248.7,45.93 248.7,43.77 247.61,42.68 246.1,42.68 245.14,41.72 245.14,40.04 241.02,35.92 236.44,35.92 234.51,37.84 228.23,37.84 227.94,38.13 226.44,38.13 225.59,37.27 v2(225.59,35.94)
PCH_RSMRST#_Q: length 168.2
  TOP w0.102: v2(219.68,30.99) 219.45,30.99 219.03,30.57 UZ6.4 ; v2(178.93,40.44) 179.28,40.09 RC215.2 RC75.2 180.4,39.27 v3(179.8,38.66) ; v2(87.93,36.79) 87.78,36.79 87.53,37.04 RC124.1
  IN2 w0.122: v2(219.68,30.99) 219.54,30.99 217.63,32.91 204.99,32.91 204.4,33.5 194.07,33.5 187.74,39.83 179.54,39.83 v2(178.93,40.44) 178.71,40.22 178.71,40.22 178.47,39.97 178.46,39.97 178.38,39.89 106.31,39.89 102.82,36.4 99.79,36.4 98.96,35.57 91.35,35.57 90.99,35.93 88.8,35.93 88.09,36.63 88.09,36.66 87.97,36.79 v2(87.93,36.79)
  BOTTOM w0.076: 165.92,49.71 165.92,50.58 163.54,52.96 163.54,54.18 163.35,54.38 163.35,54.64 163.38,54.72 163.38,54.97 163.35,55.1 163.35,55.27 163.41,55.45 163.51,55.57 163.61,55.67 UC1.AY17
  BOTTOM w0.102: v2(178.93,40.44) 178.51,40.86 178.14,40.86 175.61,43.39 171.3,43.39 165.92,48.76 165.92,49.71
PCH_RTCRST#: length 282.8
  TOP w0.102: v2(300.66,30.57) 300.45,30.57 299.84,29.95 JAPS1.9 ; v2(187.5,48.65) 187.5,48.36 186.55,47.41 RC57.1 183.95,46.21 183,47.16 181.54,47.16 180.57,48.13 179.48,48.13 177.03,50.58 177.03,51.6 176.39,52.24 v2(176.39,53.43)
  IN1 w0.089: v2(300.66,30.57) 300.4,30.83 300.4,35.07 300.84,35.51 300.84,38.1 299.85,39.09 299.85,40.11 299.53,40.43 299.53,40.43 293.92,46.05 290.37,46.05 289.69,46.72 279.93,46.72 278.66,48 270.51,48 269.6,47.08 266.45,47.08 265.34,48.2 264.19,48.2 263.52,48.87 262.39,48.87 261,50.26 258.72,50.26 257.32,48.85 257.32,46.38 255.41,44.48 252.64,44.48 251.62,43.46 246.73,43.46 245.55,42.28 244.94,42.28 244.26,41.6 242.25,41.6 241.15,40.5 238.16,40.5 237.95,40.71 235.81,40.71 235.23,40.13 234.07,40.13 229.22,40.13 229.02,40.33 224.35,40.33 222.15,42.54 219.89,42.54 217.77,44.66 215.57,44.66 214.7,45.53 214.23,45.53 213.53,46.23 208.9,46.23 208.39,46.73 204.45,46.73 202.46,44.75 191.23,44.75 189.3,46.67 189.3,46.67 189.27,46.7 188.37,46.7 187.5,47.57 v2(187.5,48.65) ; v2(280.45,8) 280.43,8.03 280.43,10.75 281.14,11.46 281.88,11.46 282.56,12.15 282.56,15.78 281.44,16.89 279.84,16.89 277.49,19.25 277.49,28.41 277.18,28.73 277.18,35.5 280.78,39.09 281.19,39.09 281.98,39.89 281.98,41.59 282.36,41.96 v2(282.36,41.99)
  IN2 w0.122: v2(300.66,30.57) 299.96,31.27 299.96,34.24 298.66,35.54 298.66,39.45 293.51,44.61 285.25,44.61 282.63,41.99 v2(282.36,41.99)
  IN4 w0.076: 169.77,53.94 169.23,54.47 168.27,54.47 165.95,56.79 165.45,56.79 165.07,57.17 165.07,57.31 165.07,57.62 164.28,58.41
  IN4 w0.089: v2(176.39,53.43) 171.73,53.43 171.48,53.69 170.02,53.69 169.77,53.94 ; 164.28,58.41 164.28,59.92 164.76,60.4 v2(164.76,60.43)
  BOTTOM w0.076: v2(164.76,60.43) 164.66,60.43 164.29,60.79 UC1.AM16
  BOTTOM w0.102: CMOS1.1 262,25.78 CC25.1 260.73,25.78 260.16,25.21 260.16,24.51 260.56,24.11 261.68,24.11 262.65,23.14 262.65,22.91 265.24,20.32 v3(265.24,18.89) 265.24,18.18 264.07,17.01 264.07,11.44 263.97,11.34 263.97,10.82 264.63,10.16 268.39,10.16 269.09,9.46 277.54,9.46 278.41,8.59 279.87,8.59 v2(280.45,8)
PCH_RTCX1: length 22.6
  IN2 w0.122: v2(163.84,60.49) 164.07,60.49 165.33,61.75 166.28,61.75 166.39,61.64 170.91,61.64 172.03,60.53 172.36,60.53 173.04,59.85 v2(174.05,59.85)
  BOTTOM w0.076: 175.9,60.69 175.47,60.26 174.21,60.26 174.05,60.11 v2(174.05,59.85) ; v2(163.84,60.49) UC1.AM18
  BOTTOM w0.102: 175.9,60.69 176.77,60.69 176.85,60.76 177.76,60.76 179.04,62.04 179.6,62.04 RC54.2 180.45,61.41 CC23.2 181.45,62.2 181.66,61.98 YC2.1
PCH_RTCX2: length 22
  IN2 w0.122: v2(162.9,60.54) 162.95,60.54 163.37,60.95 163.37,61.99 164.13,62.75 164.13,62.97 164.85,63.69 166.49,63.69 168.31,61.88 171.84,61.88 172.47,61.25 172.79,61.25 173.51,60.53 174.41,60.53 174.68,60.27 v2(174.68,59.85)
  BOTTOM w0.076: RC296.1 177.33,60.52 177.28,60.47 175.92,60.47 175.29,59.85 v2(174.68,59.85) ; v2(162.9,60.54) 162.49,60.9 UC1.AM20
  BOTTOM w0.102: RC296.1 RC54.1
PCH_RTCX2_R: length 3.7
  BOTTOM w0.102: RC296.2 180.23,60.11 181.09,59.25 181.09,59.11 CC26.2 181.76,59.48 YC2.2
PCH_SATA_LED#: length 220.9
  TOP w0.102: v2(267.77,15.95) 267.34,16.39 RZ118.1
  IN1 w0.089: v2(283.4,70.86) 283.18,71.07 277.57,71.07 276.87,70.37 272.54,70.37 272.08,70.84 270.41,70.84 268.1,73.15 266.73,73.15 265.46,74.42 259.36,74.42 258.05,73.11 245.93,73.11 244.52,74.51 244.52,76.01 243.92,76.62 242.68,76.62 242.1,77.19 242.1,78.92 240.15,80.87 238.39,80.87 238.02,81.24 238.02,85.74 235.7,88.07 234.43,88.07 234.12,88.37 230.82,88.37 v2(230.67,88.22)
  IN2 w0.122: v2(267.77,15.95) 268.65,16.83 268.65,29.51 269.37,30.23 269.37,32.93 270.28,33.85 270.28,36.86 271.57,38.15 273.15,38.15 273.45,38.45 273.45,39.17 272.78,39.83 272.55,39.83 271.99,40.39 271.99,41.65 271.59,42.05 271.59,43.63 271.31,43.91 271.31,44.99 273.92,47.6 273.92,50.59 273.92,50.9 276.33,53.31 277.31,53.31 278.5,54.5 278.5,62.27 280.22,63.99 280.22,64.51 283.01,67.3 283.01,69.89 283.4,70.28 v2(283.4,70.86)
  IN3 w0.122: v2(232.62,72.29) 229.3,75.62 229.3,78.85 230.01,79.56 230.01,79.58 230.56,80.14 230.56,83.55 231,83.99 231,84.77 231.21,84.98 231.21,85.89 230.67,86.43 v2(230.67,88.22)
  BOTTOM w0.076: 175.19,75.31 174.51,74.63 174.51,73.96 173.71,73.15 173.2,73.15 UC1.H1
  BOTTOM w0.102: v2(283.4,70.86) 283.93,71.39 QZ3.4 ; 175.19,75.31 175.32,75.44 178.65,75.44 180.8,73.3 181.81,73.3 181.97,73.14 184.35,73.14 184.67,72.82 RPC4.2 184.67,71.98 184.78,71.88 185.8,71.88 186.04,72.11 186.04,72.58 186.48,73.02 186.48,73.27 190.31,77.1 190.78,77.58 195.4,77.58 195.49,77.48 200.45,77.48 200.65,77.69 220.02,77.69 220.34,78.01 228.56,78.01 229.58,76.99 229.58,75.34 v3(231.45,73.46) v2(232.62,72.29)
PCH_SMB_ALERT#: length 4.3
  TOP w0.102: v2(169,69.75) 169,69.4 169.43,68.96 169.43,68.41 169.25,68.23 168.62,68.23 168.51,68.12 RC23.2
  BOTTOM w0.076: UC1.R10 168.26,69.18 168.55,69.47 168.72,69.47 v2(169,69.75)
PCH_SPI_CLK: length 61.4
  TOP w0.102: RC35.2 207.5,48.26 208.64,47.13 v3(208.64,46.88) JSPI1.13 208.64,44 208.4,43.75 208.4,43.15 208.69,42.86 209.46,42.86 v2(209.6,43.01)
  IN1 w0.089: v2(209.6,43.01) 209.87,42.74 209.87,41.38 209.87,41.25 210.16,40.96 210.16,40.83 210.04,40.71 209.91,40.71 209.61,41 209.49,41 209.36,40.88 209.36,40.75 209.66,40.45 209.66,40.33 209.53,40.2 209.41,40.2 209.11,40.5 208.99,40.5 208.86,40.37 208.86,40.25 209.16,39.95 209.16,39.83 209.03,39.7 208.91,39.7 208.61,40 208.48,40 207.77,39.28 190.06,39.28 185.02,44.33 182.57,44.33 178.22,48.69 178.22,51.17 178.21,51.18 178.21,51.44 176.61,53.03 176.08,53.03 173.96,55.15 173.96,56.31 174.52,56.87 v2(174.54,56.87)
  BOTTOM w0.076: v2(174.54,56.87) 174.13,57.28 172.64,57.28 UC1.AV2
PCH_SPI_CLK_0_R: length 16.7
  TOP w0.102: v2(193.81,66.92) 193.81,67.19 193.64,67.35 v3(193.44,67.35) 193.31,67.35 193.21,67.25 193.21,66.34 193.42,66.12 RC29.2
  BOTTOM w0.102: UC5.6 193.64,69.39 193.32,69.7 193.32,69.9 193.1,70.13 193.1,70.24 193.21,70.35 193.41,70.35 193.53,70.48 193.53,70.6 193.43,70.7 191.65,70.7 191.53,70.82 191.53,70.99 191.66,71.11 193.79,71.11 194.05,71.36 194.19,71.36 194.3,71.26 194.3,70.7 193.84,70.25 193.84,69.79 194.3,69.34 194.3,67.42 193.81,66.92 v2(193.81,66.92) 193.89,66.83 RPC1.6
PCH_SPI_CLK_1_R: length 15.2
  TOP w0.102: 192.21,54.79 192.21,54.86 192.75,55.4 192.75,55.51 RC28.2 ; 192.21,54.79 193.01,54.79 193.25,54.55 193.25,53.94 193,53.7 RPC2.7 ; 192.21,54.79 v2(192.21,54.79)
  BOTTOM w0.102: v2(192.21,54.79) 192.19,54.79 191.74,55.24 191.74,55.63 192.06,55.96 192.43,55.96 192.52,56.05 192.52,56.3 192.43,56.39 192.14,56.39 192.04,56.49 192.04,57.03 192.14,57.13 192.87,57.13 193.02,56.98 193.02,55.92 193.11,55.83 193.62,55.83 193.71,55.74 193.71,55.54 193.62,55.45 192.75,55.45 192.64,55.34 192.64,55.23 192.77,55.1 193.1,55.1 193.19,55.01 193.19,54.78 193.09,54.68 192.89,54.68 192.81,54.6 192.81,53.97 192.88,53.89 193.18,53.89 193.64,53.44 UC6.6
PCH_SPI_CLK_2_R: length 13.9
  TOP w0.102: RZ63.2 RZ60.2 190.97,74.3 191.26,74.59 191.8,74.59 192.25,74.13 192.25,74.02 192.05,73.81 190.04,73.81 189.91,73.68 189.91,73.5 190.02,73.39 191.94,73.39 192.08,73.25 192.08,73.11 191.98,73.01 191.73,73.01 191.59,72.87 191.59,72.64 191.41,72.46 191.12,72.46 191.02,72.57 191.02,72.85 190.9,72.96 v3(190.54,72.96) 190.04,72.96 189.93,72.86 189.93,72.64 190.13,72.45 190.13,72.31 189.93,72.12 189.93,71.49 190.4,71.02 UZ12.19
PCH_SPI_CLK_R1: length 50.7
  TOP w0.102: v2(193.13,51.46) 193,51.59 RPC2.2 ; RZ60.1 192.03,75.21 192.92,74.32 192.92,72.57 v2(192.2,71.85) ; v2(200.49,49.05) 201.04,49.05 201.83,48.26 RC35.1 206.79,47.76 207.13,47.76 208.14,46.74 JSPI1.14
  IN2 w0.122: v2(192.2,71.85) 193.09,70.96 194.81,70.96 195.44,70.32 195.44,68.29 194.37,67.22 v2(194.37,64.32) 194.37,63.03 193.79,62.45 193.79,59.38 192.81,58.39 192.81,56.66 194.27,55.2 194.27,54.68 194.27,54.68 194.27,54.35 193.13,53.22 v2(193.13,51.46) 193.13,51.01 194.05,50.09 196.6,50.09 196.88,50.37 198.77,50.37 200.09,49.05 v2(200.49,49.05)
  BOTTOM w0.102: v2(194.37,64.32) 193.89,64.8 RPC1.3
PCH_SPI_CS#0: length 58
  TOP w0.102: v2(209.18,43.41) 209.64,43.87 JSPI1.11 209.64,46.15 209.46,46.33 209.46,47.62 209.55,47.71 209.7,47.71 209.79,47.79 209.79,48.21 209.74,48.26 RC36.2
  IN1 w0.089: v2(209.18,43.41) 207.87,43.41 207.41,43.87 207.02,43.87 203.92,40.78 190.65,40.78 184.66,46.77 182.2,46.77 179.7,49.27 179.7,53.18 179.17,53.71 178.7,53.71 178.58,53.59 178.45,53.59 178.33,53.72 178.33,53.84 178.45,53.96 178.45,54.09 178.29,54.24 178.17,54.24 177.9,53.97 177.77,53.97 177.64,54.09 177.64,54.22 177.92,54.49 177.92,54.62 177.76,54.77 177.64,54.77 177.37,54.5 177.24,54.5 177.11,54.63 177.11,54.75 177.39,55.02 177.39,55.15 177.26,55.27 177.13,55.27 176.86,55 176.74,55 176.61,55.13 176.61,55.25 176.88,55.52 176.88,55.65 176.62,55.91 176.62,56.46 v2(176.21,56.87)
  BOTTOM w0.076: UC1.AU3 172.41,58.09 173.03,58.09 173.18,58.16 173.21,58.17 173.68,58.17 173.81,58.31 174.03,58.31
  BOTTOM w0.102: 174.03,58.31 175.27,58.31 176.21,57.36 176.21,56.87 v2(176.21,56.87)
PCH_SPI_CS#0_R1: length 50.1
  TOP w0.102: JSPI1.12 209.14,47.52 RC36.1 207.99,48.26 207.33,48.92 205.82,48.92 205.2,49.54 v2(205,49.54)
  IN2 w0.122: v2(205,49.54) 205.41,49.54 205.64,49.77 205.64,50.63 206.58,51.56 206.98,51.56 207.5,52.09 207.5,53.03 207.94,53.47 208.07,53.6 208.07,54.08 205.45,56.7 202.12,56.7 200.8,58.02 197.92,58.02 197.55,58.39 197.55,59.15 198.7,60.3 198.7,61.35 196.03,64.01 196.03,66.54 197.68,68.19 197.68,71.16 196.74,72.1 194.2,72.1 v2(193.34,72.96)
  BOTTOM w0.102: RC37.1 190.38,72.6 192.97,72.6 v2(193.34,72.96)
PCH_SPI_CS#0_R2: length 14.6
  BOTTOM w0.102: v3(189.64,69.76) 189.64,70.2 189.29,70.55 189.29,71.54 189.22,71.61 189.22,72.5 189.54,72.83 RC37.2 192.76,72.83 192.93,72.99 192.93,73.26 192.8,73.38 190.23,73.38 190.11,73.51 190.11,73.82 190.23,73.94 191.98,73.94 192.09,74.04 192.09,74.2 191.96,74.32 191.25,74.32 191.1,74.48 UC5.1
PCH_SPI_CS#1: length 51.7
  TOP w0.102: RC32.2 204.33,46.57 v3(204.33,45.79) 204.46,45.66 204.66,45.66 204.94,45.94 205.33,45.94 205.64,45.63 JSPI1.19 205.64,44.44 206.71,43.37 207.08,43.37 v2(207.18,43.47)
  IN1 w0.089: v2(207.18,43.47) 204.27,40.56 190.56,40.56 184.61,46.52 182.15,46.52 179.46,49.2 179.46,51.97 178.48,52.95 176.38,55.05 176.38,56.14 v2(176.22,56.29)
  BOTTOM w0.076: UC1.AU2 172.71,57.74 172.73,57.76 173.25,58 173.25,58 173.79,58 173.9,58.12 174.14,58.12
  BOTTOM w0.102: v2(176.22,56.29) 175.82,56.69 175.82,57.4 175.11,58.12 174.14,58.12
PCH_SPI_CS#1_R1: length 25.8
  TOP w0.102: JSPI1.20 205.14,44.61 204.99,44.47 204.36,44.47 203.67,45.16 RC32.1 202.81,46.82 202.4,47.22 v2(202.4,47.3) ; RC42.1 192.14,58.4 v2(192.11,58.37)
  IN2 w0.122: v2(202.4,47.3) 201.92,47.78 198.9,47.78 197.55,49.13 194.04,49.13 192.49,50.68 192.49,51.66 191.76,52.4 191.76,58.02 v2(192.11,58.37)
PCH_SPI_CS#1_R2: length 11.1
  TOP w0.102: v2(190.77,58.47) 190.84,58.4 v3(190.84,57.65) 190.84,56.63 190.93,56.54 191.36,56.54 191.45,56.63 191.45,58.87 RC42.2
  BOTTOM w0.102: v2(190.77,58.47) 190.77,56.66 190.85,56.57 191.25,56.57 191.43,56.75 191.43,58.83 191.1,59.16 UC6.1
PCH_SPI_CS#2: length 105.5
  TOP w0.102: v2(189.19,73.84) 189.3,73.74 RZ61.1
  IN1 w0.089: v2(175.33,56.88) 175.81,56.4 175.81,56.11 176.16,55.76 176.16,54.96 179.24,51.88 179.24,49.11 182.19,46.17 184.63,46.17 190.46,40.35 205.55,40.35 v2(207.93,42.72)
  IN2 w0.122: v2(207.93,42.72) 202.89,42.72 196.98,48.64 193.63,48.64 189.89,52.37 189.89,55.17 187.91,57.15 185.97,57.15 184.63,58.49 184.63,64.56 185.34,65.27 186.71,65.27 189.51,68.08 189.51,69.17 188.66,70.02 188.66,71.51 188.81,71.66 189.91,71.66 190.03,71.79 190.03,72.03 189.94,72.12 188.78,72.12 188.63,72.26 188.63,72.48 188.78,72.62 190.96,72.62 191.08,72.74 191.08,72.99 190.96,73.11 188.16,73.11 188.01,73.25 188.01,73.7 188.16,73.84 v2(189.19,73.84)
  BOTTOM w0.076: UC1.AU1 173.42,57.81 173.9,57.81 174.01,57.92 174.99,57.92 175.33,57.58
  BOTTOM w0.102: 175.33,57.58 v2(175.33,56.88)
PCH_SPI_CS#2_R: length 14.8
  TOP w0.102: v2(196.74,70.37) RZ110.1 197.37,67.61 197.37,66.79 196.7,66.12 RZ113.1 ; UZ12.20 189.9,70.64 v2(189.7,70.83) 189.3,71.24 RZ61.2
  IN4 w0.089: v2(196.74,70.37) 196.28,70.83 v2(189.7,70.83)
PCH_SPI_D0: length 77.4
  TOP w0.102: v2(206.63,44.07) 206.64,44.08 JSPI1.17 206.64,45.72 205.88,46.48 205.88,46.97 205.42,47.44 205.42,47.63 205.27,47.78 RC33.2
  IN1 w0.089: v2(177.18,56.01) 179.92,53.27 179.92,49.36 182.16,47.11 184.62,47.11 190.74,40.99 203.55,40.99 v2(206.63,44.07)
  BOTTOM w0.076: 175.19,54.72 174.86,54.72 173.62,55.96 173.22,55.96 172.98,56.2 171.94,56.2 171.73,56.41 UC1.AV3
  BOTTOM w0.102: RC10.2 193.48,49.74 190.88,49.74 189.64,48.49 188.32,48.49 186.73,46.9 181.41,46.9 178.06,50.25 v3(178.06,53.89) 178.06,55.13 v2(177.18,56.01) 177,55.83 177,55.39 176.33,54.72 175.19,54.72
PCH_SPI_D0_0_R: length 15.3
  BOTTOM w0.102: RPC1.7 194.39,66.65 194.56,66.81 195.15,66.81 195.23,66.89 195.23,67.2 195.36,67.33 195.51,67.33 195.59,67.25 195.59,66.77 195.7,66.66 195.81,66.66 196.05,66.9 196.05,67.35 196.21,67.52 196.6,67.52 196.73,67.65 196.73,68.1 196.44,68.4 v3(196.44,68.44) 196.44,69.32 196.26,69.5 195.91,69.5 195.41,70 195.41,70.91 195.59,71.09 195.59,71.67 195.25,72.01 194.81,72.01 194.7,71.9 194.7,71.72 194.91,71.52 194.91,69.43 195.02,69.32 195.37,69.32 195.59,69.1 195.59,68.32 195.48,68.21 UC5.5
PCH_SPI_D0_1_R: length 16.9
  TOP w0.102: v2(193.63,54.3) 193.5,54.18 RPC2.6
  BOTTOM w0.102: v2(193.63,54.3) 194.03,53.9 194.23,53.9 194.32,53.99 194.32,56.36 194.22,56.46 193.76,56.46 193.66,56.57 193.66,56.77 193.76,56.87 194.22,56.87 194.32,56.97 194.32,58.08 194.41,58.17 194.82,58.17 194.91,58.08 194.91,54.35 195.72,53.53 195.72,51.5 195.44,51.22 v3(195.19,51.22) 195.01,51.4 195.01,51.98 194.91,52.09 UC6.5
PCH_SPI_D0_2_R: length 12.8
  TOP w0.102: UZ12.21 189.4,70.4 189.24,70.56 189.24,70.77 188.98,71.03 188.98,71.28 188.88,71.38 188.63,71.38 188.52,71.49 188.52,71.73 188.82,72.04 188.82,72.3 188.6,72.53 188.6,72.76 188.81,72.97 188.81,73.68 188.71,73.78 188.51,73.78 188.43,73.7 188.43,73.13 188.33,73.03 188.17,73.03 188.05,73.16 188.05,74.02 188.15,74.13 v3(188.31,74.13) 188.48,74.13 188.58,74.23 188.58,74.43 188.48,74.53 188.07,74.53 187.99,74.61 187.99,74.87 188.09,74.97 188.59,74.97 188.7,75.08 188.7,75.28 188.6,75.37 188.15,75.37 188.05,75.48 188.05,75.75 188.52,76.22 188.64,76.22 188.72,76.14 188.72,75.86 188.83,75.76 189.1,75.76 189.19,75.85 RZ59.2
PCH_SPI_D0_R1: length 53.1
  TOP w0.102: v2(194.38,50.75) 194.38,50.96 193.5,51.84 RPC2.3 ; v2(203.08,47.3) 203.21,47.3 RC33.1 204.2,47.27 204.91,47.27 205.48,46.71 205.48,46.25 206.14,45.59 JSPI1.18 ; RZ59.1 189.19,74.87 189.4,74.65 v2(189.4,74.43)
  IN2 w0.122: v2(189.4,74.43) 189.45,74.48 190.18,74.48 192.18,72.48 192.46,72.48 193.33,71.6 196.47,71.6 197.18,70.9 197.18,68.39 195.03,66.25 v2(195.03,64.32) 195.03,64.26 198.09,61.2 198.09,60.62 194.9,57.43 194.9,55.47 194.9,54.02 193.89,53.01 193.89,51.24 v2(194.38,50.75) 194.74,50.75 195.43,51.44 197.14,51.44 197.45,51.13 199.16,51.13 200.21,50.08 200.31,50.08 201.12,49.26 201.12,48.97 201.86,48.24 202.14,48.24 v2(203.08,47.3)
  BOTTOM w0.102: RPC1.2 194.39,64.87 194.94,64.32 v2(195.03,64.32)
PCH_SPI_D1: length 54.5
  TOP w0.102: v2(208.81,41.84) 208.23,41.84 207.52,42.55 207.52,43.12 207.64,43.24 JSPI1.15 207.64,46.14 207.53,46.25 206.94,46.25 206.79,46.4 206.79,47.26 206.88,47.35 207.16,47.35 207.25,47.26 RC34.2
  IN1 w0.089: v2(208.81,41.84) 206.88,39.91 190.28,39.91 185.27,44.93 182.82,44.93 178.81,48.93 178.81,51.7 174.74,55.78 v2(174.74,56.24)
  BOTTOM w0.076: UC1.AW3 172.35,56.75 173.54,56.75 174.06,56.24 v2(174.74,56.24)
PCH_SPI_D1_0_R: length 13.5
  BOTTOM w0.102: UC5.2 192.37,74.58 194.71,72.24 194.71,72.24 195.15,72.24 195.37,72.24 195.82,71.8 195.82,70.99 195.64,70.82 195.64,70.09 195.93,69.8 196.53,69.8 196.96,69.37 196.96,67.27 v3(196.37,66.68) 195.88,66.19 RPC1.8
PCH_SPI_D1_1_R: length 12.9
  TOP w0.102: RPC2.5 194,53.99 194.23,54.22 194.68,54.22 194.78,54.32 194.78,54.52 194.7,54.6 194.25,54.6 194.2,54.66 v3(194.2,55.01) 194.2,55.27 193.89,55.58 193.66,55.58 193.56,55.48 193.56,55.02 v2(193.64,54.94)
  IN2 w0.122: v2(192.18,57.74) 192.18,56.4 192.72,55.86 192.72,54.39 192.85,54.26 193.08,54.26 193.2,54.39 193.2,54.79 193.36,54.94 v2(193.64,54.94)
  BOTTOM w0.102: UC6.2 192.37,58.96 192.47,58.86 192.82,58.86 193.03,58.65 193.03,57.92 192.85,57.74 v2(192.18,57.74)
PCH_SPI_D1_2_R: length 13
  TOP w0.102: UZ12.24 187.9,70.46 187.49,70.87 187.18,70.87 187.11,70.79 187.11,70.18 187.01,70.08 186.78,70.08 186.7,70.16 186.7,71.29 186.61,71.38 186.33,71.38 186.24,71.47 186.24,71.85 186.16,71.93 185.96,71.93 185.86,71.84 185.86,71.5 185.77,71.41 185.63,71.41 185.48,71.56 185.48,72.06 185.39,72.16 184.88,72.16 183.86,73.18 183.86,73.62 184,73.75 184.15,73.75 v3(184.32,73.59) 184.6,73.31 184.6,73.07 185.11,72.55 185.89,72.55 RZ58.2
PCH_SPI_D1_R1: length 57.9
  TOP w0.102: v2(205.83,47.6) 206.34,47.1 RC34.1 206.34,46.54 207.14,45.73 JSPI1.16 ; v2(194.6,51.44) 194,52.04 RPC2.4 ; v2(186.04,73.31) 185.95,73.4 v3(185.95,74.13) 185.95,74.37 186.02,74.44 RZ58.1
  IN2 w0.122: v2(186.04,73.31) 187.63,74.9 190.14,74.9 192.31,72.73 192.56,72.73 193.43,71.85 196.64,71.85 197.42,71.07 197.42,68.29 195.62,66.48 v2(195.62,64.42) 195.62,64.08 198.45,61.24 198.45,60.63 195.14,57.33 195.14,54.32 195.14,53.89 194.45,53.19 194.45,51.59 v2(194.6,51.44) 195.08,51.44 195.33,51.69 197.25,51.69 197.56,51.38 199.76,51.38 201.29,49.85 202.76,49.85 203.3,49.3 203.3,48.07 203.77,47.6 v2(205.83,47.6)
  BOTTOM w0.102: RPC1.1 195.38,65.04 195.62,64.8 v2(195.62,64.42)
PCH_SPI_D2: length 84.8
  TOP w0.102: RC38.2 210.93,47.2 210.73,47.4 210.73,47.54 210.64,47.63 210.36,47.63 210.27,47.54 210.27,47.37 210.48,47.17 210.48,46.25 210.64,46.08 JSPI1.9 210.64,44.33 210.63,44.32 210.63,43.98 211.12,43.49 211.71,43.49 v2(211.85,43.62)
  IN1 w0.089: v2(211.85,43.62) 210.75,43.62 210.54,43.83 207.8,43.83 206.98,44.65 206.32,44.65 202.88,41.21 190.83,41.21 184.68,47.36 182.23,47.36 180.13,49.45 180.13,53.66 v2(177.19,56.61)
  BOTTOM w0.076: 175.19,55.16 174.9,55.16 173.8,56.26 173.48,56.59 172.83,56.59 UC1.AW2
  BOTTOM w0.102: RC11.2 194.11,50.13 190.62,50.13 190.31,50.44 v3(190.03,50.44) 189.96,50.36 189.96,50.12 190.03,50.05 190.03,49.27 189.67,48.9 188.34,48.9 186.58,47.13 181.51,47.13 180.3,48.34 180.04,48.59 179.69,48.95 179.67,48.97 178.68,49.97 178.48,50.16 178.48,55.32 v2(177.19,56.61) 177.12,56.61 176.74,56.24 176.74,55.48 176.43,55.16 175.19,55.16
PCH_SPI_D2_0_R: length 13.3
  BOTTOM w0.102: UC5.3 193.64,74.55 193.41,74.32 193.41,73.89 193.74,73.56 194.8,73.56 195.72,74.48 195.72,75.87 195.85,76 v3(197.35,76) 198.83,76 198.92,75.91 198.92,75.56 198.83,75.47 196.51,75.47 196.38,75.34 RC39.2
PCH_SPI_D2_1_R: length 13
  TOP w0.102: v2(193.51,57.74) 193.51,58.15 193.39,58.27 193.21,58.27 193.08,58.14 193.08,57.56 193.27,57.37 193.27,57.2 193.2,57.13 192.48,57.13 192.38,57.23 192.38,57.34 192.49,57.46 192.66,57.46 192.73,57.53 192.73,57.72 192.65,57.8 v3(192.65,58.11) 192.65,58.46 192.74,58.55 193.25,58.55 193.34,58.64 193.34,58.77 193.25,58.86 192.74,58.86 192.65,58.95 192.65,59.7 192.78,59.83 193.5,59.83 193.62,59.71 193.62,59.48 193.51,59.38 RC43.2
  BOTTOM w0.102: UC6.3 193.64,59.52 193.25,59.14 193.25,58.7 193.41,58.55 193.41,58.28 193.49,58.2 193.9,58.2 194,58.1 194,57.28 193.89,57.16 193.72,57.16 193.62,57.26 193.62,57.62 v2(193.51,57.74)
PCH_SPI_D2_R1: length 51
  TOP w0.102: v2(206.67,49.33) 206.67,49.33 207.27,49.33 207.83,48.77 209.61,48.77 210.02,48.37 RC38.1 210.14,46.69 JSPI1.10 ; RC43.1 194.68,59.38 195.33,58.73 v2(198.23,58.73)
  IN2 w0.122: v2(195.68,72.52) 196.67,72.52 197.93,71.27 197.93,68.03 196.28,66.38 196.28,64.12 198.95,61.45 198.95,61.24 198.95,61.24 198.95,59.93 198.23,59.22 v2(198.23,58.73) 199.58,58.73 200.07,59.22 200.46,59.22 201.45,58.24 201.45,58.23 202.36,57.32 205.54,57.32 208.43,54.43 208.57,54.28 208.57,53.8 208.57,53.39 208.15,52.97 208,52.82 208,51.88 207.43,51.31 206.74,51.31 206.16,50.73 205.91,50.49 205.91,49.48 206.13,49.25 206.59,49.25 v2(206.67,49.33)
  BOTTOM w0.102: RC39.1 196.38,72.02 RC30.2 196.11,71.92 195.68,72.35 v2(195.68,72.52)
PCH_SPI_D3: length 58.2
  TOP w0.102: RC40.2 212.53,47.83 212.61,47.76 212.61,47.57 212.31,47.27 211.92,47.27 211.77,47.12 211.77,46.31 211.64,46.18 JSPI1.7 211.64,44.68 212.36,43.97 212.36,43.36 212.14,43.15 210.72,43.15 209.87,42.29 v2(208.37,42.29)
  IN1 w0.089: v2(175.35,56.3) 175.35,55.47 178.48,52.34 179.03,51.79 179.03,49.02 182.1,45.96 184.54,45.96 190.37,40.13 206.2,40.13 v2(208.37,42.29)
  BOTTOM w0.076: UC1.AU4 171.67,57.47 173.84,57.47 173.86,57.5 v3(174.77,57.5) 174.98,57.5 175.06,57.42 175.06,57.14 174.94,57.02
  BOTTOM w0.102: v2(175.35,56.3) 174.94,56.71 174.94,57.02
PCH_SPI_D3_0_R: length 12.9
  BOTTOM w0.102: RPC1.5 193.39,66.18 193.39,65.75 193.08,65.44 193.08,65.12 192.98,65.02 192.86,65.02 192.75,65.13 192.75,66.52 193.29,67.07 193.29,67.24 193.11,67.43 192.93,67.43 192.32,66.81 192.32,65.93 192.23,65.84 191.92,65.84 191.83,65.93 v3(191.83,66.64) 191.73,66.75 191.13,66.75 191.05,66.83 191.05,67.06 191.13,67.15 191.73,67.15 191.83,67.25 191.83,69.21 191.92,69.3 192.28,69.3 192.37,69.21 UC5.7
PCH_SPI_D3_1_R: length 12.9
  TOP w0.102: RPC2.8 192.51,53.58 192.93,54 192.93,54.41 192.8,54.54 192.68,54.54 192.18,54.03 v2(192.18,53.94)
  BOTTOM w0.102: UC6.7 192.37,51.87 192.57,51.67 192.57,51.08 192.67,50.98 v3(192.83,50.98) 193.47,50.98 193.56,50.89 193.56,50.56 193.47,50.47 190.71,50.47 190.6,50.59 190.6,50.9 190.71,51.01 191.45,51.01 191.58,51.13 191.58,51.98 191.59,51.99 191.59,52.19 191.71,52.3 191.71,53.47 v2(192.18,53.94)
PCH_SPI_D3_R1: length 49
  TOP w0.102: v2(211.42,44.03) 211.14,44.3 JSPI1.8 211.14,46.16 211.44,46.46 211.44,47.55 RC40.1 ; v2(191.98,51.54) 192.15,51.54 193.04,50.65 193.04,50.04 192.8,49.8 v3(192.7,49.8) 192.67,49.8 192.28,50.19 RC31.2 191.58,51.25 191.22,51.61 RC316.2 191.59,52.33 191.71,52.21 RPC2.1
  IN2 w0.122: v2(211.42,44.03) 210.7,44.75 201.3,44.75 197.16,48.88 193.82,48.88 191.98,50.72 v2(191.98,51.54) 191.51,52.01 191.51,59.85 191.05,60.32 191.05,62.33 193.05,64.33 v2(193.05,64.37)
  BOTTOM w0.102: v2(193.05,64.37) 193.39,64.71 RPC1.4
PCH_SPI_DO2_XDP: length 164.7
  TOP w0.102: v2(95.11,47.68) 95.11,47.76 94.52,48.35 JXDP1.60
  IN3 w0.122: v2(95.11,47.68) 95.64,47.15 98.06,47.15 102.76,42.44 103.11,42.44 103.38,42.17 128.59,42.17 131.41,39.35 162.33,39.35 162.91,38.77 165.26,38.77 165.85,39.35 170.98,39.35 171.69,40.06 174.52,40.06 175.23,39.35 208.67,39.35 212.68,43.36 212.68,44.45 214.84,46.61 219.64,46.61 219.85,46.83 220.42,46.83 v2(220.79,46.46)
  BOTTOM w0.102: v2(220.79,46.46) 220.43,46.82 220.02,46.82 220.01,46.8 220,46.8 219.9,46.7 217.64,46.7 216.63,45.69 206.19,45.69 205.83,45.32 199.31,45.32 197.78,46.85 197.78,47.81 196.74,48.85 196.74,49.84 v1(196.63,49.95) 195.73,49.95 RC11.1
PCH_SPI_DO_XDP: length 172.8
  TOP w0.102: RC128.1 RC133.2 93.92,37.19 v2(94.14,37.42)
  IN3 w0.122: v2(96.4,46.66) 98.14,46.66 102.61,42.19 103.01,42.19 103.27,41.92 128.3,41.92 131.12,39.1 162.22,39.1 162.81,38.52 165.37,38.52 165.95,39.1 171.08,39.1 171.79,39.81 174.42,39.81 175.12,39.1 208.77,39.1 212.93,43.25 212.93,44.34 214.95,46.36 220.14,46.36 v2(220.19,46.41)
  IN4 w0.089: v2(94.14,37.42) 94.02,37.55 93.84,37.55 92.5,38.89 92.5,39.54 91.71,40.33 91.71,41.77 96.4,46.46 v2(96.4,46.66)
  BOTTOM w0.102: RC10.1 195.71,48.43 v1(196.66,48.43) 196.75,48.43 197.55,47.63 197.55,46.75 199.21,45.09 205.92,45.09 206.29,45.46 216.72,45.46 217.6,46.33 220.11,46.33 v2(220.19,46.41)
PCI_CLK_LPC0: length 18.6
  TOP w0.102: v2(173.35,50.99) 173.45,50.89 173.45,50.11 173.72,49.84 173.72,48.91 v3(175.03,47.6) 177.28,45.36 177.28,44.31 177.13,44.16 RC18.1 RC16.1
  BOTTOM w0.076: UC1.AW9 168.28,56.31 168.19,56.01 168.19,55.03 168.35,54.87 168.54,54.87 168.72,54.69 168.72,53.93 169.7,52.95 170.66,52.95 170.98,52.63 171.2,52.63
  BOTTOM w0.102: 171.2,52.63 171.35,52.63 172.44,51.54 172.45,51.54 172.86,51.14 173.2,51.14 v2(173.35,50.99)
PCI_CLK_LPC1: length 16.9
  TOP w0.102: v2(174.13,51.13) 174.69,50.58 174.69,49.31 v3(177.04,46.96) 177.97,46.03 RC22.1 RC24.1
  BOTTOM w0.076: 171.83,52.71 171.74,52.81 171.03,52.81 170.73,53.12 169.77,53.12 168.89,53.99 168.89,55.14 168.71,55.33 168.71,55.58 UC1.AY9
  BOTTOM w0.102: 171.83,52.71 172.95,51.59 173.67,51.59 v2(174.13,51.13)
PCIE_PRX_C_DTX_N9: length 5.9
  TOP w0.094: CL2.1 263.73,94.07 v4(263.73,93.39) 263.72,93.39 263.72,92.09 263.85,91.96 263.85,91.92 264.27,91.5 264.32,91.5 264.58,91.24 265.2,91.24 265.6,90.85 265.6,90.61 265.49,90.5 UL1.39
PCIE_PRX_C_DTX_N10: length 2.1
  TOP w0.094: CR27.2 260.75,45 260.75,44.84 261.07,44.52 261.07,44.29 261.12,44.24 UR2.8
PCIE_PRX_C_DTX_N11: length 32
  TOP w0.094: RN82.1 239.74,23.77 239.74,20.45 245.98,14.21 245.98,12.3 249.01,9.27 249.59,9.27 250.2,8.66 251.94,8.66 251.97,8.69 252.56,8.69 252.59,8.66 v4(253.84,8.66) 259.18,8.66 259.41,8.43 259.41,7.93 v2(259.6,7.73)
  BOTTOM w0.094: v2(259.6,7.73) 259.41,7.92 259.41,8.41 259.55,8.55 JNGFF3.29
PCIE_PRX_C_DTX_N12: length 42.9
  TOP w0.094: RN78.1 227.87,25.1 227.48,24.72 227.48,24.42 227.67,24.24 228.14,24.24 228.67,23.7 230.75,23.7 231.51,22.94 233.64,22.94 239.6,16.98 241.07,16.98 243.3,14.75 243.3,13.15 247.4,9.04 247.4,6.66 247.92,6.15 v4(248.58,6.15) 249.67,6.15 249.71,6.18 250.3,6.18 250.33,6.15 255.41,6.15 256.45,7.19 256.45,7.5 256.37,7.57 256.09,7.57 255.99,7.67 255.99,7.83 v2(256.05,7.89)
  BOTTOM w0.094: JNGFF3.43 256.05,8.64 256.33,8.35 256.33,8.12 256.1,7.89 v2(256.05,7.89)
PCIE_PRX_C_DTX_P9: length 5.9
  TOP w0.094: CL1.1 263.92,94.07 263.92,93.72 263.95,93.69 263.95,93.1 263.91,93.06 263.91,92.17 v4(264.22,91.87) 264.66,91.43 265.28,91.43 265.79,90.93 265.79,90.67 265.89,90.57 UL1.38
PCIE_PRX_C_DTX_P10: length 2.1
  TOP w0.094: CR26.2 260.95,45.19 260.95,44.92 261.26,44.6 261.26,44.37 261.52,44.11 UR2.7
PCIE_PRX_C_DTX_P11: length 32
  TOP w0.094: RN81.1 239.55,23.77 239.55,20.37 245.79,14.13 245.79,12.22 248.93,9.08 249.51,9.08 250.12,8.46 v4(252.26,8.46) 253.51,8.46 253.54,8.43 254.13,8.43 254.16,8.46 259.1,8.46 259.21,8.35 259.21,7.95 v2(258.99,7.73)
  BOTTOM w0.094: v2(258.99,7.73) 259.22,7.96 259.22,8.39 259.05,8.56 JNGFF3.31
PCIE_PRX_C_DTX_P12: length 42.9
  TOP w0.094: v2(256.64,7.88) 256.64,7.88 256.64,7.11 255.49,5.96 v4(250,5.96) 248.91,5.96 248.88,5.93 248.28,5.93 248.25,5.96 247.84,5.96 247.21,6.58 247.21,8.96 243.1,13.07 243.1,14.67 240.99,16.78 239.52,16.78 233.56,22.75 231.43,22.75 230.67,23.51 228.59,23.51 228.06,24.04 227.59,24.04 227.29,24.34 227.29,24.85 RN77.1
  BOTTOM w0.094: JNGFF3.41 256.55,8.46 256.53,8.44 256.53,7.99 v2(256.64,7.88)
PCIE_PRX_C_RD_DTX_N11: length 2.2
  TOP w0.094: UN5.4 240.37,31.6 240.21,31.75 240.21,32.44 240.12,32.53 240.12,32.78 CN34.2
PCIE_PRX_C_RD_DTX_N12: length 2.3
  TOP w0.094: UN4.4 229.04,32.8 228.89,32.95 228.89,33.31 228.7,33.49 228.7,33.94 CN24.2
PCIE_PRX_C_RD_DTX_P11: length 2.2
  TOP w0.094: CN33.2 239.93,32.78 239.93,32.45 240.02,32.36 240.02,31.81 239.87,31.66 UN5.5
PCIE_PRX_C_RD_DTX_P12: length 2.4
  TOP w0.094: CN23.2 228.51,33.91 228.51,33.41 228.7,33.23 228.7,32.95 228.54,32.8 UN4.5
PCIE_PRX_DTX_N3: length 94.3
  IN1 w0.112: v2(163.89,72.77) 164.33,73.21 164.33,73.51 165.08,74.26 165.08,75.79 165.55,76.26 168.65,76.26 170.59,78.21 171.51,78.21 172.38,79.08 173.39,79.08 173.87,79.56 173.87,80.29 174.67,81.09 174.67,81.43 176.86,83.62 186.23,83.62 186.47,83.37 189.2,83.37 189.4,83.57 190.47,83.57 190.65,83.39 190.79,83.25 201.81,83.25 202.1,82.96 203.73,82.96 203.92,83.16 208.15,83.16 209.82,81.48 222.8,81.48 223.6,80.67 230.78,80.67 233.61,77.83 233.61,74.94 235.24,73.32 235.44,73.32 236.31,72.45 236.31,68.55 236.03,68.27 236.03,67.46 v2(235.86,67.29)
  BOTTOM w0.076: UC1.H16 164.18,72.49 v2(163.89,72.77)
  BOTTOM w0.094: JNGFF2.33 234.6,67.55 234.83,67.31 234.83,67.13 235.16,66.81 235.92,66.81 236.1,66.99 236.1,67.11 235.93,67.29 v2(235.86,67.29)
PCIE_PRX_DTX_N5: length 153
  IN4 w0.076: v2(163.88,74.07) 163.88,74.19 164.07,74.38 164.27,74.38 164.35,74.3 164.43,74.3
  IN4 w0.112: 164.43,74.3 165.6,74.3 166.67,75.37 167.35,75.37 167.71,75.01 168.57,75.01 169.66,76.11 171.97,76.11 173.09,74.99 174.83,74.99 175.47,75.62 179.74,75.62 181.33,74.03 185.91,74.03 187.19,75.31 191.63,75.31 193.56,73.38 196.21,73.38 198.1,71.49 199.53,71.49 200.24,72.2 205.02,72.2 206.46,73.64 207.32,73.64 208.04,72.91 210.03,72.91 211.55,74.43 220.85,74.43 221.35,73.93 227.95,73.93 229.25,72.62 229.25,70.77 229.83,70.2 229.83,62.36 230.07,62.12 230.07,60.36 228.91,59.21 228.91,57.88 227.04,56.01 227.04,52.48 228.51,51.02 228.51,47.53 227.88,46.9 227.88,42.27 234.59,35.56 234.59,33.93 233.87,33.2 233.87,28.46 234.43,27.9 235.7,27.9 238.73,24.87 238.73,23.39 241.06,21.05 243.27,21.05 244.37,19.96 245.39,19.96 247.1,18.24 247.1,18.06 246.93,17.89 v2(246.77,17.89)
  BOTTOM w0.076: v2(163.88,74.07) 164.12,74.07 164.29,73.9 UC1.F16
  BOTTOM w0.094: JNGFF1.35 254.2,17 253.73,17.48 251.55,17.48 250.2,18.83 247.13,18.83 246.86,18.55 246.86,17.97 v2(246.77,17.89)
PCIE_PRX_DTX_N6: length 159.8
  IN4 w0.076: v2(162.95,73.44) 162.95,73.53 163.49,74.07 163.49,74.9 163.71,75.12
  IN4 w0.112: 163.71,75.12 164.7,76.11 168.28,76.11 168.59,76.11 169.34,76.86 172.31,76.86 173.52,75.65 174.56,75.65 175.23,76.32 179.99,76.32 181.61,74.7 185.63,74.7 186.91,75.98 192.71,75.98 194.36,74.33 209.16,74.33 209.54,73.94 210.12,73.94 211.26,75.09 221.13,75.09 221.61,74.62 228.2,74.62 229.94,72.87 229.94,71.02 230.49,70.47 230.49,62.65 230.75,62.39 230.75,61.29 231.35,60.69 231.35,58.62 230.91,58.18 230.16,58.18 227.76,55.78 227.76,52.84 229.17,51.42 229.17,47.22 228.59,46.65 228.59,42.49 235.38,35.7 235.38,33.96 235.91,33.43 235.91,28.75 239.86,24.8 239.86,23.32 240.48,22.7 240.63,22.56 242.56,22.56 243.36,21.76 244.99,21.76 246.22,20.53 246.22,20.09 247.88,18.43 249.38,18.43 252.25,15.55 254.12,15.55 255.67,17.1 256.72,17.1 257.09,17.46 260.15,17.46 v2(260.16,17.45)
  BOTTOM w0.076: v2(162.95,73.44) 163.08,73.44 UC1.G18
  BOTTOM w0.094: v2(260.16,17.45) 259.82,17.79 259.69,17.79 259.52,17.63 259.52,16.95 259.89,16.58 259.89,15.93 259.99,15.84 260.1,15.84 260.2,15.74 JNGFF1.59
PCIE_PRX_DTX_N9: length 139.2
  TOP w0.094: CL2.2 263.85,95.79 263.85,96.03 262.99,96.88 261.77,96.88 258.38,100.27 250.08,100.27 248.97,99.16 248.97,99.11 248.53,98.67 248.48,98.67 v4(247.43,97.62) 246.92,97.11 244.68,94.87 244.68,92.53 244.4,92.25 244.4,89.56 243.04,88.2 242.77,88.2 v2(242.35,87.79)
  IN4 w0.076: 158.92,77.31 160.21,76.03 160.21,75.5 160.82,74.89 160.82,74.48 160.62,74.27 160.36,74.27 v2(160.13,74.04)
  IN4 w0.112: 158.92,77.31 158.61,77.63 157.64,77.63 157.03,78.24 157.03,80.06 157.92,80.95 157.92,82.09 160.83,85 160.83,85.4 161.87,86.44 161.87,87.21 162.44,87.79 164.5,87.79 165.01,87.28 175.61,87.28 176.08,86.8 186.96,86.8 188.55,85.22 189.38,85.22 190.14,84.46 190.93,84.46 191.39,84 202.44,84 202.53,84.1 203.76,84.1 204.16,83.69 207.54,83.69 208.58,84.74 211.65,84.74 212.25,84.14 212.46,84.14 212.96,84.14 213.37,83.74 216.9,83.74 217.05,83.74 217.05,83.73 221.87,83.73 222.26,84.12 222.26,86.65 225.42,89.82 235.94,89.82 236.49,89.26 236.49,88.65 237.12,88.02 242.12,88.02 v2(242.35,87.79)
  BOTTOM w0.076: v2(160.13,74.04) 160.24,74.04 UC1.E22
PCIE_PRX_DTX_N10: length 191.5
  TOP w0.094: v2(260.46,46.97) 260.52,46.97 260.65,46.84 260.65,46.7 CR27.1
  IN4 w0.076: v2(159.26,74.02) 159.49,74.02 159.65,74.17 159.65,74.95 159.82,75.12 159.82,75.41 158.53,76.7 157.48,76.7 156.69,77.49 156.69,77.51
  IN4 w0.112: 156.69,77.51 156.69,77.61 156.37,77.93 156.37,81.48 160.16,85.27 160.16,85.68 161.21,86.72 161.21,87.49 162.17,88.45 162.23,88.45 162.23,88.45 162.29,88.45 162.29,88.45 164.77,88.45 165.28,87.94 175.88,87.94 176.36,87.47 187.24,87.47 188.82,85.88 189.65,85.88 190.41,85.12 202.62,85.12 202.9,85.4 212.24,85.4 212.41,85.23 213.13,85.23 213.96,84.4 217.17,84.4 217.32,84.4 220.52,84.4 221.59,85.47 221.59,87.65 222.06,88.12 222.76,88.12 225.12,90.48 236.8,90.48 238.01,89.26 239.43,89.26 240.97,90.81 243.94,90.81 244.74,90.02 252.08,90.02 252.47,89.63 252.47,87.88 254.42,85.94 254.42,79.15 255.98,77.59 257.23,77.59 258.65,76.18 259.84,76.18 261.63,74.39 264.57,74.39 266.41,72.55 267.98,72.55 272.82,67.71 272.82,66.54 273.22,66.13 273.22,65.76 277.23,61.75 277.23,57.82 276.21,56.8 276.21,56.19 275.88,55.86 275.76,55.74 275.76,54.75 274.13,53.12 274.13,50.04 269.83,45.74 262.97,45.74 262.11,46.6 262.11,47.59 261.48,48.21 260.92,48.21 260.47,47.76 260.47,46.98 v2(260.46,46.97)
  BOTTOM w0.076: v2(159.26,74.02) 159.03,73.79 UC1.F25
PCIE_PRX_DTX_N11: length 155
  TOP w0.094: CN34.1 240.13,34.38 240.13,35.67 238.32,37.48 v4(238.32,40.94) 238.32,42.08 238.36,42.11 238.36,42.71 238.32,42.74 238.32,42.89 v2(238.57,43.13)
  IN4 w0.076: v2(158.38,74.73) 158.5,74.73 158.89,74.34 158.89,73.81 159.65,73.05 161.28,73.05 161.45,73.23 161.45,74.4 161.1,74.76 161.1,76.47 160.22,77.35 160.22,77.35 160.21,77.37
  IN4 w0.112: 160.21,77.37 159.95,77.62 159.95,79 160.37,79.41 160.37,82.07 163.42,85.12 166.01,85.12 166.93,84.2 170.22,84.2 170.36,84.05 170.36,84.05 171.17,83.24 180.54,83.24 182.36,85.06 185.82,85.06 189.23,81.65 191.03,81.65 192.07,80.62 193.99,80.62 195.42,82.05 197.42,82.05 197.97,81.5 200.01,81.5 200.2,81.69 212.5,81.69 212.81,81.99 216.17,81.99 216.32,81.99 219.62,81.99 219.63,81.99 222.81,81.99 224,83.18 224,85.48 224.93,86.41 228.39,86.41 228.93,85.86 228.93,82.96 230.06,81.83 232.2,81.83 238.62,75.42 238.62,71.81 241.01,69.42 241.01,64.13 241.01,63.93 241.01,62.59 242.13,61.46 242.13,57.51 241,56.37 241,54.65 242.27,53.38 242.27,51.47 241.45,50.65 241.45,48.36 240.69,47.6 240.69,46.56 238.75,44.61 238.75,43.57 238.57,43.39 v2(238.57,43.13)
  BOTTOM w0.076: v2(158.38,74.73) 158.36,74.76 157.3,74.76 UC1.E28
PCIE_PRX_DTX_N12: length 101
  TOP w0.094: v2(228.81,36.2) 228.63,36.01 228.63,35.6 CN24.1
  IN4 w0.076: v2(155.61,74.68) 156.18,74.68 156.42,74.43 156.42,73.97 156.18,73.73 156.18,72.81 155.62,72.25 155.62,71.22 156.04,70.81 160.93,70.81 161.37,70.36 171.44,70.36 171.65,70.57 172.17,70.57 172.2,70.6 172.2,70.61 172.21,70.62 172.22,70.62
  IN4 w0.112: 172.22,70.62 172.56,70.62 172.98,70.2 172.98,70.19 173.61,69.57 174.63,69.57 175.9,70.84 176.5,70.84 176.5,70.84 177.17,71.5 180.66,71.5 180.92,71.24 183.71,71.24 184.57,70.38 186.63,70.38 187.42,69.59 190.54,69.59 193.87,66.26 194.84,66.26 195.38,66.26 196.77,64.88 196.77,63.74 199.76,60.74 203.43,60.74 206,58.18 206,57.76 208.32,55.45 208.32,53.18 208.41,53.08 208.53,52.96 208.53,51.29 208.66,51.17 208.66,50.71 209.1,50.27 209.1,48.68 209.48,48.29 210.5,47.27 212.94,47.27 217.62,42.59 221.12,42.59 221.73,41.98 225.9,37.81 225.9,37.46 226.31,37.05 226.76,37.05 226.97,37.25 228.41,37.25 228.79,36.88 228.79,36.22 v2(228.81,36.2)
  BOTTOM w0.076: v2(155.61,74.68) 155.85,74.44 UC1.E30
PCIE_PRX_DTX_P3: length 94.3
  IN1 w0.112: v2(163.92,73.44) 163.97,73.44 164.84,74.31 164.84,75.89 165.45,76.51 168.55,76.51 170.49,78.45 171.41,78.45 172.28,79.33 173.29,79.33 173.63,79.67 173.63,80.39 174.43,81.19 174.43,81.53 174.43,81.53 176.76,83.86 186.33,83.86 186.57,83.62 189.1,83.62 189.3,83.82 190.57,83.82 190.9,83.49 201.92,83.49 202.2,83.21 203.63,83.21 203.82,83.4 208.25,83.4 209.92,81.72 222.9,81.72 223.71,80.92 230.88,80.92 233.86,77.93 233.86,75.05 235.34,73.56 235.55,73.56 236.55,72.55 236.55,68.45 236.27,68.17 236.27,67.5 v2(236.49,67.29)
  BOTTOM w0.076: v2(163.92,73.44) 164.23,73.14 UC1.G16
  BOTTOM w0.094: JNGFF2.35 234.64,67.05 235.08,66.61 236,66.61 236.3,66.91 236.3,67.1 v2(236.49,67.29)
PCIE_PRX_DTX_P5: length 153
  IN4 w0.076: v2(163.88,74.71) 164.04,74.55 164.43,74.55
  IN4 w0.112: 164.43,74.55 165.49,74.55 166.57,75.62 167.45,75.62 167.81,75.26 168.47,75.26 169.56,76.35 172.07,76.35 173.19,75.24 174.73,75.24 175.37,75.87 179.85,75.87 181.44,74.28 185.81,74.28 187.08,75.56 191.73,75.56 193.66,73.63 196.31,73.63 198.2,71.74 199.43,71.74 200.14,72.44 204.92,72.44 206.36,73.88 207.42,73.88 208.14,73.16 209.93,73.16 211.44,74.67 220.96,74.67 221.45,74.18 228.05,74.18 229.5,72.73 229.5,70.87 230.07,70.3 230.07,62.46 230.31,62.22 230.31,60.26 229.16,59.11 229.16,57.78 227.29,55.91 227.29,52.58 228.75,51.12 228.75,47.43 228.13,46.8 228.13,42.37 234.84,35.66 234.84,33.82 234.12,33.1 234.12,28.56 234.53,28.15 235.8,28.15 238.97,24.97 238.97,23.49 241.16,21.3 243.37,21.3 244.47,20.2 245.49,20.2 247.35,18.34 247.35,18.07 v2(247.53,17.89)
  BOTTOM w0.076: v2(163.88,74.71) 164.14,74.71 164.29,74.56 UC1.E16
  BOTTOM w0.094: JNGFF1.33 253.7,15.76 253.76,15.82 253.91,15.82 254.01,15.92 254.01,16.92 253.65,17.29 251.47,17.29 250.12,18.63 247.21,18.63 247.05,18.47 247.05,18.19 247.13,18.11 247.41,18.11 247.53,17.99 v2(247.53,17.89)
PCIE_PRX_DTX_P6: length 159.8
  IN4 w0.076: 163.54,75.27 163.54,75.18 163.32,74.97 163.32,74.14 163.2,74.02 163,74.02 v2(162.95,74.07)
  IN4 w0.112: 163.54,75.27 163.54,75.3 164.59,76.35 168.39,76.35 168.49,76.35 169.24,77.11 172.41,77.11 173.62,75.9 174.46,75.9 175.12,76.57 180.09,76.57 181.71,74.94 185.53,74.94 186.81,76.22 192.81,76.22 194.46,74.57 209.26,74.57 209.65,74.19 210.01,74.19 211.16,75.34 221.23,75.34 221.71,74.86 228.3,74.86 230.19,72.98 230.19,71.12 230.74,70.57 230.74,62.75 230.99,62.49 230.99,61.39 231.59,60.79 231.59,58.52 231.01,57.94 230.26,57.94 228,55.68 228,52.94 229.42,51.52 229.42,47.12 228.84,46.54 228.84,42.6 235.63,35.81 235.63,34.06 236.16,33.54 236.16,28.86 240.11,24.9 240.11,23.42 240.73,22.81 242.66,22.81 243.46,22.01 245.09,22.01 246.47,20.63 246.47,20.19 247.99,18.67 249.48,18.67 252.35,15.8 254.02,15.8 255.56,17.34 256.62,17.34 256.98,17.71 259.8,17.71 v2(260.16,18.06)
  BOTTOM w0.076: UC1.F18 v2(162.95,74.07)
  BOTTOM w0.094: JNGFF1.57 259.7,16.5 259.33,16.87 259.33,17.71 259.61,17.99 260.08,17.99 v2(260.16,18.06)
PCIE_PRX_DTX_P9: length 139.3
  TOP w0.094: CL1.2 264.04,95.53 264.04,96.11 263.07,97.07 261.85,97.07 258.46,100.46 250,100.46 248.78,99.24 248.77,99.24 v4(248.58,99.04) 247.52,97.99 247.48,97.99 247.04,97.55 247.04,97.5 246.78,97.24 244.49,94.95 244.49,92.61 244.21,92.33 244.21,89.64 242.96,88.4 v2(242.35,88.4)
  IN4 w0.076: v2(160.18,74.63) 160.37,74.44 160.55,74.44 160.65,74.55 160.65,74.82 160.04,75.43 160.04,75.91 158.87,77.08
  IN4 w0.112: 158.87,77.08 158.8,77.08 158.53,77.35 157.57,77.35 156.79,78.13 156.79,80.17 157.67,81.05 157.67,82.19 160.58,85.1 160.58,85.5 161.62,86.55 161.62,87.32 162.34,88.04 164.6,88.04 165.11,87.52 175.71,87.52 176.19,87.05 187.06,87.05 188.65,85.46 189.48,85.46 190.24,84.7 191.04,84.7 191.49,84.25 202.34,84.25 202.43,84.34 203.86,84.34 204.26,83.94 207.44,83.94 208.48,84.98 211.75,84.98 212.36,84.38 213.07,84.38 213.47,83.98 217,83.98 217.15,83.98 217.15,83.98 221.77,83.98 222.01,84.23 222.01,86.76 225.32,90.06 236.04,90.06 236.74,89.36 236.74,88.75 237.22,88.27 242.23,88.27 v2(242.35,88.4)
  BOTTOM w0.076: v2(160.18,74.63) 159.78,74.63 159.72,74.57 UC1.E23
PCIE_PRX_DTX_P10: length 191.6
  TOP w0.094: CR26.1 260.84,46.71 260.84,46.82 261,46.97 v2(261.07,46.97)
  IN4 w0.076: v2(159.26,74.81) 159.27,74.81 159.65,75.19 159.65,75.34 158.46,76.53 157.4,76.53 156.51,77.43 156.51,77.44 156.44,77.51
  IN4 w0.112: 156.44,77.51 156.13,77.82 156.13,81.58 159.92,85.37 159.92,85.78 160.96,86.82 160.96,87.59 162.07,88.7 162.13,88.7 164.88,88.7 165.39,88.19 175.99,88.19 176.46,87.71 187.34,87.71 188.93,86.13 189.76,86.13 190.52,85.37 202.52,85.37 202.8,85.65 212.34,85.65 212.52,85.47 213.23,85.47 214.06,84.64 217.27,84.64 217.42,84.64 220.42,84.64 221.35,85.57 221.35,87.75 221.96,88.36 222.66,88.36 225.02,90.72 236.9,90.72 238.11,89.51 239.32,89.51 240.87,91.05 244.05,91.05 244.84,90.26 252.19,90.26 252.71,89.73 252.71,87.99 254.66,86.04 254.66,79.25 256.08,77.84 257.33,77.84 258.75,76.42 259.94,76.42 261.73,74.64 264.67,74.64 266.51,72.79 268.08,72.79 273.06,67.81 273.06,66.64 273.47,66.24 273.47,65.87 277.48,61.85 277.48,61.65 277.48,57.72 276.46,56.7 276.46,56.09 276.13,55.76 276.01,55.64 276.01,54.65 274.38,53.02 274.38,49.94 269.93,45.49 262.86,45.49 261.86,46.49 261.86,47.48 261.38,47.97 261.02,47.97 260.72,47.66 260.72,47.32 v2(261.07,46.97)
  BOTTOM w0.076: v2(159.26,74.81) 158.89,74.44 UC1.E25
PCIE_PRX_DTX_P11: length 155
  TOP w0.094: CN33.1 239.94,34.4 239.94,35.59 238.13,37.4 238.13,40.61 238.1,40.64 238.1,41.23 238.13,41.26 v4(238.13,42.41) 238.13,42.96 v2(237.96,43.13)
  IN4 w0.076: v2(158.36,74.07) 158.36,74.3 158.41,74.36 158.64,74.36 158.73,74.27 158.73,73.74 159.58,72.89 161.34,72.89 161.62,73.16 161.62,74.47 161.26,74.82 161.26,76.54 160.39,77.42 160.39,77.47 160.38,77.49
  IN4 w0.112: 160.38,77.49 160.2,77.66 160.2,78.89 160.62,79.31 160.62,81.97 163.52,84.87 165.91,84.87 166.83,83.95 170.12,83.95 171.07,83 180.44,83 180.44,82.99 180.64,82.99 182.46,84.81 185.72,84.81 189.13,81.41 190.93,81.41 191.97,80.37 194.09,80.37 195.52,81.8 197.32,81.8 197.86,81.26 200.11,81.26 200.3,81.44 212.61,81.44 212.91,81.75 216.07,81.75 216.07,81.75 216.22,81.75 219.52,81.75 219.52,81.75 222.91,81.75 224.25,83.08 224.25,85.38 225.03,86.16 228.28,86.16 228.69,85.76 228.69,82.86 229.96,81.59 232.1,81.59 238.37,75.32 238.37,71.71 240.76,69.32 240.76,64.23 240.76,64.03 240.76,62.48 241.89,61.36 241.89,57.61 240.75,56.48 240.75,54.55 242.03,53.28 242.03,51.57 241.21,50.75 241.21,48.46 240.45,47.7 240.45,46.66 238.5,44.72 238.5,43.67 238.26,43.44 238.06,43.44 237.96,43.34 v2(237.96,43.13)
  BOTTOM w0.076: UC1.E27 157.54,74.44 157.44,74.34 157.44,74.2 157.54,74.1 158.33,74.1 v2(158.36,74.07)
PCIE_PRX_DTX_P12: length 100.8
  TOP w0.094: v2(228.21,36.22) 228.43,36 228.43,35.47 CN23.1
  IN4 w0.076: 172.22,70.37 172.13,70.37 172.1,70.4 171.72,70.4 171.51,70.2 161.3,70.2 160.86,70.64 155.97,70.64 155.46,71.15 155.46,72.32 156.02,72.88 156.02,73.8 156.26,74.04 156.26,74.36 156.11,74.51 155.98,74.51 155.61,74.15 v2(155.61,74.1)
  IN4 w0.112: v2(228.21,36.22) 228.24,36.22 228.52,36.49 228.52,36.8 228.31,37.01 227.07,37.01 226.86,36.8 226.21,36.8 225.65,37.36 225.65,37.71 221.86,41.5 221.02,42.35 217.52,42.35 212.84,47.03 210.61,47.03 210.4,47.03 209.38,48.05 208.85,48.58 208.85,50.16 208.41,50.6 208.41,51.06 208.29,51.19 208.29,52.86 208.07,53.07 208.07,55.34 205.75,57.66 205.75,58.08 203.33,60.5 199.66,60.5 196.52,63.64 196.52,64.78 196.12,65.17 195.28,66.02 194.94,66.02 193.77,66.02 190.44,69.35 187.32,69.35 186.53,70.14 184.47,70.14 183.61,70.99 180.82,70.99 180.55,71.25 177.27,71.25 176.6,70.59 176.4,70.59 176,70.59 174.73,69.32 173.51,69.32 172.74,70.09 172.74,70.09 172.46,70.37 172.22,70.37
  BOTTOM w0.076: v2(155.61,74.1) 155.92,73.79 UC1.F30
PCIE_PRX_RD_DTX_N11: length 2.5
  TOP w0.094: RN82.2 239.74,25.38 239.74,25.76 240.21,26.24 240.21,26.44 240.37,26.59 UN5.15
PCIE_PRX_RD_DTX_N12: length 3.3
  TOP w0.094: RN78.2 227.55,26.39 227.55,26.6 227.83,26.89 228.62,26.89 228.89,27.16 228.89,27.51 229.04,27.67 UN4.15
PCIE_PRX_RD_DTX_P11: length 2.5
  TOP w0.094: UN5.14 239.87,26.62 240.02,26.47 240.02,26.32 239.54,25.84 239.54,25.37 RN81.2
PCIE_PRX_RD_DTX_P12: length 3.3
  TOP w0.094: RN77.2 227.36,26.39 227.36,26.68 227.75,27.08 228.54,27.08 228.7,27.24 228.7,27.48 228.54,27.63 UN4.14
PCIE_PTX_C_DRX_N3: length 2.9
  TOP w0.094: CZ58.2 233.19,65.74 232.66,65.74 v2(232.49,65.92)
  BOTTOM w0.094: v2(232.49,65.92) 232.61,65.79 233.05,65.79 233.31,66.05 JNGFF2.39
PCIE_PTX_C_DRX_N5: length 3.3
  TOP w0.094: CZ14.2 252.69,14.12 252.69,13.89 252.51,13.72 252.51,13.44 v2(252.74,13.21)
  BOTTOM w0.094: v2(252.74,13.21) 252.55,13.41 252.55,13.75 252.7,13.9 JNGFF1.29
PCIE_PTX_C_DRX_N6: length 7.7
  TOP w0.094: CZ22.2 261.25,15.17 261.38,15.04 261.38,14.69 261.19,14.49 260.16,14.49 259.78,14.11 259.78,12.83 259.64,12.69 259.48,12.69 v2(259.09,13.08)
  BOTTOM w0.094: v2(259.09,13.08) 258.8,12.8 258.67,12.8 258.39,13.07 258.39,13.73 258.49,13.82 258.58,13.82 258.7,13.94 JNGFF1.53
PCIE_PTX_C_DRX_N9: length 5.9
  TOP w0.094: CL6.2 262,94.07 262,93.7 262,93.7 v4(262,93.45) 262,92.93 262,92.93 262.47,92.46 262.47,92.42 262.88,92 262.93,92 263.66,91.26 263.94,91.26 264.4,90.81 264.4,90.58 264.29,90.48 UL1.42
PCIE_PTX_C_DRX_N10: length 2
  TOP w0.094: CR25.2 262.8,45.17 262.8,44.54 262.91,44.43 262.91,44.29 262.72,44.1 UR2.4
PCIE_PTX_C_DRX_N11: length 30
  TOP w0.094: CN36.1 242.96,23.91 242.96,23.23 241.89,22.16 241.89,19.13 246.7,14.31 246.7,12.78 247.46,12.02 250.58,12.02 251.18,11.42 251.18,9.59 251.58,9.19 v4(255.18,9.19) 256.3,9.19 256.34,9.15 256.93,9.15 256.96,9.19 257.65,9.19 258.08,9.61 v2(258.08,10.37)
  BOTTOM w0.094: v2(258.08,10.37) 257.91,10.2 257.91,10.08 258.05,9.94 JNGFF3.35
PCIE_PTX_C_DRX_N12: length 35.2
  TOP w0.094: CN26.1 230.91,24.78 230.91,24.1 231.38,23.64 233.55,23.64 239.54,17.65 241.13,17.65 244.38,14.39 244.38,12.79 248.7,8.47 248.88,8.47 250.34,7.01 250.77,7.01 250.8,6.98 251.39,6.98 251.42,7.01 v4(252.52,7.01) 253.11,7.01 253.43,7.33 253.85,7.33 v2(253.94,7.24)
  BOTTOM w0.094: JNGFF3.47 255.05,8.41 255.04,8.4 255.04,7.7 254.59,7.25 253.97,7.25 253.96,7.24 v2(253.94,7.24)
PCIE_PTX_C_DRX_P3: length 2.9
  TOP w0.094: v2(232.47,65.32) 232.7,65.55 233.25,65.55 CZ59.2
  BOTTOM w0.094: v2(232.47,65.32) 232.75,65.6 233.05,65.6 233.1,65.55 JNGFF2.41
PCIE_PTX_C_DRX_P5: length 3.3
  TOP w0.094: CZ13.2 252.49,14.12 252.49,13.97 252.32,13.8 252.32,13.4 v2(252.13,13.21)
  BOTTOM w0.094: JNGFF1.27 252.2,13.9 252.35,13.75 252.35,13.43 v2(252.13,13.21)
PCIE_PTX_C_DRX_P6: length 7.7
  TOP w0.094: CZ21.2 261.57,14.9 261.57,14.61 261.27,14.3 260.24,14.3 259.97,14.03 259.97,12.75 259.72,12.5 v2(259.09,12.5)
  BOTTOM w0.094: JNGFF1.51 258.2,12.99 258.59,12.6 258.99,12.6 v2(259.09,12.5)
PCIE_PTX_C_DRX_P9: length 5.9
  TOP w0.094: CL5.2 262.19,94.09 262.19,93.78 262.23,93.75 262.23,93.15 262.19,93.12 262.19,93.01 v4(262.83,92.37) 263.74,91.46 264.02,91.46 264.59,90.89 264.59,90.6 264.69,90.49 UL1.41
PCIE_PTX_C_DRX_P10: length 2
  TOP w0.094: CR24.2 262.99,44.98 262.99,44.62 263.12,44.5 UR2.3
PCIE_PTX_C_DRX_P11: length 30
  TOP w0.094: CN35.1 243.16,23.62 243.16,23.15 242.08,22.08 242.08,19.21 246.9,14.39 246.9,12.86 247.54,12.22 250.66,12.22 251.37,11.5 251.37,9.67 251.66,9.38 254.86,9.38 254.89,9.41 255.48,9.41 255.51,9.38 v4(256.63,9.38) 257.57,9.38 257.88,9.69 257.88,9.98 257.8,10.06 257.52,10.06 257.44,10.14 v2(257.44,10.37)
  BOTTOM w0.094: v2(257.44,10.37) 257.54,10.37 257.72,10.19 257.72,10.06 257.55,9.89 JNGFF3.37
PCIE_PTX_C_DRX_P12: length 35.1
  TOP w0.094: v2(253.94,7.85) 253.61,7.52 253.35,7.52 253.03,7.21 252.85,7.21 252.81,7.24 252.22,7.24 252.19,7.21 v4(251.1,7.21) 250.42,7.21 248.96,8.67 248.78,8.67 244.57,12.87 244.57,14.47 241.21,17.84 239.62,17.84 233.63,23.83 231.46,23.83 231.1,24.18 231.1,24.78 CN25.1
  BOTTOM w0.094: v2(253.94,7.85) 254.04,7.85 254.14,7.75 254.14,7.61 254.31,7.44 254.51,7.44 254.85,7.78 254.85,8.23 254.77,8.31 254.67,8.31 254.55,8.43 JNGFF3.49
