# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_XDP_WAN_SMBCLK: length 354
  TOP w0.102: JXDP1.53 92.61,40.94 v2(92.22,40.54) ; v2(197.2,52.47) 196.1,52.47 195.54,51.9 QC2.1
  TOP w0.203: UN1.1 251.45,32.59 251.22,32.82 v3(250.18,32.82) v2(249.26,32.82)
  IN1 w0.089: v2(249.26,32.82) 247.97,31.53 246.06,31.53 245.34,30.81 242.25,30.81 242.07,30.99 241.74,31.32 238.36,31.32 237.85,30.81 234.48,30.81 234.09,30.81 231.1,27.82 224.41,27.82 224.4,27.82 224.26,27.82 223.73,28.35 221.05,28.35 220.48,27.78 220.48,25.24 223.56,22.16 224.2,22.16 225.99,20.38 225.99,17.9 v2(225.59,17.5) 225.17,17.09 225.17,13.54 224.29,12.66 223.99,12.66 223.44,12.11 222.5,12.11 222.1,12.51 190.01,12.51 190,12.5 189.25,12.5 189.22,12.53 170.55,12.53 170.55,12.53 168.89,12.53 168.87,12.51 159.39,12.51 156.16,15.73 148.68,15.73 146.99,17.42 144.88,17.42 v2(144.72,17.58)
  IN4 w0.089: v2(92.22,40.54) 93.11,39.65 94.23,39.65 95.08,38.8 95.63,38.8 95.95,38.48 95.95,29.35 86.62,20.03 86.62,12.73 87.8,11.55 90.29,11.55 90.66,11.17 92.23,11.17 92.68,10.72 131.31,10.72 131.53,10.94 145.78,10.94 148.16,13.33 148.16,16.86 147.44,17.58 v2(144.72,17.58)
  BOTTOM w0.102: v2(144.72,17.58) 143.87,18.42 JDIMM1.253 ; RC319.2 v2(197.2,52.47) 197.22,52.44 197.22,49.13 198.26,48.09 198.26,47.13 199.49,45.9 205.69,45.9 205.96,46.17 216.4,46.17 217.42,47.2 219.71,47.2 219.96,47.45 220.52,47.45 221.59,46.38 223.03,46.38 223.33,46.08 227.26,46.08 229.51,48.33 229.51,48.74 229.85,49.09 233.63,49.09 236.58,52.04 237.78,52.04 240.38,49.43 240.38,45.71 240.83,45.25 240.83,43.73 240.44,43.33 240.44,42.58 239.89,42.04 239.89,39.14 240.4,38.64 240.4,35.56 238.05,33.2 237.47,33.2 232.35,28.08 232.35,25.67 231.64,24.96 231.64,22.22 232.88,20.98 232.88,15.01 231.79,13.92 229.19,13.92 227.21,15.9 226.58,15.9 226.29,16.19 225.79,16.19 225.59,16.39 v2(225.59,17.5) 225.97,17.89 225.97,18.93 225.87,19.02 JDIMM2.253
DDR_XDP_WAN_SMBDAT: length 355.8
  TOP w0.102: QC2.4 196.84,54.31 v2(197.17,54.64) ; JXDP1.51 v2(92.11,41.15)
  TOP w0.203: v2(249.26,30.94) 249.41,31.09 UN1.4
  IN1 w0.089: v2(144.9,16.27) 144.9,16.83 145.01,16.95 146.8,16.95 148.48,15.26 155.97,15.26 159.2,12.04 169.07,12.04 169.09,12.06 170.75,12.06 170.75,12.06 189.02,12.06 189.05,12.03 190.2,12.03 190.2,12.04 221.91,12.04 222.31,11.64 223.64,11.64 224.19,12.19 224.49,12.19 225.64,13.34 225.64,14.15 v2(225.84,14.35) 226.46,14.97 226.46,20.58 224.4,22.63 223.75,22.63 220.95,25.43 220.95,27.59 221.23,27.87 223.55,27.87 224.07,27.35 224.21,27.35 224.21,27.35 231.29,27.35 234.29,30.34 238.85,30.34 239.31,30.8 241.6,30.8 242.05,30.34 245.54,30.34 246.14,30.94 v2(249.26,30.94)
  IN4 w0.089: v2(144.9,16.27) 144.9,16.92 145.08,17.11 147.24,17.11 147.69,16.67 147.69,13.52 145.58,11.41 131.34,11.41 131.12,11.19 92.87,11.19 92.42,11.64 90.86,11.64 90.48,12.02 88,12.02 87.09,12.93 87.09,19.83 96.42,29.16 96.42,38.68 94.92,40.17 93.28,40.17 92.33,41.13 92.14,41.13 v2(92.11,41.15)
  BOTTOM w0.102: v2(197.17,54.64) 197.2,54.61 RC318.2 197.7,53.48 197.7,49.33 198.75,48.29 198.75,47.33 199.7,46.38 205.49,46.38 205.76,46.65 216.2,46.65 217.22,47.68 219.51,47.68 219.76,47.93 220.72,47.93 221.79,46.87 223.23,46.87 223.53,46.57 227.06,46.57 229.02,48.53 229.02,48.94 229.65,49.57 233.43,49.57 236.38,52.52 237.98,52.52 240.86,49.63 240.86,45.91 241.32,45.45 241.32,43.53 240.92,43.13 240.92,42.38 240.38,41.84 240.38,39.34 240.88,38.84 240.88,35.36 238.25,32.72 237.67,32.72 232.83,27.88 232.83,25.47 232.12,24.76 232.12,22.42 233.36,21.18 233.36,14.81 231.99,13.44 228.99,13.44 227.01,15.42 226.38,15.42 226.09,15.7 225.92,15.7 225.92,15.7 225.84,15.63 v2(225.84,14.35) 226.25,13.95 226.25,13.11 226.12,12.99 JDIMM2.254 ; JDIMM1.254 144.12,14.12 144.9,14.89 v2(144.9,16.27)
DEW1: length 4.3
  TOP w0.102: UN7.16 263.13,26.95 263.38,27.21 263.38,28.86 263.16,29.09 RN21.2 RN20.2
DEW2: length 8
  TOP w0.102: RN18.2 RN19.2 263.49,18.86 264.13,19.5 264.61,19.5 v3(264.66,19.55) 264.66,20.1 263.5,21.25 262.45,21.25 262.09,21.62 261.43,21.62 261.13,21.92 UN7.6
DH_1.2V: length 4.7
  IN1 w1.016: 88.48,54.61 87.29,55.81 84.32,55.81
  vias: v2(81.14,57.6) v2(81.09,56.98) v2(89.52,53.93) v2(90.11,53.93)
DIMM1_SA0: length 6.4
  TOP w0.102: RD62.2 RD66.1 146.39,13.85 v2(146.14,14.1) 145.8,14.1 v1(145.51,13.81)
  BOTTOM w0.102: JDIMM1.256 144.62,12.81 144.5,12.93 144.5,13.61 144.99,14.1 v2(146.14,14.1)
DIMM1_SA1: length 3.7
  TOP w0.102: RD63.2 RD67.1 146.64,12.98 v2(146.24,13.39)
  BOTTOM w0.102: JDIMM1.260 145.62,12.39 146.24,13.01 v2(146.24,13.39)
DIMM1_SA2: length 4.7
  TOP w0.102: v2(123.43,10.27) 123.86,10.7 RD64.2 RD68.1
  BOTTOM w0.102: v2(123.43,10.27) 122.53,10.27 122.12,10.67 JDIMM1.166
DIMM2_SA0: length 6.1
  TOP w0.102: v2(226.78,10.37) 227.57,11.16 v3(227.57,12.16) 227.57,12.49 227.99,12.91 RD72.1 RD69.2
  BOTTOM w0.102: JDIMM2.256 226.62,10.53 v2(226.78,10.37)
DIMM2_SA1: length 4
  TOP w0.102: v2(227.42,10.37) 228.18,11.13 RD73.1 RD70.2
  BOTTOM w0.102: v2(227.42,10.37) 227.62,10.57 JDIMM2.260
DIMM2_SA2: length 4.3
  TOP w0.102: RD71.2 RD74.1 204.3,11.31 204.3,10.49 v2(204.43,10.37) v1(204.98,10.37)
  BOTTOM w0.102: v2(204.43,10.37) 204.12,10.67 JDIMM2.166
DIMM_TYPE: length 13
  BOTTOM w0.076: 175.19,71.07 174.14,70.02 173.05,70.02 UC1.P2
  BOTTOM w0.102: RC341.2 182.57,70.96 182.56,70.96 182.16,70.56 182.16,70.35 RC342.1 180.97,70.17 180.97,70.82 180.51,71.28 179.76,71.28 179.53,71.5 v1(175.89,71.5) 175.62,71.5 175.19,71.07
DIS_BAT_PROCHOT#: length 28.2
  TOP w0.102: UE1.B51 253.64,77.61 253.88,77.37 v2(254.39,77.37) ; PR907.1 253.91,91.27 v2(253.91,91.01) 254.23,91.01 v3(254.48,91.27)
  IN3 w0.122: v2(254.39,77.37) 254.09,77.07 251.93,77.07 251.29,76.43 251.29,75.9 250.81,75.41 250.3,75.41 250.01,75.7 250.01,77.66 250,77.68 248.99,78.69 248.99,80.68 251.52,83.21 253.4,83.21 253.77,83.58 253.77,84.34 254.71,85.28 254.71,90.21 v2(253.91,91.01)
DISP_ON: length 5.4
  TOP w0.102: v2(86.26,85.17) 85.56,85.87 RV2.1
  BOTTOM w0.102: DV2.1 84.47,85.16 84.8,85.48 85.95,85.48 v2(86.26,85.17) 86.75,85.66 JEDP1.22
DK_AC_OFF: length 8.9
  TOP w0.102: PD901.3 26.67,88.91 26.29,89.29 v3(24.55,89.29) 24.4,89.14 24.4,85.96 24.62,85.73 24.89,85.73 25.68,84.94 PU901.25
DK_AC_OFF_EN: length 2.4
  TOP w0.102: PR938.1 27.37,85.62 27.37,84.95 27.18,84.76 PU901.22
DK_CSS_GC: length 16.9
  TOP w0.254: PU901.11 30.08,79.79 30.75,79.13 30.75,78.28 31.4,77.63 31.94,77.63 32.38,77.19 32.38,77.17 32.39,77.15 32.39,76.52 v3(32.5,76.41) 32.5,75.54 33.43,74.62 35.07,74.62 35.13,74.68 35.51,74.68 35.58,74.62 40.03,74.62 v2(41.34,75.92)
  BOTTOM w0.254: PR810.1 41.11,76.05 41.21,76.05 v2(41.34,75.92)
DK_PWRBAR: length 3
  TOP w0.254: v2(22.52,80.88) 22.61,80.79 PU901.33
  BOTTOM w0.508: v2(22.52,80.88) 23.87,80.88 PR924.1
DL_1.2V: length 7.9
  IN1 w1.016: 82.32,51.08 82.86,50.55 85.89,50.55 87.01,51.67 89.52,51.67 89.52,51.67
  vias: v2(81.83,51.95) v2(82.41,51.92) v2(90.66,52.18) v2(91.22,52.4)
DMIC0: length 277.1
  TOP w0.102: v2(94.58,87.63) 94.58,87.05 94.45,86.92 CA6.1 ; UA1.47 277.31,37.03 276.92,37.42 276.05,37.42 274.68,38.79 273.24,38.79 v2(273.03,38.99)
  IN2 w0.122: v2(273.03,38.99) 271.74,40.29 271.74,41.55 271.34,41.95 271.34,43.53 271.06,43.8 271.06,45.09 273.67,47.7 273.67,50.48 273.67,50.48 273.67,51 276.22,53.55 277.2,53.55 278.22,54.57 278.22,64.34 276.92,65.64 276.92,66.39 275.04,68.28 274.4,68.28 273.79,68.89 273.79,69.94 271.42,72.31 271.17,72.31 267.54,75.93 267.54,76.11 266.95,76.71 266.95,82.07 265.95,83.06 265.95,85.74 266.63,86.42 266.63,88.28 266.01,88.9 264.75,88.9 262.11,91.54 262.11,93.36 259.22,96.24 254.75,96.24 254.59,96.41 250.47,96.41 246.33,100.55 246.33,101.62 245.67,102.28 245.67,102.32 244.6,103.39 234.8,103.39 234.22,103.39 233.97,103.14 232.17,103.14 v2(230.53,101.5) ; v2(230.14,98.33) 229.23,98.33 228.53,97.63 225.67,97.63 225.05,98.25 221.09,98.25 220.32,99.02 217.92,99.02 217.19,99.02 217.08,98.91 207.8,98.91 202.13,93.23 193.27,93.23 192.85,93.23 192.34,93.23 186.83,98.74 184.93,98.74 184.1,98.74 183.14,99.7 178.63,99.7 178.22,99.3 177.81,99.3 173.44,99.3 169.43,103.31 168.43,103.31 168.01,103.31 167.28,104.04 167.28,105.61 166.01,106.88 162.83,106.88 161.93,107.79 160.83,107.79 160.23,107.18 158.49,107.18 158.13,107.55 157.47,108.21 156.23,108.21 156.23,108.21 151.37,108.21 150.26,107.1 145.86,107.1 144.66,105.89 144.66,105.3 144.66,103.58 143.36,102.28 143.27,102.19 143.27,100.99 142.35,100.08 142.35,98.04 139.38,95.07 128.95,95.07 127.15,93.26 126.4,92.51 126.4,92.33 125.5,91.43 121.25,91.43 119.71,89.89 117.65,89.89 117.51,90.03 116.93,90.61 107.42,90.61 106.54,91.49 105.88,91.93 105.55,92.06 105.16,92.23 104.96,92.27 104.61,92.34 104.39,92.38 103.06,92.38 102.24,92.38 99.51,89.65 99.51,88.78 98.78,88.05 96.96,88.05 96.91,87.99 95.65,87.99 95.29,87.63 v2(94.58,87.63)
  BOTTOM w0.102: v2(94.58,87.63) 94.58,87.61 94.25,87.28 JEDP1.7 ; v2(230.14,98.33) 229.94,98.53 229.94,100.37 230.19,100.62 v3(230.19,100.63) 230.53,100.97 v2(230.53,101.5)
DMIC_CLK0: length 290.7
  TOP w0.102: CA5.1 93.1,88.19 v2(92.9,88.4) ; RA14.2 274.28,36 271.95,36 271.44,35.49 CA54.1 271,34.7 v2(270.83,34.52)
  IN2 w0.122: v2(270.83,34.52) 270.83,34.56 271.21,34.95 271.21,37.07 271.78,37.65 273.36,37.65 273.95,38.24 273.95,39.67 273.88,39.74 273.88,42.24 273.18,42.94 273.18,44.21 273.49,44.53 273.49,46.29 274.42,47.22 274.42,50.67 275.76,52.01 277.18,52.01 279.35,54.18 279.35,57.91 279.01,58.26 279.01,62.06 280.28,63.33 280.65,63.33 285.18,67.87 285.81,67.87 286.43,68.49 v2(286.73,68.49) ; v2(231.65,98.33) 231.65,98.48 231.19,98.94 221.11,98.94 220.53,99.52 218.13,99.52 216.98,99.52 216.87,99.41 207.59,99.41 201.92,93.73 193.06,93.73 193.06,93.73 192.64,93.73 192.59,93.73 187.08,99.25 184.31,99.25 183.35,100.21 178.42,100.21 178.01,99.8 173.65,99.8 169.64,103.81 168.22,103.81 167.81,104.22 167.81,105.79 166.76,106.84 166.76,107.37 166.13,108 162.52,108 162.24,108.29 160.62,108.29 160.02,107.69 158.72,107.69 157.7,108.71 157.67,108.71 151.16,108.71 150.05,107.6 145.66,107.6 144.16,106.1 144.16,105.09 144.16,103.89 141.24,100.97 141.24,98.15 139.48,96.4 136.92,96.4 136.14,95.62 128.8,95.62 126.65,93.47 125.9,92.72 125.9,92.54 125.29,91.93 110.04,91.93 109.68,92.29 108.97,92.29 108.63,92.29 108.63,92.29 107.01,92.29 106.33,92.75 106.1,92.84 105.91,92.92 105.72,93 105.55,93.07 105.38,93.16 105.35,93.16 105.34,93.16 105.33,93.16 105.25,93.16 105.14,93.18 104.79,93.25 104.48,93.31 103.44,93.31 101.82,93.31 99.17,90.66 94.6,90.66 92.9,88.95 v2(92.9,88.4)
  IN4 w0.089: v2(286.73,68.49) 286.73,69.9 284.92,71.71 282.94,71.71 281.82,72.83 277.39,72.83 275.68,74.54 274.62,74.54 270.52,78.64 268.77,78.64 265.9,81.5 265.9,85.41 267,86.5 267,87.59 265.49,89.09 264.31,89.09 261.92,91.48 261.92,92.72 261.02,93.62 261.02,95.09 259.28,96.83 257.49,96.83 255.22,99.1 232.42,99.1 v2(231.65,98.33)
  BOTTOM w0.102: v2(92.9,88.4) 93.25,88.05 JEDP1.9
DMIC_CLK_CODEC: length 2.7
  TOP w0.102: UA1.2 275.65,35.28 274.89,36.04 274.89,36.55 RA14.1
DOCK_AC_OFF: length 135.1
  TOP w0.102: v2(28.95,89.49) 28.95,89.84 PR925.1 26.75,90.46 PD901.1
  IN2 w0.122: v2(134.12,110.67) 133.86,110.67 132.91,111.62 128.4,111.62 125.45,108.68 125.45,103.25 119.06,96.85 114.17,96.85 113.16,95.85 107.09,95.85 106.49,96.45 105.81,96.59 105.03,96.74 104.88,96.77 101.1,100.55 100.11,101.54 96.78,101.54 96.23,100.99 94.86,100.99 92.8,98.93 60.6,98.93 59.71,99.82 59.71,100.24 59.25,100.7 58.97,100.7 58.19,99.93 54.81,99.93 53.85,98.96 53.85,98.77 50.11,95.03 50.11,93.54 45.74,89.17 43.03,89.17 42.65,89.55 40.16,89.55 36.99,92.71 29.73,92.71 28.54,91.52 28.54,89.9 v2(28.95,89.49)
  BOTTOM w0.102: JDOCK1.2 134.5,110.3 v2(134.12,110.67)
DOCK_AC_OFF_EC: length 285.7
  TOP w0.102: PR929.1 PR938.2 26.84,87.15 27.42,87.74 27.62,87.74 27.78,87.9 27.78,89.07 v2(27.42,89.43) ; v2(255.79,86.21) 255.78,86.21 255.45,85.88 UE1.A63
  IN3 w0.122: v2(27.42,89.43) 28.59,90.61 29.88,90.61 30.6,91.33 34.01,91.33 34.78,90.57 37.81,90.57 40.82,87.56 44.81,87.56 54.77,97.51 54.97,97.51 56.32,97.51 57.47,98.66 59.57,98.66 60.18,98.05 63.11,98.05 63.96,97.2 79.11,97.2 80.32,98.41 92.22,98.41 92.95,97.68 101.23,97.68 101.44,97.68 104.43,94.69 106.2,94.69 106.61,94.28 107.16,94.28 115.39,94.28 115.95,94.83 115.95,96.15 117.12,97.33 119.39,97.33 126.8,104.75 126.8,108.79 128.79,110.77 132.89,110.77 133.85,109.81 135.1,109.81 136.5,108.41 145.18,108.41 145.91,107.69 148.42,107.69 149.18,108.45 156.49,108.45 158.72,110.67 176.73,110.67 176.93,110.67 178.18,109.43 178.47,109.14 178.47,108.52 178.47,108.52 178.47,108.41 179,107.88 179,100.86 181.27,98.58 188.28,98.58 192.28,94.57 199.76,94.57 199.83,94.64 201.4,94.64 206.79,100.04 206.79,101.2 207.28,101.68 207.28,101.78 210.46,104.96 213.42,104.96 214.18,104.19 227.84,104.19 229.15,102.88 229.95,102.88 230.1,103.03 232.05,103.03 232.6,102.48 237.45,102.48 237.74,102.19 243.13,102.19 244.1,102.19 245.46,100.83 245.62,100.67 246.35,99.94 246.5,99.79 249.47,96.83 249.47,95.5 251.25,93.71 253.11,93.71 255.76,91.06 255.76,90.24 255.51,89.98 255.51,86.49 v2(255.79,86.21)
  BOTTOM w0.102: v2(255.79,86.21) 255.18,85.61 v1(255.18,84.09)
DOCK_DCIN_IS+: length 161.9
  IN4 w0.254: v2(44.67,74.28) 44.77,74.38 44.77,74.64 43.78,75.62 43.78,76.58 46.09,78.88 46.09,81.95 50.48,86.34 54.49,86.34 55.21,87.06 55.21,89.09 55.72,89.6 55.72,90.04 58.97,93.3 61.51,93.3 62.47,94.26 62.47,95.94 64.17,97.64 79.13,97.64 80.22,98.73 91.71,98.73 92.59,97.84 96.22,97.84 96.6,98.23 102.21,98.23 102.75,97.68 103.63,97.68 104.99,96.32 106.92,96.32 107.11,96.12 107.49,96.12 107.8,95.82 112.96,95.82 114.37,97.23 115.1,97.23 116.37,98.49 122.66,98.49 124.67,100.51 124.67,106.64 124.67,107.06 124.67,107.48 128.49,111.29 132.71,111.29 134.77,109.24 144.51,109.24 146.08,110.81 148.82,110.81 149.44,110.19 151.01,110.19 152.28,111.46 162.86,111.46 164.13,110.19 166.37,110.19 168.74,107.83 169.24,107.83 169.63,107.44 v2(169.63,107.45)
  BOTTOM w0.254: v2(44.67,74.28) 44.67,75.11 44.47,75.31 PQ804.1 ; v2(169.63,107.45) 169.63,107.5 169.5,107.63 JDOCK1.134
DOCK_DCIN_IS-: length 161.9
  IN4 w0.254: v2(45.27,74.3) 45.27,74.85 44.29,75.84 44.29,76.37 46.6,78.67 46.6,81.74 50.69,85.83 54.7,85.83 55.71,86.85 55.71,88.88 56.23,89.39 56.23,89.83 59.18,92.79 61.72,92.79 62.98,94.05 62.98,95.73 64.38,97.13 79.34,97.13 80.44,98.23 91.5,98.23 92.38,97.34 96.43,97.34 96.81,97.72 102,97.72 102.54,97.18 103.42,97.18 104.78,95.81 106.71,95.81 106.9,95.61 107.28,95.61 107.59,95.31 113.18,95.31 114.58,96.72 115.31,96.72 116.58,97.98 122.87,97.98 125.18,100.3 125.18,100.72 125.18,100.72 125.18,106.85 125.18,106.85 125.18,107.27 128.7,110.79 132.5,110.79 134.56,108.73 144.72,108.73 146.3,110.3 148.61,110.3 149.23,109.68 151.22,109.68 152.49,110.95 162.65,110.95 163.92,109.68 166.16,109.68 168.53,107.32 169.03,107.32 v2(169.51,106.84)
  BOTTOM w0.254: v2(169.51,106.84) 169.75,106.84 170.14,107.24 170.14,107.67 170,107.81 JDOCK1.136 ; PQ805.1 45.82,75.31 45.27,74.77 v2(45.27,74.3)
DOCK_DET#: length 412
  TOP w0.102: R272.1 170.5,108.46 v3(171.37,109.33) 172.04,110 177.31,110 180.67,106.64 180.67,101.95 v2(180.94,101.68) ; PR919.1 63.71,16.29 63.71,14.89 v2(63.76,14.84) ; v2(70.56,15.02) PQ907.2 ; UE1.B41 248.64,78.73 248.4,78.97 247.55,78.97 247.28,79.24 247.28,79.25 247.28,79.25 247.28,79.63 247.55,79.9 251.53,79.9 v2(251.95,79.48)
  IN2 w0.122: v2(70.56,15.02) 70.56,14.7 70.09,14.23 64.02,14.23 63.76,14.49 v2(63.76,14.84)
  IN3 w0.122: v2(251.95,79.48) 251.95,80.14 252.45,80.64 253.67,80.64 254.76,81.73 254.76,82.53 255.02,82.79 255.02,83.6 255.68,84.27 257.38,84.27 257.94,84.83 257.94,87.54 256.79,88.7 256.79,90.84 255.23,92.4 255.23,97.4 253.39,99.23 252.57,99.23 248,103.79 248,104.62 247.64,104.98 229.03,104.98 227.84,106.18 220.54,106.18 219.88,106.84 217.94,106.84 217.36,107.42 217.36,109.21 216.2,110.37 209.64,110.37 205.9,106.63 205.9,102.25 205.41,101.77 205.41,100.61 200.83,96.03 199.26,96.03 199.19,95.95 193.6,95.95 189.33,100.22 182.4,100.22 v2(180.94,101.68)
  IN4 w0.089: v2(70.56,15.02) 70.56,14.04 71.2,13.4 79.01,13.4 80.05,12.36 83.94,12.36 84.42,12.84 84.42,20.56 93.53,29.67 93.53,35.26 93.03,35.75 93.03,37.46 90.85,39.65 90.85,41.21 94.57,44.93 94.57,50.23 94.78,50.44 94.78,55.79 94.57,56 94.57,57.36 92.61,59.31 89.52,59.31 89.16,59.67 87.65,59.67 87.26,60.07 82.45,60.07 81.92,59.53 79.58,59.53 79.16,59.94 77.81,61.3 77.81,64.34 76.88,65.28 76.88,69.85 76.14,70.59 75.25,70.59 74.31,71.53 74.31,72.58 75.28,73.55 76.57,73.55 78.8,75.78 78.8,77.73 78.04,78.49 78.04,80.78 77.11,81.72 77.11,81.97 76.22,82.86 76.22,83.83 77.58,85.19 77.58,86.07 77.94,86.43 77.96,86.43 77.96,88.67 77.59,89.04 77.59,93.4 80.66,96.47 88.97,96.47 89.41,96.03 92.23,96.03 92.7,96.5 98.39,96.5 98.87,96.98 101.63,96.98 102.34,96.26 103.34,96.26 104.47,95.13 106.42,95.13 106.62,94.93 107,94.93 107.3,94.63 113.46,94.63 114.86,96.04 115.59,96.04 116.86,97.3 123.15,97.3 125.86,100.02 125.86,106.32 129.48,109.94 132.34,109.94 134.57,107.7 155.56,107.7 157.51,109.65 161.03,109.65 162.09,108.59 165.27,108.59 166.64,107.22 166.64,106.98 167.46,106.16 169.87,106.16 171.06,107.36 171.06,108.14 172.57,109.65 179.23,109.65 180.94,107.94 v2(180.94,101.68)
  BOTTOM w0.102: v2(180.94,101.68) 181,101.61 D19.2
DOCK_DET_R#: length 25.7
  BOTTOM w0.102: JDOCK1.142 171.5,107.41 171.61,107.3 171.87,107.3 172,107.42 JDOCK1.144 172,109.8 172.28,110.07 177.15,110.07 180.15,107.07 180.15,99.48 180.55,99.08 180.55,97.75 v3(180.25,97.45) 179.6,96.8 D19.1
DOCK_HP_DET: length 127.7
  TOP w0.102: v2(249.85,89.4) 249.85,88.84 250.39,88.3 UE1.A7 ; v2(279.35,21.52) 279.35,21.52 279.35,22.12 278.8,22.66 278.8,23.22 RA29.2 278.62,23.4 QA3.2
  IN2 w0.122: v2(253.81,98.1) 255.62,98.1 256.98,96.74 260.58,96.74 262.61,94.72 262.61,92.67 264.32,90.95 264.32,90.55 264.65,90.23 265.48,89.4 266.22,89.4 267.13,88.49 267.13,86.21 266.45,85.53 266.45,83.97 268.64,81.78 268.64,75.54 271.37,72.81 271.63,72.81 273.28,71.15 275.6,71.15 275.75,71.3 275.98,71.54 279.71,71.54 279.74,71.51 281.94,71.51 282.25,71.83 284.93,71.83 287.74,69.02 287.74,67.44 287.95,67.24 287.95,66.4 287.34,65.8 287.34,64 286.57,63.22 285.91,63.22 285.26,62.57 285.26,58.91 282.57,56.22 282.57,53.1 281.88,52.41 280.77,51.3 280.37,51.3 279.86,51.3 279.01,50.44 279.01,46.34 278.92,46.26 276.38,43.71 276.38,43.26 276.38,43.26 276.38,43.06 276.38,43.06 276.38,42.85 275.98,42.45 275.98,40.61 276.06,40.54 276.06,36.81 275.98,36.74 275.98,36.35 276.18,36.15 276.18,30.1 274.53,28.45 274.53,26.68 279.35,21.87 279.35,21.52 v2(279.35,21.52)
  BOTTOM w0.102: v2(253.81,98.1) v3(253.81,97.04) 253.81,96.63 253.13,95.94 253.13,93.09 252.67,92.63 252.67,90.71 251.68,89.72 250.17,89.72 v2(249.85,89.4)
DOCK_MIC_DET: length 126
  TOP w0.102: v2(250.56,86.57) 250.27,86.57 250.14,86.69 UE1.B8 ; QA3.5 275.97,23.91 275.97,24.29 275.77,24.48 275.12,24.48 274.98,24.62 273.24,24.62 v2(272.93,24.92) 272.76,24.74 RA26.2
  IN2 w0.122: v2(272.93,24.92) 273.49,25.48 273.49,27.97 275.63,30.11 275.93,30.41 275.93,35.97 275.73,36.17 275.73,36.84 275.81,36.91 275.81,40.44 275.73,40.51 275.73,42.56 276.13,42.95 276.13,43.16 276.13,43.81 278.68,46.36 278.68,50.47 279.76,51.55 280.47,51.55 280.48,51.55 280.67,51.55 281.78,52.66 281.78,52.66 282.32,53.2 282.32,56.33 282.47,56.47 284.19,58.2 284.19,61.93 285.81,63.55 286.35,63.55 286.98,64.18 286.98,66.22 286.78,66.42 286.78,67.08 287.36,67.67 287.36,68.78 284.57,71.58 282.5,71.58 282.16,71.23 276.03,71.23 275.85,71.05 275.85,71.05 275.7,70.9 273.18,70.9 271.52,72.56 271.27,72.56 268.31,75.52 268.31,81.76 266.2,83.87 266.2,85.64 266.88,86.31 266.88,88.38 266.12,89.15 264.85,89.15 262.36,91.64 262.36,94.61 260.48,96.49 256.88,96.49 255.7,97.67 v2(254.32,97.67)
  BOTTOM w0.102: v2(250.56,86.57) 250.79,86.8 250.79,87.9 251.04,88.16 251.04,89.12 251.39,89.46 252.62,89.46 253.28,90.12 253.28,91.54 v3(253.05,91.76) 253.05,92.25 253.41,92.6 253.41,95.74 254.32,96.65 v2(254.32,97.67)
DOCK_POR_RST#: length 164.5
  TOP w0.102: UE2.A21 267.65,67.51 v2(268.18,68.05) 267.91,68.05 267.65,68.3 RE277.2
  IN3 w0.122: v2(180.68,111.15) 180.36,110.83 180.36,101.67 182.12,99.9 188.91,99.9 193.11,95.71 199.29,95.71 199.36,95.78 200.93,95.78 205.66,100.51 205.66,101.67 206.15,102.15 206.15,106.52 209.74,110.12 216.09,110.12 216.9,109.32 216.9,107.37 217.68,106.59 219.77,106.59 220.43,105.93 227.7,105.93 228.9,104.73 245.02,104.73 246.24,103.51 247.53,103.51 254.98,96.07 254.98,92.3 256.54,90.74 256.54,88.59 257.69,87.44 257.69,84.94 257.28,84.52 255.55,84.52 254.77,83.74 254.77,82.89 254.51,82.63 254.51,81.83 253.57,80.89 252.35,80.89 251.54,80.07 251.54,78.62 252.26,77.9 255.93,77.9 259.24,74.58 259.24,73.51 260.77,71.99 263.34,71.99 263.93,72.59 263.94,72.59 264.05,72.7 267.09,72.7 268.18,71.61 v2(268.18,68.05)
  BOTTOM w0.102: JDOCK1.140 171,110.57 171.59,111.15 v2(180.68,111.15)
DOCK_PSID: length 130
  TOP w0.102: PU1.1 53.66,97.67 53.58,97.74 53.58,99.06 53.03,99.62 v2(52.63,99.62) 51.21,99.62 v3(51.03,99.44)
  IN1 w0.089: v2(52.63,99.62) 53.34,99.62 53.61,99.35 59.35,99.35 59.75,98.95 79.55,98.95 81.33,100.73 94.03,100.73 94.41,100.73 95.71,99.43 101.85,99.43 105.13,96.15 107.28,96.15 107.44,96 113.94,96 114.72,96.78 118.16,96.78 118.64,97.25 119.4,97.25 119.41,97.27 133.87,97.27 134.84,98.23 136.82,98.23 137.36,97.69 167.09,97.69 v2(168.59,99.19)
  BOTTOM w0.102: JDOCK1.135 170,100.01 169.66,99.67 169.07,99.67 v2(168.59,99.19) ; PD7.3 v2(52.63,99.62) PD7.2
DOCK_PWR_BTN#: length 173.4
  TOP w0.102: RE42.2 CE44.1 271.46,51.16 270.67,51.16 v2(270.22,50.71)
  IN1 w0.089: v2(270.22,50.71) 270.22,50.26 269.79,49.83 265.79,49.83 265.65,49.97 265.65,51.18 265.44,51.39 263.47,51.39 260.7,54.17 257.78,54.17 257.45,54.5 252.98,54.5 v2(252.67,54.18)
  IN2 w0.122: v2(252.67,54.18) 252.67,54.77 253.99,56.09 253.99,57.23 255.83,59.07 255.83,62.92 255.84,62.93 255.84,65.13 256.45,65.74 256.45,69.77 256.19,70.04 256.19,71.01 256.63,71.45 257.39,71.45 258.26,72.32 258.26,75.56 257.45,76.37 257.45,77.6 258.16,78.31 259.56,78.31 261.46,80.21 261.46,81.01 260.67,81.8 260.67,83.04 259.93,83.78 259.73,83.78 259.73,83.78 259.08,83.78 257.75,85.11 257.75,87.14 256.86,88.03 256.72,88.18 256.71,88.18 256.65,88.24 256.65,90.05 253.17,93.53 247.05,93.53 246.23,94.35 243.04,94.35 241.03,92.33 239.53,90.84 239.53,89.79 239.27,89.53 237.84,89.53 237.67,89.7 235.76,89.7 235.74,89.73 235.39,89.73 235.37,89.7 229.48,89.7 229.2,89.98 224.84,89.98 222.84,87.99 221.99,87.99 221.59,87.59 221.59,86.85 221,86.26 221,85.38 220.18,84.57 213.45,84.57 212.78,85.23 211.73,85.23 210.05,86.9 205.76,86.9 204.67,87.99 199.73,87.99 199.36,87.61 198.08,87.61 197.72,87.97 191.35,87.97 190.53,87.97 189.08,89.43 188.26,89.43 183.75,93.94 181.5,93.94 181.44,94.01 181.43,94.01 181.28,94.16 179.95,95.48 177.43,95.48 175.88,97.03 175.49,97.42 175.49,97.43 174.5,98.43 169.53,98.43 169.23,98.73 v2(169.23,99.14)
  BOTTOM w0.102: v2(169.23,99.14) 169.53,99.44 169.76,99.44 169.9,99.59 170.81,99.59 171,99.78 JDOCK1.139
DOCK_PWR_SW#: length 7.2
  TOP w0.102: RE62.2 273.62,52.28 RE42.1 273.19,52.71 272.55,52.71 271.94,53.32 271.94,53.85 CE45.1 271.17,54.63 v3(270.5,54.63) 269.8,54.63 269.15,55.28 UE2.A63
DOCK_SMB_ALERT#: length 358.6
  TOP w0.102: v2(57.24,11.08) 55.33,11.08 PQ2.3 ; UE1.A51 255.36,79.88 255.92,79.33 255.92,79.17 256.26,78.82 260.18,78.82 260.44,79.07 260.44,79.81 v2(260.75,80.12) 260.85,80.12 260.95,80.02 260.95,78.57 v3(262.16,77.35) 262.87,76.64 RPE12.3
  IN2 w0.122: v2(260.75,80.12) 260.86,80.12 261.21,80.46 261.21,80.91 260.42,81.7 260.42,82.94 259.83,83.53 258.98,83.53 257.5,85 257.5,87.04 255.28,89.27 255.28,91.07 253.07,93.28 246.66,93.28 246.54,93.16 242.21,93.16 241.13,92.08 239.78,90.74 239.78,88.94 239.22,88.38 231.74,88.38 231.16,87.8 229.26,87.8 228.81,88.25 224.04,88.25 221.25,85.45 221.25,85.28 220.29,84.32 211.96,84.32 210.65,85.63 206.39,85.63 204.27,87.74 201.57,87.74 200.62,86.79 199.38,86.79 198.8,87.36 197.97,87.36 197.61,87.73 191.46,87.73 191.46,87.72 190.41,87.72 188.97,89.17 188.17,89.17 183.64,93.69 181.4,93.69 181.33,93.76 181.32,93.76 181.03,94.05 179.85,95.23 177.32,95.23 175.63,96.93 175.24,97.32 175.24,97.33 174.39,98.18 168.89,98.18 168.08,98.99 168.08,102.41 166.42,104.08 165.86,104.08 v2(165.85,104.09) 165.28,104.66 164.64,104.66 164.39,104.9 162.02,104.9 161.84,105.08 161.84,105.62 160.92,106.54 158.43,106.54 157.92,107.05 157.92,107.05 157.26,107.71 156.44,107.71 151.58,107.71 151.43,107.56 150.46,106.6 146.07,106.6 145.16,105.68 145.16,105.5 145.16,105.5 145.16,103.79 145.16,103.37 144.68,102.9 144.68,102.9 143.86,102.07 143.86,98.67 140.01,94.82 132.19,94.82 129.6,92.23 128.06,92.23 127.19,91.36 125.79,91.36 125.75,91.33 125.61,91.18 121.63,91.18 120.02,89.57 117.62,89.57 116.83,90.36 107.31,90.36 106.38,91.3 105.77,91.7 105.09,91.99 104.56,92.09 104.37,92.13 102.96,92.13 102.96,92.13 102.34,92.13 99.76,89.55 99.76,88.68 98.88,87.8 97.06,87.8 97.01,87.75 96.19,87.75 95.46,87.01 93.14,87.01 92.71,86.59 82.06,86.59 79.89,88.76 78.29,88.76 78.09,88.56 78.09,87.65 76.6,86.16 76.6,84.65 76.29,84.34 76.29,82.57 77.13,81.73 77.13,78.56 78.1,77.58 78.1,74.31 75.65,71.86 70.63,71.86 69.27,70.5 69.27,67.74 70.83,66.18 70.83,53.29 71.03,53.09 71.03,52.38 71.86,51.55 72.5,51.55 72.69,51.36 73.85,51.36 74.31,50.91 74.31,45.95 73.49,45.14 73.49,41.16 75.28,39.38 75.28,29.74 78.09,26.93 81.75,26.93 v2(82.46,26.22)
  IN4 w0.089: v2(82.46,26.22) 81.65,25.4 81.65,23.73 76.06,18.14 65.16,18.14 59,11.97 58.13,11.97 v2(57.24,11.08)
  BOTTOM w0.102: JDOCK1.133 169.5,102.17 167.91,103.76 166.18,103.76 v2(165.85,104.09)
DOCK_SMB_CLK: length 178.1
  TOP w0.102: v2(269.86,58.94) 269.86,58.93 270,58.79 UE2.B4 ; v2(257.8,51.31) 257.68,51.31 257.24,50.87 257.24,50.39 257.62,50.01 RPE3.4
  IN2 w0.122: v2(252.31,56.62) 252.31,56.66 252.34,56.69 252.34,56.75 252.48,56.9 252.48,57.56 252.85,57.92 252.85,59.63 253.92,60.7 253.92,65.91 254.5,66.49 254.5,68.32 253.68,69.15 253.68,72.07 254.65,73.05 254.65,76.41 254.81,76.56 254.81,77.59 253.71,78.69 253.71,79.11 253.71,81.73 253.71,86.3 252.56,87.45 252.56,89.11 252.26,89.41 252.06,89.61 250.76,89.61 250.53,89.84 244.44,89.84 243.45,90.83 242.58,90.83 241.69,89.95 241.69,88 241.64,87.95 241.62,87.95 241.38,87.7 241.38,87.69 239.2,85.51 238.7,85.51 238.33,85.14 232.12,85.14 231.51,85.76 228.6,85.76 228.02,86.34 224.83,86.34 223.99,85.5 223.99,83.26 222.6,81.86 209.44,81.86 208.68,82.62 202.62,82.62 202.2,82.62 198.21,86.61 197.66,86.61 197.35,86.93 189.79,86.93 188.57,88.15 187.64,88.15 187.42,88.36 186,89.79 186,89.79 185.76,90.03 183.56,92.23 182.16,92.23 181.44,92.94 181.09,92.94 181.08,92.95 181.07,92.95 181.01,93.01 179.54,94.48 177.01,94.48 174.88,96.61 174.49,97.01 174.49,97.02 174.08,97.43 168.4,97.43 167.27,98.56 167.27,101.46 v2(166.64,102.09)
  IN4 w0.089: v2(269.86,58.94) 270.28,58.53 270.47,58.53 270.97,58.02 270.97,55.27 270.84,55.13 270.84,50.49 269.91,49.56 264.18,49.56 263.38,50.36 263.38,51.06 262.89,51.55 261.79,51.55 261.02,50.78 258.56,50.78 258.02,51.31 v2(257.8,51.31)
  BOTTOM w0.102: v2(252.31,56.62) 252.31,56.69 252.72,57.1 253.12,57.1 256.23,54 256.23,52.29 257.33,51.18 257.77,51.18 257.8,51.21 v2(257.8,51.31) ; JDOCK1.127 168,101.75 167.66,102.09 v2(166.64,102.09)
DOCK_SMB_DAT: length 178.1
  TOP w0.102: v2(257.77,50.7) 258.12,50.36 RPE3.3 ; UE2.A3 272.03,58.54 272.07,58.5 v2(272.07,58.44)
  IN2 w0.122: v2(252.92,56.62) 252.99,56.69 252.99,57.35 253.35,57.71 253.35,59.42 254.42,60.49 254.42,65.7 255,66.28 255,68.53 254.18,69.36 254.18,71.86 255.15,72.84 255.15,76.2 255.31,76.36 255.31,77.8 254.6,78.51 254.21,78.9 254.21,81.52 254.21,81.53 254.21,86.51 253.06,87.66 253.06,89.32 252.47,89.91 252.27,90.11 250.96,90.11 250.74,90.34 244.65,90.34 243.66,91.33 242.37,91.33 241.19,90.15 241.19,88.23 240.87,87.91 240.87,87.9 238.99,86.01 238.49,86.01 238.13,85.65 232.33,85.65 231.72,86.26 228.81,86.26 228.23,86.84 224.62,86.84 223.49,85.71 223.49,83.47 222.39,82.37 209.65,82.37 208.89,83.13 202.41,83.13 198.42,87.12 197.87,87.12 197.55,87.43 190,87.43 188.78,88.66 187.84,88.66 186.5,90 185.97,90.53 185.96,90.53 183.77,92.73 182.36,92.73 181.65,93.45 181.3,93.45 181.29,93.45 181.28,93.45 181.22,93.51 181.22,93.51 180.78,93.95 179.75,94.98 177.22,94.98 175.38,96.82 175.38,96.82 174.99,97.21 174.99,97.23 174.29,97.93 168.61,97.93 167.77,98.76 167.77,101.67 166.74,102.7 v2(166.59,102.7)
  IN4 w0.089: v2(257.77,50.7) 258.18,50.3 261.2,50.3 261.99,51.08 262.7,51.08 262.91,50.87 262.91,50.16 263.99,49.09 270.1,49.09 271.31,50.29 271.31,54.94 271.44,55.07 271.44,57.87 272.07,58.5 v2(272.07,58.44)
  BOTTOM w0.102: v2(252.92,56.62) 255.74,53.8 255.74,52.09 257.13,50.7 v2(257.77,50.7) ; v2(166.59,102.7) 166.71,102.57 167.86,102.57 168.48,101.95 168.48,101.72 168.5,101.7 JDOCK1.129
DOCKED: length 126.3
  TOP w0.102: UL4.13 271.63,76.72 271.13,76.23 271.13,74.46 271.7,73.89 v2(271.7,73.85) ; v2(247.76,75.7) 248.39,76.33 UE1.A38 ; UV16.30 231.22,91.63 v2(231.12,91.72)
  IN1 w0.089: v2(247.76,75.7) 248.83,76.76 248.83,85.25 249.18,85.59 249.18,86.79 248.33,87.63 247.98,87.63 246.88,88.74 246.88,89.07 247.7,89.89 248.16,89.89 248.87,90.61 v2(248.87,90.93)
  IN3 w0.122: v2(201.2,92.73) 201.95,92.73 208.54,99.32 208.54,100.47 209.64,101.58 213.86,101.58 214.73,102.45 227.12,102.45 228.99,100.58 231.43,100.58 v2(231.85,100.16) 232.02,99.99 243.13,99.99 243.79,99.33 244.85,99.33 245.15,99.03 247.93,96.25 247.93,96.04 247.85,95.96 247.85,91.45 248.11,91.19 248.49,91.19 248.75,90.93 v2(248.87,90.93)
  BOTTOM w0.102: v2(231.85,100.16) 231.85,100.13 230.54,98.82 230.54,97.86 229.94,97.25 229.94,96.08 230.51,95.51 230.51,92.77 v3(230.82,92.46) 231.12,92.16 v2(231.12,91.72) ; v2(201.2,92.73) 202.02,92.73 QV11.2 ; v2(247.76,75.7) 249.64,73.82 253.82,73.82 255.08,75.07 255.08,75.88 255.21,76.01 255.35,76.14 255.58,76.38 256.06,76.38 257.53,77.85 259.75,77.85 260.01,77.6 262.58,77.6 263.99,76.19 263.99,75.74 264.95,74.78 270.77,74.78 v2(271.7,73.85)
EC5048_TX: length 9.8
  TOP w0.102: RE305.1 252.31,89.78 v2(252.8,90.26) ; v2(252.31,85.7) 253.14,86.54 UE1.B2
  IN1 w0.089: v2(252.8,90.26) 253.15,89.91 253.15,86.66 252.31,85.81 v2(252.31,85.7)
  BOTTOM w0.102: v3(252.78,87.55) 252.78,86.32 252.31,85.85 v2(252.31,85.7)
EC_32KHZ_ECE5048: length 48.3
  TOP w0.102: UE2.B2 270.14,57.79 270,57.93 269.66,57.93 269.26,58.32 269.26,58.43 v2(269.26,58.43) ; v2(245.91,75.27) 245.14,75.27 244.72,75.68 v3(244.72,76.09) 244.72,76.68 245.64,77.61 UE1.B35
  IN1 w0.089: v2(269.26,58.43) 268.74,58.96 268.74,59.09 268.12,59.71 263.71,59.71 262.97,58.97 262.97,58.69 262.65,58.37 262.55,58.37 262.2,58.02 258.4,58.02 258.22,58.2 254.2,58.2 254.19,58.19 254.05,58.19 254.01,58.15 253.27,58.15 252.81,58.61 v2(247.36,58.61)
  IN2 w0.122: v2(247.36,58.61) 247.13,58.84 247.13,62.63 247.01,62.75 247.01,64.01 247.18,64.18 247.18,68 248.35,69.17 248.35,73.82 246.9,75.27 v2(245.91,75.27)
EC_FPM_EN: length 73.1
  TOP w0.102: JUSH1.22 270.46,7.34 271.1,6.71 273.56,6.71 274.75,7.89 v3(275.68,7.89) 275.68,8.98 276.64,9.94 276.64,13.54 v2(276.72,13.62) ; v2(267.23,58.04) 267.23,57.98 266.9,57.65 UE2.B62
  IN3 w0.122: v2(267.23,58.04) 267.23,56.89 270.81,53.31 270.81,50.64 269.55,49.38 266.48,49.38 265.94,48.84 265.94,47.83 267.56,46.21 267.56,44.09 266.73,43.25 266.73,41.53 266.37,41.18 266.37,39.51 266.37,39.51 266.37,34.61 265.69,33.93 265.69,30.1 266.37,29.42 266.37,26.98 266.78,26.57 266.78,26.31 266.78,24.53 268.42,22.88 268.42,17.81 272.06,14.18 274.04,14.18 274.6,13.62 v2(276.72,13.62)
EDP_AUXN: length 97.2
  IN4 w0.089: v2(81.79,82.11) 81.64,82.11 81.25,82.49 81.25,83.52 80.58,84.19 80.58,93.09 82.15,94.66 88.22,94.66 88.94,93.94 94.22,93.94 94.91,94.64 101.42,94.64 102.73,93.32 105.68,93.32 105.87,93.13 106.25,93.13 106.56,92.83 122.3,92.83 122.92,93.45 127.78,93.45 132.07,89.15 138.9,89.15 140.27,87.79 140.27,81.03 140.68,80.62 140.68,79.66 142.07,78.26 142.07,77.58 142.73,76.92 144.22,76.92 144.53,76.61 146.34,76.61 147.7,75.25 147.7,74.58 147.52,74.4 147.25,74.4 147.25,74.4 147.11,74.53 147.11,74.71 v2(147.23,74.83)
  BOTTOM w0.076: v2(147.23,74.83) 147.23,74.82 147.62,74.44 UC1.E45
  BOTTOM w0.094: v2(81.79,82.11) 81.65,82.11 81.53,82.23 81.53,82.71 CV1.1
EDP_AUXN_C: length 2.9
  BOTTOM w0.094: CV1.2 81.52,84.33 81.52,84.59 81.1,85.01 81.1,85.78 81.25,85.93 JEDP1.33
EDP_AUXP: length 97.2
  IN4 w0.089: v2(81.07,82.11) 81.07,83.44 80.4,84.11 80.4,93.16 82.07,94.84 88.3,94.84 89.01,94.13 94.15,94.13 94.84,94.82 101.49,94.82 102.8,93.51 105.75,93.51 105.95,93.31 106.33,93.31 106.63,93.01 122.23,93.01 122.85,93.63 127.85,93.63 132.15,89.34 138.98,89.34 140.45,87.87 140.45,81.11 140.86,80.7 140.86,79.73 142.25,78.34 142.25,77.65 142.8,77.1 144.29,77.1 144.61,76.79 146.42,76.79 147.88,75.32 147.88,74.5 v2(147.4,74.02)
  BOTTOM w0.076: v2(147.4,74.02) 147.5,74.12 147.71,74.12 147.83,74 UC1.F45
  BOTTOM w0.094: CV2.1 81.33,82.71 81.33,82.2 81.24,82.11 v2(81.07,82.11)
EDP_AUXP_C: length 2.9
  BOTTOM w0.094: JEDP1.34 80.75,85.93 80.9,85.78 80.9,84.93 81.33,84.51 81.33,84.32 CV2.2
EDP_BIA_PWM: length 137.8
  IN1 w0.089: v2(167.7,68.76) 167.7,68.69 167.2,68.19 166.95,68.19 166.7,67.94 166.35,67.94 165.78,67.37 160.39,67.37 160.23,67.21 159.85,67.21 159.47,67.59 159.47,67.85 159.27,68.05 155.94,68.05 155.49,67.6 149.89,67.6 149.39,68.1 149.39,70.34 147.84,71.89 147.84,72.06 147.46,72.44 144.69,72.44 144.07,73.06 143.6,73.06 143.34,73.31 143.34,74.99 142.85,75.49 142.85,76.54 140.42,78.97 139.93,78.97 139.31,79.6 139.31,79.66 139.31,80.11 138.88,80.53 137.4,80.53 136.97,80.1 135.28,80.1 135.06,79.89 134.15,79.89 133.78,80.26 133.78,80.59 133.56,80.8 133.19,80.8 130.69,83.31 130.69,84.5 129.1,86.08 126.88,86.08 124.63,88.33 121.88,88.33 121.39,88.83 120.21,88.83 119.32,89.72 118.13,89.72 117.22,90.63 107.22,90.63 105.9,91.95 105.6,92.24 101.32,92.24 99.33,90.25 94.09,90.25 93.58,90.76 79.63,90.76 78.57,89.71 74.19,89.71 69.5,85.02 v2(69.3,85.02)
  BOTTOM w0.076: v2(167.7,68.76) 167.37,69.09 UC1.R11
  BOTTOM w0.102: v2(69.3,85.02) 69.76,85.02 71.18,83.6 v3(73.7,83.6) 74.89,83.6 77.23,81.26 83.55,81.26 84.04,81.75 85.64,81.75 DV1.3
EDP_COMP: length 2.8
  TOP w0.203: v3(143.7,75.3) 143.22,74.82 143.22,74.52 143.65,74.09 143.65,74.08
  TOP w0.381: v2(143.8,74.08) 143.65,74.08 143.27,73.7 143.27,73.68
  BOTTOM w0.254: UC1.E52 144.15,74.44 v2(143.8,74.08)
EDP_HPD: length 106.1
  TOP w0.102: RC1.2 167.92,70.31 v2(168.34,70.73)
  IN1 w0.089: v2(168.34,70.73) 168.13,70.73 167.58,70.17 167.58,69.68 167.33,69.44 166.34,69.44 165.77,68.87 160.18,68.87 159.85,69.19 159.85,69.47 158.15,71.17 156.08,71.17 155.76,71.49 155.76,72.38 155.15,72.98 150.76,72.98 150.56,73.18 150.56,74.63 149.67,75.52 148.68,75.52 148.48,75.32 147.76,75.32 147.45,75.63 146.45,75.63 146.14,75.32 145.74,75.32 143.55,77.52 143.55,77.89 143.07,78.36 142.35,78.36 140.91,79.8 140.91,80.68 139.67,81.92 138.91,81.92 138.71,81.72 134.68,81.72 129.46,86.95 127.23,86.95 124.99,89.2 122.56,89.2 120.48,91.28 107.49,91.28 106.17,92.6 105.87,92.89 102.58,92.89 101.36,94.11 95.49,94.11 95.03,93.65 86.42,93.65 v2(85.97,93.2)
  BOTTOM w0.076: UC1.L10 v2(168.34,70.73)
  BOTTOM w0.102: v2(85.97,93.2) 85.97,92.03 84.29,90.35 84.29,88.45 84.75,87.99 JEDP1.26
EDP_TXN0: length 96.6
  IN4 w0.089: v2(146.03,78.41) 146.17,78.41 146.29,78.29 146.29,78.14 146.08,77.93 145.63,77.93 145.43,77.73 144,77.73 142.87,78.86 142.87,79.85 141.19,81.53 141.19,88.01 139.38,89.82 139.25,89.95 134.48,89.95 132.12,92.31 130.36,92.31 128.24,94.44 122.05,94.44 121.2,93.59 106.87,93.59 106.57,93.89 106.19,93.89 105.99,94.08 103.04,94.08 101.73,95.4 94.6,95.4 93.91,94.7 89.25,94.7 88.54,95.42 81.79,95.42 79.68,93.31 79.68,84.45 79.55,84.32 79.55,82.36 v2(79.31,82.12)
  BOTTOM w0.076: v2(146.03,78.41) 146.16,78.28 146.16,77.88 146.7,77.34 146.7,76.69 146.67,76.66 146.67,76.32 146.4,76.05 UC1.C47
  BOTTOM w0.094: v2(79.31,82.12) 79.56,82.38 79.56,82.78 79.29,83.06 CV4.1
EDP_TXN0_C: length 2.8
  BOTTOM w0.094: JEDP1.36 79.75,85.66 79.9,85.5 79.9,85.25 79.55,84.89 79.55,84.32 CV4.2
EDP_TXN1: length 101.6
  IN4 w0.089: v2(146.26,80.06) 146.31,80.06 146.49,79.89 146.49,79.73 146.4,79.64 146.3,79.64 145,78.35 144.2,78.35 143.5,79.05 143.5,80.04 141.77,81.77 141.77,88.27 139.8,90.24 139.46,90.59 136.48,90.59 132.02,95.05 121.63,95.05 120.74,94.16 107.11,94.16 106.81,94.46 106.43,94.46 106.23,94.66 103.28,94.66 101.97,95.97 94.36,95.97 93.67,95.28 89.49,95.28 88.78,96 81.47,96 79.1,93.62 79.1,84.69 77.81,83.39 77.81,82.3 v2(77.61,82.1)
  BOTTOM w0.076: UC1.D46 147.18,75.75 147.18,75.92 147.42,76.17 147.66,76.17 147.74,76.24 147.8,76.42 147.8,76.61 147.76,76.7 147.76,76.95 147.8,77.05 147.8,77.4 147.36,77.83 147.36,78.98 147.22,79.12 147.19,79.12 147.05,79.26 147.04,79.26 147,79.3 147,79.31
  BOTTOM w0.094: v2(77.61,82.1) 77.78,82.27 77.78,82.81 77.52,83.06 CV6.1 ; 147,79.31 146.88,79.44 146.66,79.44 146.45,79.64 146.45,79.88 v2(146.26,80.06)
EDP_TXN1_C: length 3.3
  BOTTOM w0.094: JEDP1.38 78.75,85.99 78.9,85.84 78.9,85.54 78.71,85.35 78.66,85.35 78.25,84.93 78.25,84.89 77.77,84.41 77.77,84.12 77.62,83.98 CV6.2
EDP_TXP0: length 96.6
  IN4 w0.089: v2(146.67,78.44) 146.47,78.24 146.47,78.06 146.16,77.75 145.71,77.75 145.51,77.55 143.92,77.55 142.68,78.79 142.68,79.78 141.01,81.45 141.01,87.94 139.18,89.77 134.4,89.77 132.04,92.13 130.29,92.13 128.16,94.26 122.13,94.26 121.27,93.4 106.79,93.4 106.49,93.71 106.11,93.71 105.91,93.9 102.97,93.9 101.66,95.21 94.68,95.21 93.98,94.52 89.18,94.52 88.46,95.24 81.86,95.24 79.86,93.23 79.86,84.37 79.73,84.24 79.73,82.29 79.89,82.12 v2(79.97,82.12)
  BOTTOM w0.076: UC1.C46 147.07,76.18 147.17,76.28 147.17,76.4 147.08,76.49 146.93,76.49 146.86,76.56 146.86,77.41 146.33,77.94 146.33,78.17 146.6,78.44 v2(146.67,78.44)
  BOTTOM w0.094: v2(79.97,82.12) 79.76,82.34 79.76,82.8 80.02,83.06 CV3.1
EDP_TXP0_C: length 2.8
  BOTTOM w0.094: JEDP1.35 80.25,85.66 80.1,85.5 80.1,85.17 79.74,84.81 79.74,84.33 CV3.2
EDP_TXP1: length 101.6
  IN4 w0.089: v2(78.22,82.1) 77.99,82.32 77.99,83.32 79.28,84.61 79.28,93.55 81.55,95.81 88.7,95.81 89.42,95.1 93.74,95.1 94.44,95.79 101.89,95.79 103.21,94.48 106.15,94.48 106.35,94.28 106.73,94.28 107.03,93.98 120.81,93.98 121.7,94.87 131.94,94.87 136.4,90.4 139.38,90.4 141.59,88.2 141.59,81.69 143.31,79.96 143.31,78.97 144.12,78.16 145.08,78.16 146.37,79.46 146.47,79.46 146.67,79.65 146.67,79.91 v2(146.85,80.09)
  BOTTOM w0.076: UC1.C45 147.53,75.66 147.6,75.59 147.77,75.59 147.84,75.66 147.84,75.97 147.88,76.12 147.9,76.2 147.95,76.35 147.96,76.4 147.96,76.64 147.93,76.73 147.93,76.92 147.96,77.02 147.96,77.47 147.52,77.9 147.52,79.05 147.27,79.31
  BOTTOM w0.094: CV5.1 78.27,83.06 77.97,82.76 77.97,82.34 v2(78.22,82.1) ; v2(146.85,80.09) 146.65,79.89 146.65,79.72 146.74,79.63 146.96,79.63 147.2,79.39 147.2,79.38 147.27,79.31
EDP_TXP1_C: length 3.3
  BOTTOM w0.094: CV5.2 78.09,83.98 77.96,84.11 77.96,84.33 v4(78.61,84.98) 79.09,85.46 79.09,85.86 79.25,86.01 JEDP1.37
EDRAM_OPIO_RCOMP: length 6.1
  TOP w0.381: v2(135.11,72.82) 135.92,72 137.28,72 v3(137.71,71.57) 138.55,70.73 138.55,70.53 139.09,69.98 RC90.1
  BOTTOM w0.254: UC1.H66 135.38,72.55 v2(135.11,72.82)
EMMC_RCOMP: length 11.8
  BOTTOM w0.203: 174.33,58.64 173.8,58.64 173.69,58.53 173.16,58.53 UC1.AT1
  BOTTOM w0.381: RC4.1 182.68,57.97 181.83,57.12 181.19,57.12 180.45,56.37 v3(180.08,56.37) 179.28,57.17 178.23,57.17 177.64,57.75 176.41,57.75 175.52,58.64 174.33,58.64
EN_1.0V_PRIM_COREP: length 5.3
  TOP w0.102: v2(203.85,71.67) 203.85,72.3 PR406.2 203.24,72.91 PR407.1 PC411.1 203.24,70.32 v3(203.09,70.17)
  BOTTOM w0.102: PU402.13 203.55,71.37 v2(203.85,71.67)
EN_1.8VALW: length 5.4
  BOTTOM w0.102: PU501.1 209.17,108.86 PC505.1 208.06,109.06 PR505.1 206.96,109.07 v3(206.8,108.91) 206.8,108.28 206.9,108.18 PR504.2
EN_1VS_VCCIO: length 4.4
  TOP w0.102: 204.25,51.36 v3(203.33,51.36) ; 204.25,51.36 PR403.1 PC402.1 205.21,51.36 PR402.2 ; 204.25,51.36 v2(204.25,50.63)
  BOTTOM w0.102: PU401.13 204.28,50.66 v2(204.25,50.63)
EN_+1VALWP: length 3.8
  TOP w0.102: PR312.1 221.71,48.98 PR302.1 222.62,50.32 v2(222.74,50.45)
  BOTTOM w0.102: v2(222.74,50.45) 223.34,51.04 PU301.1
EN_DK_PWRBAR: length 5.8
  TOP w0.102: PR901.1 31.36,84.74 30.97,84.74 v2(30.95,84.71) 30.57,84.33 30.57,83.21 30.14,82.79 PU901.17
  BOTTOM w0.102: PR934.1 29.78,83.54 v2(30.95,84.71)
EN_DOCK_PWR_BAR: length 281.8
  TOP w0.102: v2(33.65,87.88) 33.68,87.85 v3(33.68,86.22) 33.68,85.49 PR901.2 ; UE1.B37 246.64,78.46 v2(246.87,78.7)
  IN1 w0.089: v2(246.87,78.7) 247.16,78.7 247.29,78.82 247.29,80.26 247.12,80.42 247.12,81.3 247.01,81.42 247.01,87.93 246.45,88.49 246.45,90.71 247.76,92.02 248.28,92.02 v2(248.28,92.02)
  IN2 w0.122: v2(250.56,99.67) 247.56,99.67 246.65,100.58 246.65,101.78 246.16,102.26 246.16,102.85 244.5,104.51 232.41,104.51 230.69,102.79 208.06,102.79 201.07,95.8 193.42,95.8 187.88,101.34 185.32,101.34 181.56,105.09 181.56,109.28 179.3,111.54 152.68,111.54 151.89,111.54 151.89,111.54 135.9,111.54 134.59,110.23 133.95,110.23 132.81,111.38 128.51,111.38 125.7,108.57 125.7,101.31 123.61,99.22 123.61,97.44 120.56,94.39 112.91,94.39 112.46,94.84 107.2,94.84 106.97,94.93 106.86,94.98 106.77,95.01 106.48,95.13 105.6,95.57 104.38,95.57 104.16,95.79 84.3,95.79 81.79,98.3 60.04,98.3 59.76,98.59 56.87,98.59 55.29,97 55.29,96.46 45.95,87.12 39.73,87.12 38.29,88.56 34.32,88.56 33.64,87.89 33.64,87.88 v2(33.65,87.88)
  BOTTOM w0.102: v2(250.56,99.67) 250.56,98.81 249.57,97.82 249.57,93.61 248.28,92.32 v2(248.28,92.02)
EN_I2S_NB_CODEC#: length 88.3
  TOP w0.102: UA1.1 275.62,35.68 275.4,35.9 275.4,36.35 275.63,36.58 v2(276.41,36.58) ; UE1.B36 246.14,78.57 v2(246.27,78.7)
  IN1 w0.089: v2(276.41,36.58) 276.18,36.58 274.41,38.34 272.2,38.34 271.94,38.61 271.94,41.09 272.71,41.86 273.15,41.86 273.22,41.93 281.37,41.93 282.03,42.59 282.51,42.59 v2(282.54,42.61)
  IN3 w0.122: v2(282.54,42.61) 281.94,43.22 281.94,49.88 279.54,52.27 279.54,55.81 280.32,56.58 280.32,58.95 278.48,60.79 278.48,63.54 277.96,64.06 274.88,67.14 274.67,67.14 271.89,67.14 271.28,66.53 267.83,66.53 267.12,67.24 267.12,69.56 267.42,69.87 267.42,70.79 266.99,71.22 258.56,71.22 258.53,71.25 257.29,71.25 257.02,71.52 252.72,71.52 248.47,75.77 248.47,76.96 247.16,78.28 246.69,78.28 v2(246.27,78.7)
  BOTTOM w0.102: v3(245.68,78.15) 245.72,78.15 v2(246.27,78.7)
EN_INVPWR: length 226.7
  TOP w0.102: RE55.2 263.74,70.57 v2(263.74,70.49) ; QV2.2 v3(91.54,83.96) 91.54,84.52 v2(90.99,85.07) ; UE2.A25 265.65,67.39 265.62,67.42 v2(265.62,67.44)
  IN2 w0.122: v2(243.32,69.64) 242.56,70.4 242.56,71.96 240.78,73.74 240.78,75.4 239.74,76.43 237.68,76.43 236.65,77.47 234.9,77.47 233.03,75.6 229.47,75.6 228.42,76.65 223.6,76.65 223,77.25 222.75,77.5 204.19,77.5 203.81,77.12 200.96,77.12 200.89,77.19 200.74,77.35 189.7,77.35 187.32,79.73 187.32,80.96 185.97,82.31 183.87,84.41 183.29,84.41 183,84.7 180.55,87.15 178.02,87.15 176.39,88.78 172.98,88.78 172.25,89.52 169.99,89.52 169.15,90.36 167.94,90.36 161.8,96.5 161.02,96.5 158.61,98.91 158.61,99.47 158.19,99.89 158.19,101.54 158.48,101.84 158.48,103.2 157.9,103.78 157.9,106.01 157.61,106.3 156.95,106.96 156.74,106.96 154.14,106.96 151.58,104.41 151.58,104.28 150.94,103.64 147.93,103.64 147.78,103.48 147.73,103.48 145.42,101.17 145.42,99.17 144.6,98.36 140.46,94.22 140.32,94.07 136.77,94.07 134.69,91.99 130.43,91.99 129.05,90.62 127.26,90.62 126.42,89.78 121.96,89.78 120.98,88.8 117.33,88.8 116.59,89.55 107.07,89.55 105.9,90.72 105.41,91.04 104.87,91.27 104.29,91.38 102.65,91.38 100.5,89.24 100.5,88.37 99.19,87.05 98.6,87.05 97.37,87.05 97.32,87 96.6,87 95.82,86.22 95.62,86.22 95.41,86.22 95.41,86.23 93.4,86.23 93.02,85.84 91.77,85.84 v2(90.99,85.07)
  BOTTOM w0.102: v2(243.32,69.64) 243.74,69.22 244.26,69.22 244.97,69.93 247.18,69.93 249.19,71.94 254.6,71.94 256.74,74.07 262.35,74.07 263.13,73.29 263.13,72.74 263.76,72.11 265.72,72.11 265.98,71.86 265.98,71.5 265.7,71.22 265.67,71.2 264.45,71.2 v2(263.74,70.49) 263.74,70.08 265.06,68.76 265.06,68 v2(265.62,67.44)
EN_LCDPWR: length 6.7
  BOTTOM w0.102: UV24.4 97.72,77.54 98.82,77.54 99,77.71 99,78.42 98.44,78.98 v2(98.44,79.14) 98.44,79.58 DV3.1 99.15,80.29 99.15,81.06 RV3.2
ENLDO_3V5V: length 18.7
  IN1 w0.122: v2(225.06,60.1) 225.64,60.1 226.78,61.24 227.21,61.24 227.75,61.77 227.75,64.35 226.94,65.15 225.47,65.15 224.59,66.03 224.59,68.16 v2(223.91,68.83)
  BOTTOM w0.102: PU100.11 222.08,69.83 223.32,68.59 223.32,68.34 PR103.1 PR102.1 224.37,68.38 v2(223.91,68.83) ; v2(225.06,60.1) 224.95,60.21 224.33,60.21 224.12,60 223.91,60 223.81,60.1 PU102.11
ENVDD_PCH: length 229.3
  TOP w0.102: UE2.A7 272.26,60.54 v2(272.68,60.13)
  IN1 w0.076: 172.86,71.84 171.16,70.14 168.19,70.14 167.93,69.88 167.93,69.54 167.48,69.09 166.85,69.09 v2(166.51,68.75)
  IN1 w0.089: v2(166.51,68.75) 166.26,68.49 159.78,68.49 159.59,68.68 159.03,68.68 158.63,69.08 158.63,70.06 157.87,70.82 155.86,70.82 155.33,71.35 155.33,72.17 155.05,72.44 149.65,72.44 149.09,73.01 145.42,73.01 145.07,73.36 145.07,74.93 140.49,79.51 140.01,79.51 139.74,79.78 139.74,80.3 138.96,81.08 133.98,81.08 133.76,81.29 133.41,81.29 133.31,81.29 131.2,83.4 131.2,84.59 129.28,86.52 127.06,86.52 124.81,88.76 122.85,88.76 122.2,88.76 121.68,89.28 120.36,89.28 119.5,90.15 118.6,90.15 v2(118.2,90.55) ; 172.86,71.84 173.98,72.96 179.96,72.96 180.19,73.2 181.85,73.2 182.13,72.92 182.13,72.28 182.77,71.63 184.03,71.63 184.88,72.48 184.88,73.04 189.65,77.82 191.77,77.82 192.37,78.41 197.95,78.41 198.67,79.13 221.92,79.13 222.66,78.39 228.08,78.39 232,74.47 232,74.27 233.46,72.81 233.46,68.93 233.64,68.74 233.64,63.07 234.66,62.06 238.64,62.06 238.9,62.32 243.34,62.32 244.45,63.43 246.9,63.43 247.35,62.98 248.75,62.98 249.43,63.65 250.15,63.65 252.64,61.16 253.17,61.16 253.95,60.39 257.76,60.39 258.61,59.54 260.32,59.54 261.38,60.6 263.37,60.6 263.41,60.63 268.12,60.63 268.68,61.19 271.46,61.19 271.76,61.49 272.85,61.49 273.08,61.26 273.08,60.92 272.68,60.52 v2(272.68,60.13)
  IN2 w0.122: v2(97.85,85.55) 97.88,85.58 101.43,85.58 101.94,85.07 102.09,84.92 105.38,84.92 105.77,85.31 105.92,85.46 106.03,85.46 107.22,86.65 114.32,86.65 v2(114.81,86.15)
  IN3 w0.122: v2(114.81,86.15) 114.8,86.15 114.19,86.77 114.19,88.63 115.23,89.67 116.75,89.67 117.64,90.55 v2(118.2,90.55)
  BOTTOM w0.076: UC1.U13 166.07,68.31 v2(166.51,68.75)
  BOTTOM w0.102: v2(97.85,85.55) 98.66,85.55 99.08,85.13 99.08,83.91 98.85,83.68 98.11,83.68 97.33,82.91 97.33,79.17 DV3.3
EOPIO_RCOMP: length 4.9
  TOP w0.381: RC91.1 138.59,71.48 138.59,72.11 138.12,72.58 136.37,72.58 v2(136.16,72.8)
  BOTTOM w0.254: v2(136.16,72.8) 136.29,72.8 136.54,72.55 UC1.H65
ERC1: length 3
  TOP w0.102: PU901.3 25.68,77.27 v2(25.42,77.02)
  BOTTOM w0.102: PC908.1 25.87,76.1 25.42,76.55 v2(25.42,77.02)
ERC2: length 2.4
  TOP w0.254: PU901.13 30.58,80.79 v2(30.69,80.67)
  BOTTOM w0.203: v2(30.69,80.67) 29.96,80.67 PC901.1
ERC3: length 2.9
  TOP w0.102: v3(30.98,79.59) 30.98,79.76 v2(30.67,80.06)
  TOP w0.254: v2(30.67,80.06) 30.49,80.06 30.27,80.29 PU901.12
  BOTTOM w0.203: PC907.1 30.57,79.96 v2(30.67,80.06)
FAN1_PWM: length 279.8
  TOP w0.102: v2(266.41,69.3) 266.36,69.3 RE48.2 ; v3(64.9,71.5) 66.35,72.95 v2(66.36,72.95)
  TOP w0.127: RE48.2 266.15,68.33 UE2.A24
  IN1 w0.127: v2(66.36,72.95) 66.94,72.37 66.94,69.12 70.1,65.96 70.1,60.76 69.35,60.02 69.35,51.45 70.06,50.74 70.06,46.46 74.27,42.25 74.27,40.92 80.79,34.4 87.34,34.4 v2(87.97,33.76)
  IN2 w0.127: v2(87.97,33.76) 88.66,34.45 94.39,34.45 94.69,34.14 101.63,34.14 104.98,37.49 188.18,37.49 188.74,37.49 193.49,32.74 203.79,32.74 207.23,29.3 219.42,29.3 220.58,30.46 221.45,30.46 221.91,30.92 222.93,30.92 223.48,31.47 223.89,31.47 226.66,28.71 233.69,28.71 234.33,28.07 236.18,28.07 237.2,27.05 241.78,27.05 242.42,27.69 245.32,27.69 246.06,28.43 247.53,28.43 250.18,31.07 250.18,32.55 252.08,34.46 253.35,34.46 254.68,35.78 254.68,38.41 256.9,40.63 256.9,45.15 257.78,46.03 257.78,49.67 257.06,50.39 257.06,52.49 259.41,54.84 259.44,54.84 261.54,56.94 261.54,57.68 261.55,57.69 261.55,60.22 261.89,60.56 264.24,60.56 264.97,61.29 264.97,63.54 265.29,63.86 265.29,65.92 266.18,66.81 266.18,69.07 v2(266.41,69.3)
  BOTTOM w0.127: JFAN1.2 66.89,71.59 66.89,72.42 v2(66.36,72.95)
FAN1_TACH: length 288.5
  TOP w0.127: v2(266.48,64.29) 266.91,64.29 267.9,65.28 UE2.B22 ; v2(264.43,70.54) 264.43,71.12 264.32,71.23 RE51.2
  IN1 w0.127: v2(65.67,73) 65.65,72.98 65.65,69.75 69.65,65.75 69.65,60.95 68.91,60.2 68.91,51.36 69.61,50.65 69.61,46.27 73.82,42.06 73.82,40.73 80.82,33.74 v2(87.17,33.74)
  IN2 w0.127: v2(266.48,64.29) 265.87,63.68 265.67,63.68 265.24,63.25 265.24,61.09 264.76,60.61 264.76,57.33 264.15,56.72 261.68,56.72 259.55,54.59 259.51,54.59 257.31,52.39 257.31,50.5 258.04,49.78 258.04,45.9 257.17,45.03 257.17,40.55 254.96,38.33 254.96,35.7 253.43,34.18 252.16,34.18 250.43,32.45 250.43,30.97 247.61,28.15 246.24,28.15 245.53,27.44 242.52,27.44 241.89,26.8 237.1,26.8 236.18,27.72 234.02,27.72 233.45,28.29 226.5,28.29 224.34,30.45 221.8,30.45 221.55,30.2 220.69,30.2 219.53,29.05 206.99,29.05 203.55,32.49 193.04,32.49 188.29,37.24 105.09,37.24 99.61,31.77 87.37,31.77 87.06,32.07 87.06,33.62 v2(87.17,33.74)
  BOTTOM w0.127: v2(266.48,64.29) 267.12,64.93 267.12,66.94 266.06,68 266.06,68.91 v2(264.43,70.54) ; v2(65.67,73) 64.45,73 63.92,72.47 63.92,71.22 65.65,69.5 66.57,69.5 JFAN1.3
FB_1.8VALW: length 6.7
  BOTTOM w0.102: PC503.2 208.43,102.53 207.51,101.61 v1(207.51,100.05)
  BOTTOM w0.254: PC503.2 PR501.2 209.41,103.24 PR506.1 209.17,103.48 PU501.6
FB_+1VALWP: length 3.8
  BOTTOM w0.254: PR306.2 PR308.2 225.27,49.62 PR311.1 v3(224.42,50.55) 224.69,50.81 PU301.4
FB_IA: length 7.8
  TOP w0.203: v3(86.68,64.25) 87.08,64.65 87.08,65.61 86.42,66.27 PU602.17
  TOP w0.254: PR650.1 87.87,62.82 PR648.2 87.24,62.79 v2(87.21,62.82) 86.6,63.42 86.6,64.18 v3(86.68,64.25)
  BOTTOM w0.254: PR645.2 v2(87.21,62.82)
FB_VSA: length 7.5
  TOP w0.203: PR646.1 PR649.1 PR652.1 79.26,71.53 v3(80.12,70.67) 80.24,70.55 80.4,70.55 80.77,70.18 82.03,70.18 82.63,69.58 PU602.25
FCCM_GT: length 17.6
  TOP w0.102: v2(97.65,68.61) v3(97.65,69.21)
  TOP w0.203: v2(86.06,63.64) 85.85,63.85 85.34,63.85 85.32,63.87 PU602.11
  TOP w0.254: v2(97.65,68.61) 97.84,68.61 98.33,68.13 PR671.2
  IN2 w0.254: v2(97.65,68.61) 97.09,68.05 88.76,68.05 87.72,67.01 87.72,65.62 86.6,64.51 86.6,64.05 86.35,63.8 86.16,63.8 86.06,63.69 v2(86.06,63.64)
