# Allegro board LAC621PR10-0924-A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_RUN_VDDIO on IN4 (solid shape): outline of 1293 points within 213.69,85.32 221.31,93.38
+3.3V_RUN_VMM on TOP (solid shape): 225.41,95.15 225.41,92.95 225.15,92.69 223.3,92.69 223.21,92.78 223.21,93.08 223.33,93.2 224.24,93.2 224.24,93.2 224.47,93.2 224.72,93.45 224.72,95.13 224.82,95.23 225.33,95.23
+3.3V_RUN_VMM on TOP (solid shape): 204.93,89.17 204.93,88.81 205.07,88.68 205.07,85.81 206.16,84.71 207.81,84.71 207.99,84.54 207.99,84.15 208.11,84.03 208.32,84.03 208.57,83.77 208.57,83.29 208.83,83.04 209.69,83.04 209.79,83.14 209.79,83.72 209.84,83.77 210.27,83.77 210.4,83.65 210.4,82.48 210.86,82.02 213.02,82.02 213.1,81.94 213.1,81.39 213.04,81.33 209.56,81.33 208.36,82.54 208.36,82.59 206.79,84.15 205.45,84.15 204.95,84.66 204.94,84.67 204.85,84.8 204.71,84.89 204.7,84.9 204.1,85.5 204.1,88.55 203.54,89.11 203.54,89.89 203.67,90.02 204.08,90.02
+3.3V_RUN_VMM on BOTTOM (solid shape): outline of 515 points within 205.32,87.53 223.99,97.06
+3.3V_TP on TOP (solid shape): 222.48,36.7 222.48,35.88 223.73,34.62 224.29,34.62 224.4,34.52 224.4,33.57 224.89,33.57 224.91,33.57 224.93,33.56 224.95,33.53 224.95,33.43 224.91,33.39 224.41,33.39 224.4,33.38 224.4,33.08 224.38,33.04 224.34,33.02 223.1,33.02 222.94,32.86 221.87,32.86 221.29,32.28 220.86,32.28 220.79,32.35 220.79,32.85 220.82,32.88 221.43,32.88 221.83,33.28 221.83,33.68 221.83,33.7 221.84,33.72 221.87,33.74 221.9,33.76 221.94,33.74 222.54,33.82 222.32,34.38 222.28,34.42 220.76,34.42 220.51,34.17 220.51,34.04 220.49,34 220.46,33.99 220.15,33.99 219.92,34.21 219.92,34.62 219.94,34.62 219.94,34.82 219.99,35.02 219.94,35.23 219.94,35.43 219.92,35.43 219.92,35.55 219.94,35.55 219.94,36.03 220.18,36.27 220.59,36.27 221.03,35.84 221.03,35.81 221.06,35.81 221.09,35.78 221.65,35.78 221.74,35.86 221.74,36.81 221.86,36.94 222.24,36.94
+3.3V_TSP on TOP (solid shape): 98.69,86.24 99.78,86.24 99.83,86.19 99.83,85.75 99.78,85.7 98.49,85.7 97.88,86.31 97.88,86.57 97.99,86.68 98.25,86.68
+3.3V_WLAN on TOP (solid shape): 246.21,22.13 246.21,20.35 245.96,20.1 244.46,20.1 243.6,20.96 243.42,20.96 243.22,21.16 243.22,22 243.27,22.05 244.39,22.05 244.59,22.25 246.09,22.25
+3.3V_WLAN on TOP (solid shape): 261.8,21.32 261.8,20.15 260.03,20.15 259.93,20.25 259.5,20.25 259.42,20.32 259.42,20.77 259.48,20.86 259.58,20.85 260.02,20.85 260.17,21.26 260.19,21.35 260.27,21.39 261.73,21.39
+3.3V_WLAN on TOP (solid shape): 246.4,34.88 246.44,34.86 246.45,34.83 246.45,34.38 246.96,34.38 246.96,34.83 246.97,34.86 247.01,34.88 247.2,34.88 247.24,34.86 247.25,34.83 247.25,34.38 247.76,34.38 247.76,34.83 247.77,34.86 247.81,34.88 248.75,34.88 248.93,34.7 248.93,33.43 247.55,32.05 246.87,32.05 245.95,32.97 244.92,32.97 244.82,33.07 244.82,33.87 244.19,34.49 244.19,34.8 244.27,34.88
+3.3V_WLAN on BOTTOM (solid shape): 262.06,23.02 262.06,21.01 261.62,20.57 261,20.57 260.83,20.75 260.83,21.14 261.28,21.59 261.28,23.04 261.38,23.14 261.94,23.14
+3.3V_WLAN on BOTTOM (solid shape): 244.64,23.12 244.64,21.54 244.72,21.47 244.99,21.47 245.2,21.26 245.2,20.6 244.89,20.3 244.33,20.3 243.45,21.19 243.45,22.89 243.72,23.17 244.59,23.17
+3.3V_WLAN on IN3 (solid shape): outline of 1064 points within 242.78,17.64 261.81,34.22
+3.3V_WLAN_UZ3 on TOP (solid shape): outline of 234 points within 242.99,34.51 249.34,38.76
+3.3V_WWAN on TOP (solid shape): outline of 489 points within 236.66,50.22 243.76,78.43
+3.3V_WWAN on BOTTOM (solid shape): 240.45,60.76 240.45,60.58 240.58,60.46 242.12,60.46 242.25,60.33 242.25,59.03 242.07,58.86 240.07,58.86 239.78,59.16 239.4,59.33 239.39,59.33 239.31,59.41 239.31,60.33 239.32,60.34 239.32,60.7 239.58,60.96 240.24,60.96
+3.3V_WWAN on BOTTOM (solid shape): outline of 245 points within 236.69,75.9 242.37,84.64
+3.3V_WWAN_UZ2 on TOP (solid shape): 245.97,53.41 245.97,52.65 245.97,52.64 245.97,52.52 246.18,52.31 246.89,52.31 247.17,52.03 247.17,50.95 247.11,50.89 246.5,50.89 246.34,50.72 245.23,50.72 244.95,50.45 243.8,50.45 243.74,50.5 243.74,51.3 243.19,51.3 243.18,51.31 243.18,51.74 243.2,51.76 243.74,51.76 243.74,52.51 243.19,52.51 243.18,52.52 243.18,52.54 243.18,52.9 243.18,52.92 243.19,52.94 243.74,52.94 243.74,53.79 243.77,53.83 245.55,53.83
+5V_ALW on TOP (solid shape): 73.6,89.51 73.6,86.24 73.47,86.11 71.92,86.11 71.67,86.36 71.67,90.07 72.02,90.43 72.68,90.43
+5V_ALW on TOP (solid shape): 203.93,79.04 203.93,78.07 203.62,77.77 203.04,77.77 201.49,79.31 201.49,80.71 201.62,80.84 202.12,80.84
+5V_ALW on TOP (solid shape): 209.24,74.92 209.24,73.63 209.06,73.45 208.02,73.45 207.66,73.8 207.66,74.92 207.76,75.02 209.13,75.02
+5V_ALW on TOP (solid shape): 281.95,65.42 281.95,64.29 281.85,64.19 280.8,64.19 280.65,64.34 280.65,65.07 281.16,65.59 281.78,65.59
+5V_ALW on TOP (solid shape): 267.68,33 267.68,32.59 266.51,31.42 266.3,31.42 266.27,31.4 264.93,31.4 264.86,31.47 264.86,32.44 265.04,32.62 265.51,32.62 265.51,32.62 265.69,32.62 266.23,33.15 266.29,33.15 266.39,33.25 267.42,33.25
+5V_ALW on TOP (solid shape): 284.62,62.39 284.62,62.07 284.59,62.05 284.46,61.94 284.39,61.78 284.38,61.77 284.33,61.71 284.33,60.43 283.59,59.69 282.3,59.69 281.98,60.01 281.98,60.66 282.64,61.32 282.89,61.32 283.15,61.57 283.15,62.44 283.2,62.49 284.52,62.49
+5V_ALW on TOP (solid shape): 246.96,45.95 247.15,45.9 247.35,45.95 247.43,45.95 247.46,45.93 247.46,44.76 247.36,44.66 247.25,44.66 247.18,44.58 247.18,44.53 247.18,43.89 246.85,43.56 244.05,43.56 243.87,43.84 243.53,43.87 243.51,43.87 243.42,43.96 243.42,44.71 243.55,44.84 243.55,45.68 243.62,45.75 244.18,45.75 244.41,45.52 244.5,45.52 244.64,45.47 244.78,45.48 244.92,45.34 244.92,45.06 245.07,44.91 246.59,44.91 246.7,45.01 246.7,45.83 246.82,45.95
+5V_ALW on TOP (solid shape): 211.75,64.47 211.75,62.59 211.19,62.03 210.25,62.03 210.25,62.5 210.23,62.51 210.23,62.55 209.53,62.55 209.53,62.54 209.51,62.54 209.51,62.03 209.06,62.03 209.06,62.54 209.03,62.54 209.03,62.55 208.33,62.55 208.33,62.54 208.31,62.54 208.31,62.03 207.4,62.03 206.34,60.96 206.34,57.1 206.34,57.09 206.34,57.02 207.79,55.57 207.79,54.69 207.69,54.59 207.42,54.59 207.42,55.15 206.93,55.15 206.93,54.59 206.06,54.59 206.01,54.64 206.01,54.65 205.27,55.38 205.27,55.43 204.55,56.15 204.55,57.21 205.27,57.92 205.27,62.21 206.11,63.05 206.79,63.05 207.06,63.16 207.17,63.43 207.37,63.62 207.58,63.62 207.76,63.73 207.78,63.73 208.19,64.14 208.19,64.67 208.39,64.88 211.34,64.88
+5V_ALW on BOTTOM (solid shape): 209.31,74.72 209.31,73.83 209.08,73.6 207.28,73.6 207.1,73.78 207.1,74.95 207.23,75.07 208.96,75.07
+5V_ALW on BOTTOM (solid shape): 20.41,88.04 20.41,85.93 20.28,85.81 18.17,85.81 18.06,85.92 18.06,86.38 18.25,86.57 18.5,86.57 18.63,86.69 18.63,88.09 19.19,88.65 19.8,88.65
+5V_ALW on BOTTOM (solid shape): 281.7,65.05 281.7,63.76 281.61,63.66 280.73,63.66 280.58,63.81 280.58,64.41 281.12,64.94 281.31,65.04 281.49,65.15 281.6,65.15
+5V_ALW on BOTTOM (solid shape): 284.06,60.98 284.06,60.29 283.44,59.67 282.58,59.67 282.39,59.48 281.27,59.48 280.9,59.85 280.9,60.99 281.04,61.13 281.5,61.13 281.81,61.44 282.58,61.44 282.67,61.35 282.98,61.35 283.1,61.46 283.58,61.46
+5V_ALW on BOTTOM (solid shape): 201.08,75.11 201.08,74.85 200.52,74.85 200.52,74.36 201.08,74.36 201.08,74.08 200.91,73.88 200.91,73.61 200.91,73.6 200.91,73.52 201.08,73.36 201.08,73.08 200.98,72.98 200.42,72.98 200.31,73.09 200.3,73.1 200.23,73.2 200.13,73.27 200.12,73.27 199.6,73.79 199.6,75.11 199.66,75.16 201.03,75.16
+5V_ALW on IN2 (solid shape): 211.52,64.67 211.52,63.28 211.19,62.95 208.98,62.95 208.8,62.77 208.37,62.77 207.73,63.4 207.73,63.53 208.34,64.14 208.34,64.72 208.52,64.9 211.29,64.9
+5V_ALW on IN2 (solid shape): 200.88,73.74 200.95,73.53 201.12,73.39 201.15,73.38 201.15,72.22 200.7,71.76 200.42,71.76 200.06,72.11 200.06,72.59 200.19,72.92 199.99,73.21 199.96,73.23 199.96,73.92 200.11,74.07 200.55,74.07
+5V_ALW on IN2 (solid shape): 250.13,40.49 250.39,40.23 250.39,40.07 250.38,40.06 250.38,40.03 246.1,35.74 244.26,35.74 244.12,35.88 244.12,36.91 244.78,37.57 246.44,37.57 248.51,39.64 248.95,39.71 249.02,40.15 249.05,40.18 249.23,40.28 249.33,40.45 249.36,40.49 250.13,40.49
+5V_ALW on IN2 (solid shape): outline of 461 points within 18.02,70.46 56.21,88.19
+5V_ALW on IN3 (solid shape): 209.11,88.64 209.11,87.32 208.8,87.01 207.36,87.01 207.1,87.27 207.1,88.79 207.18,88.87 208.88,88.87
+5V_ALW on IN3 (solid shape): 170.07,92.75 170.07,88.71 169.92,88.56 168.29,88.56 168.11,88.74 168.11,88.84 168.12,88.84 168.14,88.98 168.12,89.12 168.11,89.13 168.11,89.91 167.58,90.44 167.58,93.18 167.73,93.34 169.48,93.34
+5V_ALW on IN3 (solid shape): 202.33,82.16 202.33,80.71 202.35,80.69 202.35,80.68 202.45,80.48 202.65,80.38 202.66,80.38 202.96,80.08 202.96,79.65 202.73,79.42 201.13,79.42 200.47,80.08 200.47,82.19 200.75,82.46 202.02,82.46
+5V_ALW on IN3 (solid shape): 285.11,62.97 285.11,62.02 285.05,61.96 285.02,62 284.61,62.06 284.38,61.72 284.38,61.7 284.28,61.59 284.28,60.35 283.96,60.04 282.21,60.04 282.01,60.24 282.01,61.89 283.26,63.14 284.94,63.14
+5V_ALW on IN3 (solid shape): 87.97,33.38 88.07,33.39 88.71,33.39 88.81,33.38 88.91,33.39 89.46,33.39 89.65,33.2 89.66,33.17 89.66,33.16 89.76,32.82 90.11,32.71 90.12,32.72 90.15,32.71 90.6,32.25 94.31,32.25 94.68,31.88 94.68,28.32 94.22,27.87 88.88,27.87 87.19,29.56 87.19,33.24 87.34,33.39 87.87,33.39
+5V_ALW on IN3 (solid shape): outline of 1565 points within 213.8,20.81 246.47,36.96
+5V_ALW on IN4 (solid shape): 73.32,87.51 73.32,84.51 73.14,84.33 71.46,84.33 71.11,84.69 71.11,87.25 71.44,87.58 73.24,87.58
+5V_ALW on IN4 (solid shape): outline of 93 points within 54.55,71.15 58.48,74.49
+5V_ALW on IN4 (solid shape): outline of 1166 points within 65.19,26.83 90.82,72.14
+5V_ALW on VCC: 245.81,23.32 244.03,25.1 236.19,25.1 232.69,28.59 232.69,36.74 228.58,40.85 220.59,40.85 218.15,43.3 218.15,45.9 215.96,48.09 215.96,48.1 215.31,48.75 215.3,48.75 214.99,49.06 214.99,55.31 214.42,55.88 209.08,55.88 208.34,56.62 208.34,59.77 208.37,59.79 208.37,60 208.34,60.03 208.34,64.73 208.53,64.91 234.96,64.91 235.41,64.47 239.74,64.47 240.58,65.31 243.78,68.52 272.15,68.52 275.42,65.24 283.88,65.23 284.49,64.62 284.49,59.62 283.83,58.96 282.05,58.96 276.25,53.15 273.9,53.15 261.89,53.1 261.74,53.1 257.17,57.67 243.88,57.67 242.59,56.38 242.59,49.19 242.97,48.81 242.97,46.27 244,45.24 244.17,45.22 245.22,45.22 245.46,44.98 245.46,41.97 245.44,41.96 245.44,38.73 248.47,35.7 248.47,30.61 249.03,30.05 261.81,30.05 263.1,31.34 263.1,32.49 263.59,32.97 266.3,32.97 266.53,32.74 266.53,30.84 267.68,29.69 267.68,27.36 266.43,26.12 255.63,26.12 252.84,23.32
+5V_ALW2 on TOP (solid shape): 263.57,13.2 263.57,12.72 263.87,12.41 263.87,11.47 263.8,11.4 263.24,11.4 263.21,11.42 263.21,12.13 263.03,12.31 263.03,13.15 263.16,13.27 263.49,13.27
+5V_ALW2_R on TOP (solid shape): 264.48,10.68 264.48,10.68 264.66,10.51 264.66,9.21 264.65,9.2 264.65,8.19 264.61,8.14 264.4,8.14 264.3,8.25 264.3,9.44 263.21,10.53 263.21,10.99 263.29,11.07 264.1,11.07
+5V_ALWP on TOP (solid shape): 208.93,61.9 209.63,61.9 209.63,62.41 210.12,62.41 210.12,61.9 210.13,61.9 211.57,61.9 211.85,61.62 211.85,59.47 211.7,59.31 206.72,59.31 206.63,59.4 206.63,60.87 207.65,61.9 208.43,61.9 208.43,62.41 208.93,62.41
+5V_ALWP on BOTTOM (solid shape): 213.4,62.28 213.4,58.86 213.27,58.73 210.78,58.73 210.2,59.31 206.62,59.31 206.56,59.36 206.56,60.96 208.01,62.41 213.27,62.41
+5V_HDD on TOP (solid shape): 278.93,20.45 278.93,19.18 278.85,19.1 278.85,17.73 278.85,17.73 278.85,17.14 278.78,17.06 278.78,16.65 278.68,16.55 278.41,16.55 278.24,16.72 278.24,20.37 278.37,20.5 278.88,20.5
+5V_HDD on TOP (solid shape): 268.43,29.72 268.84,29.72 268.84,29.13 269.01,28.96 269.01,27.7 268.69,27.39 268.17,27.39 267.68,27.38 267.6,26.9 267.54,26.84 266.83,26.84 266.68,26.99 266.68,27.4 267.19,27.4 267.19,27.83 266.68,27.83 266.68,28.79 266.7,28.82 266.9,28.82 267.81,29.72 268.2,29.72 268.2,29.76 268.22,29.78 268.22,30 268.21,30.02 268.21,30.22 268.23,30.25 268.43,30.25
+5V_HDD on BOTTOM (solid shape): 278.24,21.62 278.31,21.59 278.34,21.52 278.48,21.23 278.79,21.14 278.8,21.14 278.83,21.14 278.88,21.09 278.88,19.28 278.62,19.03 278.62,17.1 278.52,17 277.51,17 277.35,17.15 277.35,19.26 276.64,19.97 276.64,21.37 276.9,21.62
+5V_HDD on BOTTOM (solid shape): outline of 85 points within 267.5,25.4 270.37,29.14
+5V_HDD_UZ2 on TOP (solid shape): 268.87,31.54 268.87,29.85 268.55,29.85 268.55,30.37 268.53,30.37 268.53,30.38 268.09,30.38 268.09,30.29 268.08,30.28 268.08,29.96 268.09,29.95 268.09,29.85 267.75,29.85 267.73,29.82 267.68,29.82 266.97,29.11 264.98,29.11 264.86,29.24 264.86,30.05 264.93,30.13 265.7,30.13 266.13,30.56 266.14,30.56 266.32,30.56 266.38,30.62 266.39,30.62 266.51,30.74 266.87,30.74 267.11,30.98 267.11,31.72 267.59,32.2 268.22,32.2
+5V_RUN on TOP (solid shape): 76.69,94.31 76.69,92.79 76.26,92.36 74.69,92.36 74.31,92.74 74.31,94.57 74.61,94.87 76.14,94.87
+5V_RUN on TOP (solid shape): 257.77,70.64 258.99,70.64 259.07,70.57 259.07,69.98 258.96,69.88 256.5,69.88 256.35,70.03 256.35,70.59 256.42,70.67 257.75,70.67
+5V_RUN on TOP (solid shape): 262.39,11.54 262.39,10.09 263.08,9.4 263.08,8.23 263.03,8.18 262.85,8.18 262.8,8.23 262.8,9.15 262.69,9.26 262.66,9.29 262.63,9.32 261.96,9.99 261.96,11.46 262.06,11.56 262.37,11.56
+5V_RUN on TOP (solid shape): 266.55,28.73 266.55,28.24 266.53,28.24 266.53,27.73 266.55,27.73 266.55,27.71 267.07,27.71 267.07,27.52 266.55,27.52 266.55,27.5 266.53,27.5 266.53,26.62 266.34,26.43 265.47,26.43 265.28,26.23 264.11,26.23 263.93,26.42 263.93,26.89 264.17,27.13 264.57,27.13 264.64,27.2 264.64,27.76 264.75,27.87 265.21,27.87 265.21,27.92 265.23,27.93 265.23,28.87 266.4,28.87
+5V_RUN on TOP (solid shape): 273.82,45.39 273.82,45.38 274.45,45.38 274.53,45.29 274.53,44.58 274.49,44.58 274.37,44.53 274.27,44.44 274.15,44.33 273.42,44.33 272.93,43.84 272.93,43.12 272.81,42.99 271.77,42.99 271.64,42.86 271.64,41.93 271.6,41.88 271.42,41.88 271.42,42.57 270.84,42.57 270.84,43.04 271.39,43.04 271.39,43.74 270.84,43.74 270.84,44.24 271.39,44.24 271.39,45.68 271.61,45.9 273.31,45.9
+5V_RUN on TOP (solid shape): 247.05,42.7 247.05,42.6 247.16,42.39 247.39,42.36 247.51,42.24 247.51,40.79 246.95,40.23 246.91,40.22 246.64,40.22 246.47,40.26 246.29,40.22 244.4,40.22 244.13,40.49 244.13,41.44 244.66,41.44 244.66,41.99 244.13,41.99 244.13,42.24 244.66,42.24 244.66,42.79 244.13,42.79 244.13,43.16 246.59,43.16
+5V_RUN on BOTTOM (solid shape): 90.23,96.09 98.61,96.09 99.27,95.43 102.98,95.43 103.44,94.97 103.44,93.73 103.25,93.54 103.23,93.53 103.21,93.52 99.33,93.52 98.95,93.91 93.94,93.91 93.66,93.63 86.46,93.63 86.27,93.68 86.08,93.63 83.22,93.63 83.19,93.64 83.19,93.66 83.09,93.78 82.95,93.85 82.62,93.9 82.39,93.66 82.37,93.64 82.34,93.63 77.99,93.63 76.9,92.54 74.69,92.54 74.15,93.07 74.15,95.46 74.61,95.91 74.63,95.91 74.81,96.1 90.23,96.1
+5V_RUN on BOTTOM (solid shape): 69.51,74.38 69.51,72.29 70.14,71.66 70.14,71.12 70.34,70.92 70.34,70.39 70.29,70.34 70.29,68.56 70.45,68.4 70.56,68.06 70.9,67.95 72.51,66.34 72.51,62.79 73.7,61.6 74.64,61.6 75.61,60.63 75.6,60.51 75.63,60.39 75.63,60.3 75.83,60.1 76.69,60.1 76.77,60.02 76.77,58.63 76.57,58.42 71.84,58.42 69.67,60.6 69.67,65.68 67.14,68.2 67.14,68.94 68.02,69.82 68.02,70.55 67.35,71.23 67.35,73.56 66.64,74.27 66.64,74.28 66.41,74.5 66.41,74.5 66.33,74.58 65.11,74.58 65.06,74.53 64.71,74.53 64.6,74.63 64.6,76.58 64.78,76.76 67.12,76.76
+5V_RUN on BOTTOM (solid shape): outline of 382 points within 231.08,83.15 245.53,100.92
+5V_RUN on BOTTOM (solid shape): outline of 1266 points within 245.19,40.52 273.09,50.95
+5V_RUN on IN2 (solid shape): outline of 853 points within 64.6,74.53 76.77,94.21
+5V_RUN on IN3 (solid shape): 232.77,84.2 232.77,83.32 232.39,82.94 232.39,80.37 232.56,80.19 232.56,77.77 232.52,77.69 232.43,77.68 232.35,77.7 232.28,77.7 232.2,77.73 232.17,77.8 231.68,78.16 231.46,77.59 231.48,77.52 231.44,77.46 231.43,76.89 232,76.95 232.05,76.99 232.13,76.98 232.27,76.94 232.43,76.96 232.52,76.95 232.56,76.86 232.56,74.32 232.61,74.27 232.61,74.23 233.08,73.76 233.08,73.54 232.96,73.41 232.05,73.41 232.02,73.41 230.24,75.19 230.24,75.21 229.63,75.82 229.63,78.34 230.49,79.2 230.52,79.22 230.55,79.21 230.99,79.29 231.06,79.72 231.05,79.76 231.05,79.76 230.99,79.83 230.9,79.91 230.9,83.31 231.94,84.35 232.62,84.35
+5V_RUN on IN3 (solid shape): outline of 765 points within 233.89,56.85 246.44,69.55
+5V_RUN on IN3 (solid shape): outline of 880 points within 75.88,54.41 96.39,63.4
+5V_RUN on IN3 (solid shape): outline of 1243 points within 210.1,35.69 248.12,49.64
+5V_RUN on IN4 (solid shape): outline of 1190 points within 244.69,26.47 265.29,42.39
+5V_RUN_AUDIO on TOP (solid shape): outline of 162 points within 268.36,39.12 272.58,50.16
+5V_RUN_AUDIO on IN3 (solid shape): outline of 729 points within 270.61,20.1 287.08,41.25
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 273.14,50.17 273.14,49.56 273.44,49.25 273.93,49.25 274.03,49.15 274.03,48.43 274.51,47.95 274.51,46.71 274.36,46.56 273.77,46.56 273.41,46.2 272.19,46.2 271.95,46.44 271.95,47.81 271.93,47.83 271.5,47.83 271.5,47.83 271.4,47.83 271.4,48.26 271.94,48.26 271.95,48.28 271.95,49.02 271.94,49.03 271.39,49.03 271.39,49.41 271.39,49.47 271.93,49.47 271.94,49.48 271.94,50.17 271.99,50.22 273.09,50.22
+5V_RUN_PVDD on TOP (solid shape): 281.36,41.48 281.68,41.48 281.8,41.36 281.8,40.81 281.48,40.49 281.48,39.09 281.35,38.96 281.06,38.96 279.84,37.74 279.71,37.74 279.71,38.09 280.39,38.77 280.39,40.84 280.38,40.85 280.38,40.95 280.15,41.17 280.15,41.36 280.28,41.48 281.36,41.48
+5V_RUN_PVDD on TOP (solid shape): 275.2,40.64 275.93,40.64 276.16,40.42 276.16,40.03 276.34,39.86 276.74,39.86 276.83,39.77 276.83,38.24 277.69,37.39 277.69,37.22 277.59,37.13 277.46,37.13 277,37.6 276.23,37.6 274.73,39.1 273.54,39.1 273.39,39.24 273.39,40.64 273.37,40.67 272.99,40.67 272.86,40.8 272.35,40.8 272.27,40.87 272.27,41.18 272.44,41.34 274.5,41.34
+5V_RUN_PVDD on IN1 (solid shape): outline of 215 points within 272.2,39.2 281.55,41.75
+5V_RUN_UZ4 on TOP (solid shape): 242.3,45.66 242.3,45.04 242.63,44.71 242.63,44.54 242.63,44.53 242.63,44.1 242.65,44.09 242.65,43.8 243.34,43.11 243.98,43.11 243.98,42.66 244.53,42.66 244.53,42.37 243.98,42.37 243.98,41.86 244.53,41.86 244.53,41.57 243.98,41.57 243.98,41.1 241.86,41.1 241.55,41.41 241.55,42.56 241.11,43.01 241.11,43.29 240.88,43.52 240.88,45.17 240.96,45.24 240.96,45.52 241.18,45.75 242.21,45.75
+5V_USB_CHG_PWR on TOP (solid shape): 286.37,65.82 286.37,64.31 286.19,64.14 284.26,64.14 284.16,64.24 284.16,65.69 284.52,66.04 286.15,66.04
+5V_USB_CHG_PWR on BOTTOM (solid shape): 289.37,61.69 289.37,59.11 290,58.47 291.2,58.47 291.48,58.2 291.48,56.19 291.25,55.96 290.34,55.96 290,56.16 289.67,55.96 289,55.96 288.89,56.08 288.89,56.08 288.38,56.75 287.76,57.3 286.63,57.89 285.37,58.12 285.24,58.12 285.04,58.11 284.83,58.1 284.67,58.26 284.67,59.04 284.14,59.57 284.14,59.82 284.35,60.03 284.48,60.03 284.58,59.95 284.7,59.91 284.76,59.86 285.04,59.86 285.16,59.98 285.16,61 285.84,61.68 288.21,61.68 288.37,61.85 289.22,61.85
+5V_USB_CHG_PWR on IN4 (solid shape): outline of 169 points within 283.93,60.41 289.77,66.2
+DV33_18 on TOP (solid shape): 261.61,39.96 261.61,39.16 261.74,39.04 261.74,38.53 261.52,38.31 261.27,38.31 261.15,38.18 261.15,37.63 261.11,37.6 260.39,37.6 260.25,37.74 260.25,38.65 260.54,38.94 261.11,38.94 261.14,38.94 261.42,39.23 261.42,39.97 261.48,40.03 261.55,40.03
+GND_CHASSIS on TOP (solid shape): 283.81,95.52 283.81,94.45 282.53,93.17 268.86,93.17 268.67,93.36 268.67,94.28 268.89,94.49 281.99,94.49 283.15,95.65 283.68,95.65
+GND_CHASSIS on BOTTOM (solid shape): 283.89,94.99 283.89,93.46 285.2,92.15 285.2,91.39 284.95,91.14 282.88,91.14 282.82,91.2 282.82,95.37 283,95.55 283.33,95.55
+VCC_CORE on TOP (solid shape): 154.37,74.36 154.37,73.68 154.35,73.65 154.35,72.87 154.2,72.72 153.66,72.72 153.64,72.71 153.61,72.71 153.51,72.61 153.51,72.57 153.51,67.92 153.71,67.72 153.71,63.68 153.83,63.55 154.14,63.55 154.27,63.43 154.27,62.69 154.11,62.54 153.3,62.54 153.12,62.72 153.12,63.38 153.12,63.48 152.88,63.72 152.26,63.72 152.13,63.85 152.13,68.13 152.27,68.27 152.49,68.27 152.7,68.47 152.7,68.83 152.52,69 152.22,69 152.12,69.1 152.12,69.43 152.23,69.54 152.52,69.54 152.7,69.71 152.7,69.99 152.75,70.04 152.75,70.83 152.67,70.91 152.29,70.91 152.12,71.08 152.12,71.57 152.12,71.92 153.05,72.85 153.05,73.62 153.46,74.03 153.46,74.51 153.53,74.59 154.14,74.59
+VCC_CORE on TOP (solid shape): 156.12,73.56 156.12,72.95 155.76,72.6 155.76,71.53 156.09,71.2 156.09,70.47 156,70.25 156.08,70.02 156.09,70.01 156.09,69.92 156.08,69.91 156.02,69.72 156.09,69.54 156.09,67.9 156.12,67.87 156.12,67.86 156.13,67.86 156.22,67.77 156.5,67.77 156.63,67.64 156.63,67.24 156.63,66.63 156.63,65.61 156.63,64.8 156.63,63.85 156.5,63.72 155.71,63.72 155.59,63.85 155.59,67.76 155.55,67.8 155.55,67.82 155.53,67.82 155.44,67.9 154.58,67.9 154.48,68 154.48,68.24 154.63,68.39 154.86,68.39 155.11,68.64 155.11,68.9 154.88,69.13 154.58,69.13 154.48,69.23 154.48,69.52 154.6,69.64 154.88,69.64 155.08,69.84 155.08,70.02 155.11,70.04 155.11,70.78 154.88,71.01 154.6,71.01 154.48,71.13 154.48,71.57 154.48,72.08 155.11,72.71 155.11,73.33 155.5,73.72 155.63,73.72 155.73,73.75 155.74,73.76 155.92,73.76
+VCC_CORE on TOP (solid shape): outline of 208 points within 148.68,63.58 152.28,75.45
+VCC_CORE on TOP (solid shape): outline of 575 points within 106.44,69.65 121.73,78.08
+VCC_CORE on BOTTOM (solid shape): 156.17,73.24 156.17,73.01 156.12,72.95 156.06,72.95 155.93,72.83 155.81,72.83 155.54,72.92 155.35,72.7 155.13,72.7 154.98,72.85 154.98,73.2 155.06,73.29 155.1,73.4 155.1,73.41 155.2,73.51 155.26,73.53 155.31,73.56 155.35,73.56 155.5,73.71 155.7,73.71
+VCC_CORE on BOTTOM (solid shape): outline of 536 points within 148.26,70.88 155.03,73.68
+VCC_CORE on BOTTOM (solid shape): outline of 527 points within 150.04,60.26 155.64,62.74
+VCC_CORE on BOTTOM (solid shape): outline of 613 points within 101.49,69.74 121.68,79.34
+VCC_CORE on IN2 (solid shape): outline of 8099 points within 104.28,63.43 157.25,91.06
+VCC_CORE on IN3 (solid shape): outline of 7017 points within 103.36,60.26 156.53,86.46
+VCC_CORE on VCC: 149.06,61.27 148.42,61.91 148.42,72.14 147.97,72.6 146.12,72.6 145.61,73.11 140.78,73.11 140.53,73.36 136.72,73.36 136.46,73.61 134.48,73.61 134.22,73.36 131.13,73.36 130.24,74.25 128.58,74.25 123.96,69.63 116.83,69.63 116.27,70.18 114.79,70.18 114.34,69.71 106.9,69.71 106.37,70.25 101.45,70.25 101.1,70.59 101.1,78.26 102.75,79.9 108.59,79.9 112.33,83.65 114.04,83.65 114.05,83.64 114.15,83.65 114.79,83.65 115.3,83.14 118.56,83.14 121.99,86.57 147.56,86.57 151.62,82.5 152.89,82.5 155.57,79.83 155.57,77.3 155.28,77.01 155.28,75.51 154.87,75.1 154.87,73.77 155.2,73.43 155.2,72.88 154.77,72.45 154.77,70.97 155.92,69.82 155.92,61.53 155.68,61.29 155.18,61.29 155.15,61.27
+VCC_GT on TOP (solid shape): 143.7,77.91 143.7,76.56 143.47,76.33 140.8,76.33 140.58,76.56 140.58,77.74 140.71,77.88 141.21,77.88 141.4,78.07 143.53,78.07
+VCC_GT on TOP (solid shape): outline of 520 points within 105.86,51.88 119.49,69.55
+VCC_GT on TOP (solid shape): outline of 566 points within 132.65,62.89 148.4,72.17
+VCC_GT on BOTTOM (solid shape): outline of 1964 points within 99.18,50.46 148.45,73.18
+VCC_GT on IN1 (solid shape): outline of 1070 points within 133.94,67.38 145.96,78.47
+VCC_GT on IN2 (solid shape): outline of 8779 points within 103.34,46.21 147.92,72.85
+VCC_GT on IN3 (solid shape): outline of 2941 points within 103.32,51.37 148.04,72.85
+VCC_GT on VCC: 103.34,43.17 103.34,60.02 103.34,69.49 103.58,69.74 106.16,69.74 106.69,69.21 114.55,69.21 115,69.68 116.06,69.68 116.62,69.12 124.17,69.12 128.79,73.74 130.03,73.74 130.92,72.85 134.43,72.85 134.69,73.11 136.25,73.11 136.51,72.85 140.32,72.85 140.57,72.6 145.4,72.6 145.91,72.09 147.76,72.09 147.92,71.93 147.92,61.91 147.28,61.27 146.09,61.27 145.96,61.4 144.58,61.4 144.46,61.27 138.88,61.27 138.11,62.03 138.11,63.81 137.53,64.39 133.25,64.39 132.13,65.51 128.02,65.51 126.42,63.91 124.53,63.91 124.5,63.94 122.79,63.94 122.77,63.91 121.01,63.91 113.96,56.86 113.96,56.86 113.17,56.07 113.17,52.59 103.76,43.17 103.75,43.17
+VCC_GTUS on BOTTOM (solid shape): outline of 1051 points within 139.13,60.51 149.77,62.67
+VCC_GTUS on IN4 (solid shape): 143.98,62.31 143.98,61.83 143.92,61.77 141.33,61.77 141.24,61.83 141.26,61.94 140.98,62.58 140.7,61.94 140.71,61.83 140.62,61.77 140.08,61.77 139.66,62.19 139.66,62.64 139.67,62.65 139.67,62.78 139.94,63.05 143.24,63.05
+VCC_SA on TOP (solid shape): 120.89,86.26 120.89,85.63 120.69,85.42 120.07,85.42 118.14,83.49 117.4,83.49 117.17,83.27 115.85,83.27 115.51,83.61 115.51,85.51 115.68,85.68 118.76,85.68 119.54,86.47 120.69,86.47
+VCC_SA on TOP (solid shape): 158.63,67.03 158.63,66.63 158.76,66.5 159.14,66.5 159.22,66.42 159.22,65.99 159.1,65.88 157.4,65.88 157.31,65.97 157.31,67.14 158.53,67.14
+VCC_SA on TOP (solid shape): 158.89,72.55 158.89,72.17 159.17,71.89 159.4,71.89 159.55,71.73 159.55,71.45 159.8,71.2 159.8,70.51 159.7,70.41 159.7,68.66 159.55,68.51 156.3,68.51 156.22,68.58 156.22,69.24 156.61,69.63 156.83,69.63 156.87,69.59 156.87,69.26 157.76,69.26 157.76,69.47 157.99,69.7 158.19,69.7 158.38,69.89 158.38,70.24 158.51,70.36 158.63,70.36 158.72,70.45 158.72,71.34 158.51,71.34 158.44,71.4 158.44,71.48 158.45,71.48 158.13,71.94 157.85,71.45 157.86,71.44 157.86,71.4 157.8,71.34 157.58,71.34 157.54,71.38 157.09,71.38 157.04,71.43 157.04,71.48 157.04,71.49 156.9,71.92 156.46,71.81 156.43,71.75 156.41,71.61 156.45,71.49 156.45,71.48 156.45,71.4 156.39,71.34 156.22,71.34 155.92,71.65 155.92,72.44 156.27,72.8 158.63,72.8
+VCC_SA on BOTTOM (solid shape): 159.91,62.64 159.91,62.35 159.89,62.33 159.88,62.3 159.86,62.24 159.85,62.14 159.83,62.09 159.78,62.08 159.54,62.02 159.47,61.78 159.45,61.69 159.37,61.65 159.26,61.65 159.15,61.65 159.07,61.69 159.05,61.78 158.81,62.09 158.56,61.78 158.54,61.69 158.46,61.65 158.39,61.65 158.37,61.65 158.2,61.82 158.2,61.87 158.17,61.96 158.12,62.04 158.12,62.42 158.65,62.95 159.6,62.95
+VCC_SA on BOTTOM (solid shape): outline of 127 points within 112.17,79.71 120.79,85.7
+VCC_SA on BOTTOM (solid shape): outline of 451 points within 155.94,70.46 160.36,73.74
+VCC_SA on IN3 (solid shape): outline of 5033 points within 115.2,62.03 166.11,93.27
+VCC_SA on VCC: 156.68,61.27 156.42,61.53 156.42,70.04 155.28,71.18 155.28,72.24 155.71,72.67 155.71,73.64 155.37,73.98 155.37,74.89 155.79,75.3 155.79,76.8 156.08,77.09 156.08,80.04 153.1,83.01 151.83,83.01 147.77,87.08 121.78,87.08 118.35,83.65 115.51,83.65 115.15,84.01 115.15,84.53 115.15,84.64 115.15,86.33 118.3,89.49 119.7,89.49 121.22,91.01 152.56,91.01 157.65,85.92 164.06,85.92 164.35,85.63 164.35,72.75 163.37,71.76 163.37,69.08 163.13,68.84 161.65,68.84 159.6,66.78 159.6,61.5 159.37,61.27
+VCC_SFR_OC on TOP (solid shape): outline of 618 points within 158.81,40.61 160.95,63.28
GND on TOP (solid shape): 101.33,82.99 101.33,81.87 101.26,81.79 100.21,81.79 100.09,81.92 100.09,82.99 100.21,83.11 101.21,83.11
GND on TOP (solid shape): 205.57,74.71 205.57,73.79 205.32,73.54 203.72,73.54 203.31,73.94 203.31,75.34 203.44,75.47 204.81,75.47
GND on TOP (solid shape): 207.99,73.18 207.99,67.82 207.86,67.69 206.13,67.69 205.8,68.03 205.8,72.57 206.59,73.36 207.81,73.36
GND on TOP (solid shape): 216.4,104.16 216.4,102.35 216.27,102.23 215.28,102.23 214.82,102.68 214.82,104.87 214.9,104.94 215.62,104.94
GND on TOP (solid shape): 297.95,38.95 297.95,37.73 297.64,37.43 295.42,37.43 295.16,37.69 295.16,38.78 295.49,39.1 297.8,39.1
GND on TOP (solid shape): 304.71,22.93 304.71,20.73 304.53,20.55 303.98,20.55 303.54,20.99 303.54,22.9 303.63,22.99 304.64,22.99
GND on TOP (solid shape): 208.34,52.4 208.34,51.29 208.06,51.01 206.13,51.01 205.98,51.16 205.98,52.28 206.18,52.48 208.27,52.48
GND on TOP (solid shape): 213.93,50.22 213.93,49.01 213.18,48.26 210.43,48.26 209.94,48.75 209.94,50.09 210.17,50.32 213.83,50.32
GND on TOP (solid shape): 240.04,47.98 240.04,45.5 239.86,45.32 238.57,45.32 238.14,45.75 238.14,46.81 239.38,48.06 239.97,48.06
GND on TOP (solid shape): 62.78,94.8 62.78,93.93 62.7,93.86 60.49,93.86 60.4,93.95 60.4,94.48 61.06,95.15 62.43,95.15
GND on TOP (solid shape): 110.7,79.07 110.7,76.23 110.32,75.85 107.23,75.85 106.97,76.1 106.97,79.2 107.65,79.88 109.9,79.88
GND on TOP (solid shape): 110.65,69.3 110.65,66.13 110.35,65.83 107.81,65.83 107.63,66.01 107.63,69.19 107.91,69.47 110.48,69.47
GND on TOP (solid shape): 112.23,35.67 112.23,31.07 111.58,30.42 107.77,30.42 107.38,30.81 107.38,32.9 110.43,35.94 111.95,35.94
GND on TOP (solid shape): 177.89,101.05 179.54,101.05 179.79,100.79 179.79,100.28 179.46,99.95 174.66,99.95 174.08,100.54 174.08,101.43 174.2,101.55 177.38,101.55
GND on TOP (solid shape): 205.57,54.08 205.57,52.07 205.47,51.97 202.76,51.97 202.6,52.13 202.6,54 202.83,54.23 205.42,54.23
GND on TOP (solid shape): 220.71,62.08 220.71,61.04 220.43,60.76 218.45,60.76 218.38,60.84 218.38,61.95 218.58,62.16 220.64,62.16
GND on TOP (solid shape): 231.46,100.24 231.46,99.03 231.24,98.81 230.22,98.81 229.95,99.08 229.95,100.2 230.1,100.34 231.36,100.34
GND on TOP (solid shape): 288.78,42.93 288.78,42.04 288.37,42.04 288.37,41.51 288.14,41.51 288.14,42.04 287.72,42.04 287.72,42.98 287.79,43.06 288.66,43.06
GND on TOP (solid shape): 92.42,85.84 92.42,85.03 92.32,84.93 91.68,84.93 91.1,85.52 91.1,85.91 91.2,86.02 92.24,86.02
GND on TOP (solid shape): 186.88,32.8 187.64,32.8 187.73,32.72 187.73,29.76 187.24,29.28 181.7,29.28 181.58,29.4 181.58,32.84 181.79,33.05 186.63,33.05
GND on TOP (solid shape): 75.35,51.26 75.35,47.37 75.22,47.25 74.51,47.25 74.23,47.52 73.47,47.52 73.32,47.67 73.32,51.35 73.42,51.44 75.17,51.44
GND on TOP (solid shape): 78.9,91.95 78.9,90.81 78.35,90.25 75.17,90.25 75.07,90.35 75.07,92.05 75.17,92.16 78.7,92.16
GND on TOP (solid shape): 86.65,54.64 86.65,52.2 85.51,51.06 83.2,51.06 82.94,51.31 82.94,53.12 82.54,53.52 81.7,53.52 81.47,53.75 81.47,54.89 81.55,54.97 86.32,54.97
GND on TOP (solid shape): 101.45,43.31 101.45,42.85 101.58,42.72 102.58,42.72 102.68,42.63 102.68,42.49 102.49,42.3 99.94,42.3 99.91,42.33 99.91,43.33 99.93,43.35 101.41,43.35
GND on TOP (solid shape): 219.06,71.66 219.06,70.64 218.91,70.49 217.16,70.49 216.95,70.69 216.95,71.38 217.33,71.76 218.96,71.76
GND on TOP (solid shape): 246.21,23.78 246.21,22.84 245.99,22.61 244.56,22.61 244.23,22.28 243.37,22.28 243.27,22.38 243.27,22.56 244.21,23.5 244.21,23.85 244.33,23.98 246.01,23.98
GND on TOP (solid shape): 226.47,19.53 226.47,17.96 226.38,17.88 225.67,17.88 225.59,17.89 225.51,17.88 225.41,17.88 225.3,17.99 225.3,19.34 225.55,19.59 226.42,19.59
GND on TOP (solid shape): 228.51,49.25 228.51,46.28 228.43,46.21 227.74,46.21 227.51,46.44 227.51,48.13 226.68,48.96 226.68,49.69 226.73,49.74 228.03,49.74
GND on TOP (solid shape): 244.46,34.04 244.46,33.48 244.33,33.35 244.06,33.35 243.9,33.51 243.9,33.68 243.78,33.81 243.22,33.81 243.17,33.86 243.17,34.27 243.24,34.34 244.16,34.34
GND on TOP (solid shape): 70.57,77.25 83.7,77.25 83.98,76.97 83.98,75.85 83.78,75.65 75.96,75.65 75.86,75.75 74.25,75.75 74.24,75.74 70.57,75.74 70.46,75.85 70.46,77.18 70.55,77.27
GND on TOP (solid shape): 120.94,87.84 120.94,87 120.69,86.74 119.42,86.74 118.71,86.03 115.66,86.03 115.23,86.47 115.23,87.38 115.88,88.03 115.97,88.03 116.05,88.04 120.74,88.04
GND on TOP (solid shape): 200.93,59.08 200.93,57.38 200.77,57.23 198.64,57.23 198.56,57.31 198.56,58.54 198.61,58.66 198.61,58.8 199.12,59.31 200.7,59.31
GND on TOP (solid shape): 225.08,57.43 225.08,55.35 224.8,55.07 223.63,55.07 223.58,55.12 223.58,55.3 223.61,55.33 223.61,55.81 223.02,56.39 223.02,57.15 223.38,57.51 225,57.51
GND on TOP (solid shape): 84.54,88.8 84.54,88.12 84.47,88.05 83.94,88.05 83.79,87.9 83.79,87.55 83.63,87.38 83.35,87.38 83.15,87.59 83.15,89.08 83.3,89.23 84.11,89.23
GND on TOP (solid shape): 202.68,72.29 202.68,69.9 202.42,69.65 199.81,69.65 199.63,69.83 199.63,71.56 199.68,71.61 201.74,71.61 201.97,71.84 201.97,72.32 202.04,72.39 202.58,72.39
GND on TOP (solid shape): 211.72,58.88 211.72,57.61 211.77,57.56 211.77,56.78 211.44,56.45 207.29,56.45 206.51,57.23 206.51,58.8 206.74,59.03 211.57,59.03
GND on TOP (solid shape): 92.26,76.81 92.26,72.88 92.06,72.67 92.06,69.47 91.81,69.22 90.03,69.22 89.95,69.3 89.95,70.92 89.72,71.15 89.72,76.58 90.16,77.02 92.06,77.02
GND on TOP (solid shape): 93.33,56.14 93.33,55.71 93.36,55.68 93.36,53.52 93.31,53.47 91.4,53.47 91.2,53.67 91.2,56.11 91.25,56.16 92.04,56.16 92.09,56.21 92.09,56.82 92.21,56.95 92.52,56.95
GND on TOP (solid shape): 191.5,69.08 191.5,65.71 191.33,65.53 188.03,65.53 188.02,65.54 187.22,65.54 187.21,65.55 186.69,65.55 186.64,65.6 186.64,65.74 186.73,65.82 187.69,65.82 187.86,65.99 187.86,69.16 187.92,69.22 191.36,69.22
GND on TOP (solid shape): 63.08,90.63 63.08,87.28 62.9,87.1 60.87,87.1 60.64,86.87 60.64,86.29 60.57,86.21 60.01,86.21 59.96,86.26 59.96,90.05 59.8,90.2 59.07,90.2 58.97,90.3 58.97,90.89 59.04,90.96 62.75,90.96
GND on TOP (solid shape): 158.3,64.64 158.3,64.17 158.36,64.12 158.36,61.09 158.36,61.09 158.36,60.87 158.66,60.57 158.66,60.37 158.59,60.29 157.29,60.29 157.14,60.44 157.14,60.6 157.27,60.72 157.5,60.72 157.65,60.87 157.65,64.71 157.67,64.74 158.21,64.74
GND on TOP (solid shape): 257.47,42.28 257.47,42.07 257.47,41.63 257.54,41.56 257.54,39.55 257.42,39.42 257.42,38.92 257.19,38.69 256.81,38.69 256.58,38.92 256.58,42.23 256.73,42.38 257.37,42.38
GND on TOP (solid shape): 271.46,25.43 272.15,25.43 272.4,25.18 272.4,24.64 271.66,23.91 270.55,23.91 270.16,24.3 270.08,24.4 269.97,24.48 269.92,24.53 269.44,24.53 269.28,24.69 269.28,25.81 269.38,25.91 270.98,25.91
GND on TOP (solid shape): 276.03,18.09 276.03,16.92 276.03,16.87 275.07,15.9 274.69,15.9 274.48,16.11 274.48,16.69 274.71,16.92 275.3,16.92 275.42,17.05 275.45,17.05 275.45,17.07 275.5,17.12 275.5,18.11 275.55,18.16 275.96,18.16
GND on TOP (solid shape): 147.87,63.22 147.87,60.89 148.02,60.74 148.37,60.74 148.5,60.61 148.5,60.35 148.37,60.23 147.36,60.23 147.15,60.43 147.15,61.73 146.93,61.95 144.46,61.95 144.31,62.11 144.31,62.46 144.49,62.64 144.92,62.64 145.45,63.17 146.77,63.17 146.93,63.33 147.76,63.33
GND on TOP (solid shape): 227.27,64.06 227.77,64.06 227.9,63.94 227.9,62.53 227.55,62.17 227.55,61.78 227.17,61.4 226.43,61.4 226.13,61.7 225.64,61.7 225.34,61.4 222.44,61.4 222.31,61.52 222.31,62.59 222.49,62.77 224.75,62.77 225.13,63.15 225.13,64.34 225.34,64.55 226.78,64.55
GND on TOP (solid shape): 71.46,95.58 71.46,93.88 72,93.35 72,92.23 71.74,91.98 71.33,91.98 71.06,92.26 71.06,92.89 70.88,93.07 70.33,93.07 69.86,93.54 69.86,95.33 69.86,95.34 69.89,95.47 69.87,95.6 69.87,95.66 70.02,95.81 71.23,95.81
GND on TOP (solid shape): 148.4,70.92 148.4,70.57 147.69,69.85 147.69,68.44 147.69,67.75 147.41,67.47 147.41,65.4 147.36,65.35 147.36,63.78 147.2,63.62 146.46,63.62 146.42,63.66 146.42,70.29 146.52,70.39 146.77,70.39 146.85,70.46 146.85,70.9 146.93,70.97 148.35,70.97
GND on TOP (solid shape): 62.17,81.45 62.17,79.15 61.94,78.92 61.02,78.92 60.41,78.31 58.59,78.31 58.39,78.11 54.39,78.11 54.24,78.26 54.24,80.95 54.9,81.61 58.28,81.61 58.43,81.58 58.59,81.61 59.01,81.61 59.33,81.93 61.69,81.93
GND on TOP (solid shape): 166.34,102.38 166.34,102.32 166.33,102.31 166.26,102.08 166.34,101.86 166.34,100.7 166.23,100.6 165.8,100.6 165.65,100.75 165.65,101.49 165.47,101.67 164.94,101.67 164.84,101.77 164.84,102.51 164.94,102.61 166.11,102.61
GND on TOP (solid shape): 243.14,78.68 243.14,77.94 242.87,77.68 242.48,77.68 242.33,77.52 242.33,77.5 242.28,77.45 242.28,76.89 242.2,76.81 241.74,76.81 241.67,76.89 241.67,78.37 241.83,78.5 241.9,78.69 241.96,78.76 243.07,78.76
GND on TOP (solid shape): 270.5,32.69 270.5,32.16 270.65,32.01 271.49,32.01 271.54,32.06 271.56,32.06 271.56,32.08 271.77,32.29 271.84,32.29 272.22,32.29 272.38,32.13 272.38,31.64 271.55,31.64 271.16,31.25 270.62,31.25 270.45,31.08 270.45,30.37 270.37,30.3 270,30.3 269.91,30.38 269.91,32.8 270.39,32.8
GND on TOP (solid shape): 268.82,70.84 268.82,68.66 268.69,68.53 268.18,68.53 268.18,69.17 268.06,69.3 267.17,69.3 267.04,69.17 266.77,69.17 266.79,69.33 266.74,69.49 266.74,69.6 266.64,69.7 266.41,69.7 266.15,69.96 266.15,70.9 266.54,71.29 268.37,71.29
GND on TOP (solid shape): 77.86,60.79 77.86,59.24 77.96,59.14 78.29,59.14 78.45,58.98 78.45,58.55 78.19,58.3 77.2,58.3 77.05,58.45 77.05,59.87 76.85,60.07 76.44,60.07 76.34,60.18 76.34,60.39 76.34,60.4 76.36,60.53 76.35,60.65 76.34,60.68 76.57,60.91 77.74,60.91
GND on TOP (solid shape): 224.76,46.51 224.76,44.96 224.54,44.73 221.75,44.73 221.65,44.83 221.65,45.39 221.88,45.6 221.87,45.9 221.88,46.04 221.83,46.17 221.83,46.61 221.91,46.69 224.58,46.69
GND on TOP (solid shape): 225.44,73.28 225.44,70.06 224.73,69.35 223.79,69.35 223.18,69.96 221.14,69.96 221.13,69.97 220.47,69.97 220.28,70.16 220.28,71.58 220.59,71.89 223.28,71.89 223.4,72.01 223.59,72.02 223.67,72.04 223.79,72.04 223.99,72.24 223.99,73.41 224.09,73.51 225.21,73.51
GND on TOP (solid shape): 108.55,83.93 108.55,82.93 108.47,82.86 107.86,82.86 107.81,82.91 107.81,83.34 107.61,83.54 106.87,83.54 106.82,83.54 106.59,83.54 106.49,83.44 106.49,83.3 106.46,83.16 106.49,83.02 106.49,82.48 106.41,82.4 102.27,82.4 102.09,82.58 102.09,84 102.25,84.15 108.32,84.15
GND on TOP (solid shape): 277,41.48 279.98,41.48 280.01,41.42 279.97,41.07 280.23,40.83 280.24,40.83 280.24,40.35 280.17,40.29 277.02,40.29 276.77,40.03 276.39,40.03 276.36,40.06 276.36,40.67 276.16,40.87 275.32,40.87 275.2,41 275.2,41.58 275.25,41.63 276.85,41.63
GND on TOP (solid shape): 154.98,73.65 154.98,72.76 154.35,72.13 154.35,71.01 154.5,70.86 154.8,70.86 154.96,70.7 154.96,69.89 154.83,69.76 154.42,69.76 154.35,69.69 154.35,69.13 154.47,69 154.83,69 154.98,68.85 154.98,68.7 154.8,68.52 154.45,68.52 154.35,68.42 154.35,67.96 154.52,67.78 155.39,67.78 155.46,67.71 155.46,63.85 155.36,63.75 154.06,63.75 153.94,63.87 153.94,67.68 153.64,67.98 153.64,72.56 153.66,72.58 154.24,72.58 154.47,72.81 154.47,73.6 154.58,73.7 154.93,73.7
GND on TOP (solid shape): 155.59,62.92 155.59,62.61 155.7,62.5 155.79,62.41 155.79,60.99 155.68,60.88 155.66,60.88 155.57,60.89 155.48,60.87 155.47,60.86 155.38,60.86 155.08,60.56 155.08,59.16 154.93,59.01 154.55,59.01 154.29,59.26 154.29,61.68 154.34,61.73 154.93,61.73 155.18,61.98 155.18,62.26 154.92,62.52 154.92,62.95 155.12,63.15 155.36,63.15
GND on TOP (solid shape): 44.59,89.92 44.59,88.78 44.89,88.47 46.77,88.47 47,88.24 47,85.22 46.04,84.26 41.54,84.26 40.07,82.78 40.04,82.78 39.99,82.73 39.36,82.73 39.25,82.83 39.25,83.47 39.6,83.81 39.6,85.17 39.32,85.45 38.52,85.45 38.39,85.58 38.39,86.26 38.72,86.59 41.11,86.59 41.21,86.49 41.21,86.26 41.77,85.7 44.46,85.7 44.47,85.72 44.49,85.72 44.49,85.73 44.64,85.88 44.64,87.56 44.46,87.74 43.8,87.74 43.7,87.84 43.7,88.26 43.84,88.4 43.84,89.91 43.95,90.02 44.49,90.02
GND on TOP (solid shape): 153.25,74.46 153.25,74.13 152.9,73.78 152.9,73.04 151.98,72.13 151.98,70.86 152.09,70.76 152.47,70.76 152.57,70.65 152.57,69.76 152.47,69.66 152.04,69.66 151.98,69.61 151.98,69.05 152.16,68.88 152.47,68.88 152.57,68.77 152.57,68.52 152.44,68.39 152.11,68.39 151.98,68.26 151.98,63.82 151.83,63.67 150.53,63.67 150.41,63.8 150.41,67.54 150.62,67.76 151.15,67.76 151.35,67.96 151.35,72.51 151.4,72.56 151.83,72.56 152.47,73.19 152.47,74.29 152.82,74.64 153.08,74.64
GND on TOP (solid shape): 180.62,63.23 180.62,62.27 180.49,62.15 178.36,62.15 177.9,61.69 177.08,61.69 176.95,61.55 176.85,61.54 176.75,61.5 176.74,61.49 176.72,61.49 176.66,61.43 176.54,61.43 176.04,61.93 176.04,62.83 176.36,63.15 177.58,63.15 177.73,63.3 177.8,63.33 177.87,63.3 178.14,63.21 178.4,63.33 178.42,63.35 178.44,63.35 180.49,63.35
GND on TOP (solid shape): 276.46,50.39 276.65,50.28 276.86,50.29 277.18,49.97 277.18,49.03 277.12,48.97 276.11,48.97 276.06,49.02 275.55,49.02 275.4,48.87 275.4,47.45 275.3,47.35 275.3,46.51 275.37,46.44 276.21,46.44 276.36,46.28 276.36,45.65 276.29,45.57 274.18,45.57 273.98,45.77 273.98,46.31 274.08,46.41 274.94,46.41 275.07,46.54 275.07,48.16 274.92,48.31 274.92,49.51 274.76,49.66 274.2,49.66 273.96,49.41 273.56,49.41 273.52,49.46 273.52,50.19 274.01,50.69 276.17,50.69
GND on TOP (solid shape): 270.32,14.94 270.36,14.92 270.5,14.79 270.5,14.41 270.19,14.1 270.19,10.88 270.27,10.8 270.27,9.45 270.12,9.3 270.12,7.85 270.22,7.75 270.22,7.27 269.76,6.81 269.38,6.81 269.3,6.88 269.25,6.95 269.18,7.01 269.18,7.22 269.3,7.34 269.3,7.85 269.31,7.86 269.31,8.85 269.3,8.86 269.3,9.38 269.12,9.55 269.12,10.72 269.2,10.8 269.2,14.51 269.27,14.58 269.74,14.62 270.06,14.96 270.29,14.96
GND on TOP (solid shape): 231.26,98.49 231.26,98.1 231.37,97.99 231.37,95.11 231.34,95.1 231.13,95 230.96,94.84 230.41,94.84 230.05,95.21 230.05,95.21 229.97,95.32 229.87,95.4 229.86,95.4 229.8,95.46 229.8,97.92 229.88,98 229.93,98 229.95,98 230.14,97.95 230.33,98 230.34,98 230.38,98 230.51,98.14 230.52,98.33 230.51,98.39 230.51,98.53 230.59,98.61 231.14,98.61
GND on TOP (solid shape): 217,31.69 217,29.82 217.11,29.71 217.84,29.71 218.03,29.91 218.09,29.91 218.09,29.97 218.27,30.14 219.28,30.14 219.71,30.57 219.73,30.58 219.88,30.61 220.01,30.7 220.08,30.78 220.89,30.78 221.01,30.66 221.01,30.47 220.91,30.37 220.33,30.37 219.59,29.63 218.35,29.63 218.35,29.62 218.07,29.34 218.07,29.16 217.97,29.07 217.56,29.07 217.37,28.88 217.37,28.31 217.88,27.81 221.18,27.81 221.23,27.85 221.69,27.85 221.88,27.66 221.88,27.36 221.7,27.18 221.46,27.18 221.42,27.22 217.65,27.22 215.86,29.01 215.86,31.64 215.98,31.76 216.93,31.76
GND on TOP (solid shape): 259.98,19.92 261.58,19.92 261.99,19.51 261.99,18.67 261.98,18.67 261.98,17.77 261.81,17.59 261.79,17.58 261.76,17.58 261.66,17.58 261.55,17.55 261.54,17.54 260.58,17.54 260.53,17.59 260.53,17.98 260.54,18.06 260.53,18.14 260.53,18.3 260.37,18.47 260.37,18.97 260.21,19.13 260.15,19.21 260.07,19.27 259.96,19.38 259.82,19.38 259.73,19.39 259.64,19.38 259.45,19.38 259.35,19.49 259.35,19.94 259.45,20.04 259.85,20.04
GND on TOP (solid shape): 141.24,68.37 141.24,68.01 141.39,67.86 141.98,67.86 142.08,67.96 142.08,68.39 142.15,68.47 142.46,68.47 142.56,68.37 142.56,67.96 142.64,67.88 143.25,67.88 143.37,68.01 143.37,68.32 143.5,68.44 143.73,68.44 143.86,68.32 143.86,67.99 144.01,67.83 144.52,67.83 144.67,67.99 144.67,68.34 144.77,68.44 145.05,68.44 145.15,68.34 145.15,67.99 145.05,67.88 145.05,66.89 144.95,66.79 138.95,66.79 138.85,66.89 138.85,67.86 138.93,67.94 138.97,67.94 138.98,67.93 139.13,67.9 139.27,67.93 139.28,67.94 139.39,67.94 139.56,68.11 139.56,68.34 139.67,68.44 139.94,68.44 140.05,68.34 140.05,68.04 140.2,67.88 140.61,67.88 140.76,68.04 140.76,68.37 140.86,68.47 141.14,68.47
GND on TOP (solid shape): 304.05,49.27 304.05,48.38 302.7,48.13 304.05,47.88 304.05,46.37 303.93,46.24 301.26,46.24 301.13,46.37 301.13,49.93 301.9,50.69 302.64,50.69
GND on TOP (solid shape): 142.48,65.48 142.48,65.08 142.56,65 143.17,65 143.3,65.13 143.3,65.43 143.42,65.56 143.65,65.56 143.78,65.43 143.78,65.1 143.93,64.95 144.22,64.95 144.49,65.22 144.49,65.47 144.58,65.56 144.87,65.56 144.98,65.45 144.98,65.01 144.97,65 144.97,64.01 144.87,63.91 138.88,63.91 138.78,64.01 138.78,64.98 138.85,65.05 139.03,65.05 139.03,65.05 139.15,65.03 139.27,65.05 139.31,65.05 139.39,65.13 139.42,65.16 139.49,65.23 139.49,65.46 139.59,65.56 139.87,65.56 139.97,65.46 139.97,65.15 140.12,65 140.53,65 140.58,65.06 140.59,65.06 140.76,65.24 140.75,65.49 140.75,65.55 140.78,65.59 141.2,65.59 141.27,65.52 141.27,65.12 141.41,64.98 141.9,64.98 142,65.08 142,65.51 142.1,65.61 142.36,65.61
GND on TOP (solid shape): 270.78,38.93 271.77,38.93 271.77,38.93 272.07,38.93 272.13,38.99 272.2,38.99 272.24,39.03 272.29,39.08 272.34,39.11 272.55,39.11 272.62,39.08 272.65,39 272.68,38.84 272.79,38.69 272.8,38.67 272.8,37.69 272.63,37.52 272.13,37.52 271.64,38.01 270.32,38.01 270,38.34 270,38.98 269.34,39.63 269.33,39.65 269.33,39.67 268.98,40.35 268.23,40.24 268.19,40.23 268.16,40.24 267.93,40.47 267.93,41.08 268.01,41.15 268.56,41.15
GND on TOP (solid shape): outline of 95 points within 95.95,52.26 106.42,67.55
GND on TOP (solid shape): outline of 96 points within 144.23,42.19 146.65,46.79
GND on TOP (solid shape): 149.66,72.53 149.66,71.58 149.62,71.54 149.62,71.03 149.8,70.86 150.1,70.86 150.27,70.7 150.27,70.3 150.28,70.28 150.28,70.19 150.27,70.17 150.27,69.75 150.19,69.67 149.83,69.66 149.76,69.62 149.71,69.55 149.69,69.52 149.69,69.45 149.69,69.14 149.69,69.02 149.82,68.89 150.07,68.89 150.19,68.77 150.15,68.58 149.96,68.51 149.92,68.52 149.86,68.51 149.8,68.51 149.69,68.41 149.69,68.3 149.67,68.27 149.67,68.16 149.63,68.12 149.63,68.04 149.62,68 149.58,67.99 148.74,67.99 148.5,67.75 148.5,63.77 148.35,63.62 147.59,63.62 147.53,63.67 147.53,66.41 147.57,66.49 147.66,66.51 148.05,66.68 147.95,67.09 147.81,67.23 147.81,67.49 147.99,67.67 147.99,69.65 148.88,70.54 148.88,71.45 149.01,71.58 149.01,72.52 149.08,72.6 149.59,72.6
GND on TOP (solid shape): 216.25,34.79 217.8,34.79 217.9,34.7 217.9,34.06 217.83,33.99 217.12,33.99 216.4,33.28 214.17,33.28 214.09,33.32 214.07,33.4 214.08,33.46 214.08,34.04 213.92,34.3 213.62,34.25 213.55,34.23 213.48,34.25 213.18,34.3 213.02,34.04 213.02,33.46 213.03,33.4 213.01,33.32 212.93,33.28 212.67,33.28 212.59,33.32 212.57,33.4 212.58,33.46 212.58,34.04 212.3,34.32 212.02,34.04 212.02,33.46 212.03,33.4 212.01,33.32 211.93,33.28 211.7,33.28 211.62,33.35 211.62,34.2 212.04,34.62 215.76,34.62 215.94,34.8 216.24,34.8
GND on TOP (solid shape): 156.57,71.74 156.84,71.81 156.93,71.54 156.91,71.51 156.91,71.37 156.96,71.32 156.96,71.31 157.01,71.26 157.03,71.25 157.49,71.25 157.53,71.21 157.85,71.21 157.99,71.35 157.99,71.48 157.96,71.52 158.13,71.82 158.33,71.53 158.32,71.5 158.32,71.35 158.45,71.21 158.55,71.21 158.58,71.2 158.6,71.16 158.6,70.51 158.58,70.49 158.45,70.49 158.37,70.4 158.27,70.4 158.27,70.3 158.25,70.29 158.25,69.95 158.13,69.83 157.93,69.83 157.9,69.79 157.75,69.79 157.62,69.66 157.62,69.44 157.61,69.4 157.57,69.38 157.01,69.38 157,69.4 157,69.64 156.99,69.65 156.99,69.79 156.66,70.12 156.65,70.15 156.65,70.16 156.59,70.44 156.33,70.57 156.26,70.6 156.23,70.67 156.23,71.21 156.44,71.21 156.58,71.35 156.58,71.51 156.56,71.54 156.54,71.62 156.55,71.7
GND on TOP (solid shape): outline of 134 points within 156.22,66.01 161.86,69.92
GND on TOP (solid shape): outline of 131 points within 260.21,11.42 265.04,13.95
GND on TOP (solid shape): 156.22,48.7 156.22,48.45 156.22,48.42 156.2,48.39 156.17,48.36 156.14,48.35 156.11,48.37 155.68,48.46 155.45,48.09 155.47,47.94 155.55,47.81 155.57,47.76 155.57,47.7 155.54,47.67 155.51,47.62 155.57,47.13 156.06,47.11 156.12,47.13 156.19,47.1 156.21,47.07 156.22,47.03 156.22,46.6 156.21,46.55 156.18,46.52 156.12,46.5 156.06,46.52 155.46,46.21 156.06,45.89 156.13,45.91 156.19,45.89 156.21,45.85 156.22,45.81 156.22,45.28 156.2,45.22 156.11,45.18 156.06,45.2 155.46,44.89 156.06,44.57 156.11,44.59 156.2,44.55 156.22,44.49 156.22,41.61 155.94,41.33 154.88,41.33 154.62,41.59 154.62,48.09 154.8,48.26 155.49,48.95 155.97,48.95
GND on TOP (solid shape): outline of 81 points within 164.6,71.1 169.59,74.41
GND on TOP (solid shape): outline of 346 points within 0.2,91.9 59.32,112.3
GND on TOP (solid shape): outline of 322 points within 139.67,69.66 143.58,75.58
GND on TOP (solid shape): outline of 1152 points within 4.48,0.2 305.8,80.15
GND on TOP (solid shape): outline of 1626 points within 150.05,9.9 182.56,23.05
GND on TOP (solid shape): outline of 1658 points within 78.32,11.99 100.09,18.88
GND on TOP (solid shape): outline of 1801 points within 120.39,10.11 142.81,19.75
GND on TOP (solid shape): outline of 2111 points within 199.68,10.09 226.25,19.97
GND on TOP (solid shape): outline of 2401 points within 69.61,18.2 306.1,112.9
GND on BOTTOM (solid shape): 102.42,96.7 102.42,96.17 102.2,95.94 99.73,95.94 99.53,96.14 99.53,96.73 99.73,96.93 102.2,96.93
GND on BOTTOM (solid shape): 114.54,55.03 114.54,50.51 114.44,50.41 111.5,50.41 111.31,50.6 111.31,54.72 112.36,55.77 113.8,55.77
GND on BOTTOM (solid shape): 207.99,73.11 207.99,68.46 207.91,68.38 205.88,68.38 205.8,68.46 205.8,72.81 206.3,73.31 207.78,73.31
GND on BOTTOM (solid shape): 284.77,84 284.77,80.27 284.69,80.19 284.03,80.19 283.65,80.57 283.65,83.57 284.19,84.1 284.67,84.1
GND on BOTTOM (solid shape): 120.59,87.38 120.59,86.26 120.41,86.08 115.86,86.08 115.62,86.33 115.62,87.04 116.55,87.96 120,87.96
GND on BOTTOM (solid shape): 123.76,73.41 123.76,72.32 123.63,72.19 123.01,72.19 123.01,72.18 122.52,72.67 122.52,73.13 122.9,73.51 123.66,73.51
GND on BOTTOM (solid shape): 217.68,91.65 217.68,90.54 217.61,90.46 216.64,90.46 216.59,90.51 216.59,92.27 216.65,92.34 216.99,92.34
GND on BOTTOM (solid shape): 249.19,10.01 249.19,7.07 248.96,6.84 246.65,6.84 246.44,7.04 246.44,10.16 246.7,10.42 248.78,10.42
GND on BOTTOM (solid shape): 97.73,90.96 97.73,90.44 97.56,90.27 97.56,89.64 96.62,88.7 95.46,88.7 94.86,89.31 94.86,90.73 95.18,91.05 97.63,91.05
GND on BOTTOM (solid shape): 148.73,29.87 148.73,25.78 148.2,25.25 143.57,25.25 143.01,25.81 143.01,29.42 143.95,30.36 148.25,30.36
GND on BOTTOM (solid shape): 216.08,104.69 216.08,103.37 215.97,103.25 214.91,103.25 214.76,103.4 214.76,104.58 214.77,104.58 214.77,104.77 214.86,104.86 215.9,104.86
GND on BOTTOM (solid shape): 22.31,87.46 22.31,86.19 22.06,85.93 20.79,85.93 20.66,86.06 20.66,87.33 20.79,87.46 21.5,87.46 21.75,87.71 22.06,87.71
GND on BOTTOM (solid shape): 64.22,86.8 64.22,86.24 64.02,86.03 62.96,86.03 62.94,86.05 62.89,86.05 62.78,86.16 62.78,86.85 62.88,86.95 64.07,86.95
GND on BOTTOM (solid shape): 162.85,29.87 162.85,25.63 162.84,25.62 162.84,25.06 162.47,24.69 159.04,24.69 158.05,25.68 158.05,29.95 158.43,30.33 162.39,30.33
GND on BOTTOM (solid shape): 29.04,81.26 29.04,80.65 28.64,80.24 28.64,79.63 28.56,79.56 26.4,79.56 26.2,79.76 26.2,80.09 26.3,80.19 27.11,80.19 28.26,81.33 28.97,81.33
GND on BOTTOM (solid shape): 92.19,53.17 92.19,51.82 91.6,51.24 91.43,51.24 91.3,51.36 91.3,51.59 91.96,52.25 91.96,53.17 92.01,53.22 92.14,53.22
