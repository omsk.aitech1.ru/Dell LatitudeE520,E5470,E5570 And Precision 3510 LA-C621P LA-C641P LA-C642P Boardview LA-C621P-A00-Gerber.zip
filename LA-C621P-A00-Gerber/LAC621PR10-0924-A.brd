# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.0V_VCCSTG_C:
  vias: v3(164.07,92.8)
+1.0V_VCCSTG_R: length 17.1
  TOP w0.254: 161.52,75.27 161.52,74.56 161.53,74.55 161.53,73.84 161.89,73.49 161.89,73.49 v2(161.99,73.39)
  TOP w0.508: v3(167.22,85.82) 167.05,85.64 165.91,85.64 RC143.1 164.93,84.66 164.93,84.28 164.17,83.52 162.65,83.52 162.22,83.09 162.22,77.55 161.52,76.86 161.52,75.27
  BOTTOM w0.254: v2(161.99,73.39) 162.01,73.39 UC1.G20
+1.0V_VMM_VDD: length 7.7
  TOP w0.254: UV8.E9 216.51,90.44 v2(216.18,90.77) ; UV8.C9 215.21,90.44 v2(214.88,90.77) ; UV8.E8 216.51,89.79 v2(216.18,90.12) ; UV8.C8 215.21,89.79 v2(214.88,90.12) ; UV8.G3 v2(218.13,86.22) ; v2(216.83,92.72) 217.16,92.39 UV8.F12 UV8.G12 ; UV8.E7 v2(216.18,88.82) ; UV8.H9 v2(218.78,90.77) ; UV8.D3 v2(215.53,86.22) ; UV8.H7 v2(218.78,88.82) ; UV8.H6 v2(218.78,88.17) ; UV8.E6 v2(216.18,88.17) ; UV8.H8 v2(218.78,90.12) ; UV8.E3 v2(216.18,86.22)
  BOTTOM w0.381: CV83.1 216.87,92.75 v2(216.83,92.72)
  vias: v3(217.47,89.22)
+1.0V_VMM_VDDTX: length 6.7
  TOP w0.254: UV8.K8 v2(220.08,90.12) 219.76,90.44 UV8.K9 v2(220.08,90.77) 219.76,91.09 UV8.K10 ; v2(218.78,86.22) 219.1,85.89 UV8.J2 ; v2(219.43,91.42) 219.11,91.09 UV8.J10 ; UV8.F3 v2(216.83,86.22) ; UV8.E12 216.51,92.39 v2(216.18,92.07) 215.86,92.39 UV8.D12 ; UV8.C6 v2(214.88,88.82) UV8.C7
  BOTTOM w0.305: CV91.1 216.11,92.13 v2(216.18,92.07)
  BOTTOM w0.508: v2(214.88,88.82) 214.87,88.81 214.34,88.81 CV92.1
  vias: v2(218.78,86.87) v3(219.09,85.74)
+1.0VO_DSW: length 8
  TOP w0.254: v2(173.68,61.06) 173.74,61.12 v3(173.74,62.27) 172.17,62.27 171.45,61.55 168.3,61.55 CC204.1
  BOTTOM w0.254: UC1.AL1 173.67,61.05 v2(173.68,61.06)
+1.0VS_VCCIO: length 266.3
  TOP w0.254: UV8.E5 v2(216.18,87.52) ; UV8.J3 v2(219.43,86.22)
  TOP w0.457: v2(91.73,39.73) 91.73,39.3 RC132.1
  TOP w0.508: RC2.1 144.18,71.28 v2(144.64,70.82) ; v2(244.44,56.8) 245.25,57.61 250.43,57.61 251.63,56.42 251.65,56.42 253.55,54.52 253.55,54.03 254.1,53.47 255.92,53.47 256,53.39 RE59.2 ; v2(230.62,71.94) 230.62,72.92 229.24,74.3 222.76,74.3 222.33,74.73 v3(217.9,74.73) v2(209.84,74.73)
  IN1 w0.508: v2(147.75,66.83) 147.23,66.83 146.49,67.57 146.49,69.98 145.91,70.57 144.89,70.57 v2(144.64,70.82)
  IN2 w0.254: v2(149.21,60.51) 149.66,60.05 149.66,57.81 149.5,57.65 149.5,56.73 149.93,56.29 149.93,56.3 150.6,56.98 150.6,58.8 150.58,58.83 150.58,60.05 v2(150.12,60.51)
  IN2 w0.508: v2(91.73,39.73) 92.04,39.42 97.98,39.42 98.41,38.99 101.69,38.99 106.67,43.97 147.1,43.97 151.09,47.96 151.09,54.48 149.93,55.64 149.93,56.29 ; v2(244.44,56.8) 244.45,56.82 244.45,57.47 239.99,61.93 239.99,62.18 237.45,64.72 235.42,64.72 234.66,65.49 234.66,66.94 234.02,67.57 234.02,68.15 231.86,70.31 231.86,71.3 231.23,71.94 v2(230.62,71.94)
  IN3 w0.508: v2(219.43,86.22) 219.39,86.18 219.39,84.48 219.17,84.26 217.79,84.26 217.43,84.62 217.43,87.22 217.14,87.52 v2(216.18,87.52)
  IN3 w1.016: 224.93,92.69 223.91,91.67 223.91,87.05 222.87,86.01 222.87,81.72 221.14,79.99 215.58,79.99 210.32,74.73 v2(209.84,74.73) 209.13,74.73 208.07,75.79 198.36,75.79 197.68,75.12 197.68,69.7 199.45,67.92 199.45,62.87 200.7,61.62 202.14,61.62 203.77,60 203.77,57 205.62,55.15 205.62,53.39 204.91,52.68 204.91,51.22
  IN4 w0.508: v2(132.06,87.97) 134.28,85.75 134.28,84.83 137.8,81.31 138.42,81.31 139.52,80.21 139.52,79.7 140.88,78.34 141.03,78.34 141.39,77.98 141.39,77.48 141.39,77.29 142.45,76.24 143,76.24 143.01,76.24 143.49,76.24 143.49,76.24 143.53,76.24 144.18,75.58
  BOTTOM w0.203: 156.06,61.46 UC1.AK30 ; UC1.AK30 156.44,61.84 ; UC1.AK30 156.06,62.22 ; UC1.AM28 156.91,60.9 v2(156.52,60.51) ; 156.98,61.46 UC1.AK28 ; UC1.AK28 156.6,61.84 ; UC1.AK28 156.98,62.22 ; UC1.AK28 157.36,61.84 ; UC1.AL30 156.52,61.75 ; UC1.AL30 156.52,60.99 ; UC1.AL30 156.14,61.37 ; UC1.AL30 156.9,61.37 ; v2(155.61,60.51) 156,60.9 UC1.AM30
  BOTTOM w0.254: UC1.AL42 v2(150.12,60.51) UC1.AM42 v2(149.21,60.51)
  BOTTOM w0.508: v2(219.43,86.22) 220.29,86.22 220.45,86.06 222.18,86.06 222.65,86.53 222.65,90.49 ; RE90.1 130.98,88.6 131.29,88.91 QE11.1 132.06,88.63 v2(132.06,87.97)
  vias: v2(149.06,62.89) v2(155.99,62.69) v2(156.58,62.7) v2(157.17,62.7) v2(195.67,57.07) v2(195.66,56.43) v2(196.18,57.38) v2(196.18,56.77) v2(196.18,56.14) v2(226.15,92.08) v2(226.15,92.69)
+1.2V_LDO: length 7.3
  TOP w0.203: CR13.1 259.55,43.64 259.55,43.11 260.02,42.64 UR2.10
  TOP w0.381: v2(259.03,43.3) 259.03,43.63 CR13.1
  IN3 w0.508: v2(258.96,39.63) 259.22,39.63 259.95,40.35 259.95,42.39 v2(259.03,43.3)
+1.2V_MEM: length 192.1
  TOP w0.381: CD30.1 77.43,10.79 UD1.5
  TOP w0.508: v2(217.62,10.38) 217.77,10.52 CD102.1 ; CD91.1 135.72,10.59 v2(135.61,10.48) ; RD22.1 v2(75.12,14.92)
  IN1 w0.457: v2(155.53,53.97) 155.83,54.26 157.57,54.26 158.69,53.14 160.21,53.14 160.65,53.58 v2(160.68,53.58)
  IN2 w0.508: v2(207.12,10.42) 207.81,11.1 216.78,11.1 217.5,10.38 v2(217.62,10.38) ; v2(78.32,10.62) 77.44,11.51 75.35,11.51 74.58,12.28 74.58,14.38 v2(75.12,14.92)
  IN3 w0.889: 223.7,20.17 224.11,19.76 234.07,19.76 236.13,21.83 236.13,24.69 ; 208.51,48.48 209.39,47.6 217.66,47.6
  IN4 w0.889: 234.93,25.68 234.81,25.68 233.06,27.44 233.06,33.4
  BOTTOM w0.152: UC1.BB41 150.57,54.03
  BOTTOM w0.178: v2(160.68,53.58) 160.53,53.74 160.53,54.92 UC1.BB23 ; UC1.BB51 144.46,53.97 v2(144.47,53.95) ; UC1.BB32 155.53,54.93 v2(155.53,53.97) ; UC1.BB47 146.91,53.96 v2(146.95,53.92)
  BOTTOM w0.254: UC1.AU42 149.5,57.65 v2(149.17,57.97) ; v2(159.26,57.95) 159.57,57.65 UC1.AU23 ; UC1.AU35 153.17,57.65 v2(152.86,57.95) ; 150.57,54.03 150.56,54.02 150.56,53.16 v2(150.48,53.09) ; UC1.AU28 156.82,57.65 v2(156.52,57.95)
  BOTTOM w0.305: 97.37,20.81 98.69,22.13 106.05,22.13 106.54,21.64 v2(106.54,21.42) 106.37,21.25 JDIMM1.111 ; 97.37,20.81 JDIMM1.75 ; 97.37,20.81 96.22,21.97 87.41,21.97 86.87,21.43 JDIMM1.33 ; JDIMM2.220 v2(217.62,10.38) ; v2(109.38,21.85) 109.43,21.85 109.43,21.77 109.37,21.7 JDIMM1.123 ; JDIMM1.199 130.37,21.63 v2(130.52,21.77) ; v2(193.61,21.64) 193.81,21.64 194.37,21.08 JDIMM2.135 ; v2(178.85,21.59) 178.9,21.59 179.37,21.12 JDIMM2.75 ; JDIMM2.154 v2(201.12,10.46) ; v2(91.99,10.49) 92.12,10.63 JDIMM1.54 ; v2(120.38,10.27) 120.38,10.57 120.62,10.81 JDIMM1.160 ; JDIMM2.112 v2(188.62,10.45) ; v2(118.96,10.27) 118.96,10.49 119.12,10.66 JDIMM1.154 ; JDIMM1.12 81.62,10.53 v2(81.63,10.52) ; v2(118.93,21.52) 118.87,21.46 JDIMM1.153 ; JDIMM2.178 v2(207.12,10.42) ; JDIMM2.199 212.37,20.93 212.69,21.24 v2(212.94,21.24) ; v2(196.02,21.7) 195.87,21.55 JDIMM2.141 ; JDIMM1.220 135.62,10.49 v2(135.61,10.48) ; JDIMM2.159 202.37,21.11 v2(201.74,21.75) ; JDIMM2.148 v2(199.62,10.47) ; JDIMM1.147 117.33,19.99 117.33,21.09 116.34,22.08 v2(115.58,22.08) ; v2(222.62,21.16) 222.87,20.9 JDIMM2.241 ; JDIMM2.129 v2(192.87,21.47) ; JDIMM2.54 v2(174.12,10.31) ; JDIMM2.111 188.37,20.96 188.89,21.47 189.19,21.47 v2(190,22.28) ; JDIMM1.241 140.87,21.02 140.55,21.34 v2(139.84,21.34) ; JDIMM2.12 v2(163.62,10.43) ; v2(107.13,22.01) 107.87,21.27 JDIMM1.117 ; JDIMM1.141 113.87,21.04 114.33,21.49 v2(115.18,21.49) ; v2(191.73,22.1) 191.37,21.75 JDIMM2.123 ; JDIMM1.163 121.37,21.59 120.79,22.18 v2(120.23,22.18) ; JDIMM2.163 203.37,20.92 204,21.54 v2(204,21.54) ; JDIMM1.135 112.37,21.47 v2(111.39,22.46) ; JDIMM1.148 117.62,10.87 118.02,10.48 v2(118.02,10.29) ; JDIMM1.178 125.12,10.3 v2(125.16,10.27) ; JDIMM1.136 112.62,10.45 v2(112.76,10.32) ; JDIMM1.124 v2(109.62,10.27) ; JDIMM2.160 v2(202.62,10.42) ; JDIMM1.142 v2(114.12,10.32) ; JDIMM2.33 v2(168.87,21.62) ; JDIMM1.112 v2(106.62,10.29) ; v2(119.87,21.67) 119.87,21.63 120.37,21.13 JDIMM1.159 ; v2(190.51,21.8) 189.87,21.16 JDIMM2.117 ; JDIMM2.124 v2(191.62,10.44) ; JDIMM2.153 200.87,21.95 201.28,22.36 v2(201.74,22.36) v2(201.74,22.97) ; JDIMM1.130 v2(111.12,10.3) ; JDIMM2.118 v2(190.12,10.49) ; JDIMM2.130 v2(193.12,10.42) ; v2(184.21,10.42) 184.62,10.83 JDIMM2.96 ; JDIMM2.147 199.37,21.54 v2(198.16,22.76) ; JDIMM1.96 v2(102.62,10.27) ; JDIMM1.118 v2(108.12,10.29) ; JDIMM2.142 v2(196.12,10.39) ; v2(110.87,22.04) JDIMM1.129 ; JDIMM2.136 v2(194.62,10.42)
  vias: v2(77.5,40.97) v2(77.6,42.21) v2(77.58,41.61) v2(78.09,40.95) v2(78.22,42.21) v2(78.16,41.62) v2(78.27,42.85) v2(78.75,41.57) v2(78.68,40.92) v2(78.8,42.22) v2(78.88,43.51) v2(78.91,42.93) v2(141.69,25.86) v2(141.69,25.23) v2(141.69,24.64) v2(142.33,25.86) v2(142.33,25.23) v2(142.33,24.64) v2(173.15,10.36) v2(189.55,22.71) v2(197.67,23.27) v2(201.74,23.68) v2(204.05,22.66) v2(208.42,50.02) v2(208.42,49.43) v2(218.1,48.54) v2(235.78,25.68) v2(236.36,25.68) v3(221.96,21.17)
+1.2V_MEM_CPUCLK: length 4.6
  TOP w0.381: v2(151.1,59.93) 151.1,60.44 150.41,61.13 CC297.1 CC194.1 RC231.1
  BOTTOM w0.152: v2(151.1,59.93) 151.1,60.38 UC1.AM40
+1.2V_MEN_P: length 80.5
  TOP w0.254: v2(91.68,58.47) 91.83,58.63 PC213.1
  IN1 w0.254: v2(71.51,47.65) 71.51,47.13 73.32,45.32 77.48,45.32 79.51,47.35 91.71,47.35 94.78,50.42 94.78,54.08 94.27,54.59 94.27,57.56 93.36,58.47 v2(91.68,58.47)
  IN1 w0.508: v2(72.12,47.63) 72.12,47.37 73.56,45.94 77.37,45.94 79.29,47.86 91.32,47.86 94.27,50.8 94.27,53.62 93.74,54.16 93.74,57.28 93.38,57.64 88.71,57.64 v2(88.68,57.61)
  BOTTOM w0.203: 93.64,57.03 93.64,56.72 93.28,56.37 PU201.5
  BOTTOM w0.254: 93.64,57.03 93.64,57.31 PR206.2 PC212.2 91.99,59.47 91.68,59.16 v2(91.68,58.47)
  vias: v2(71.54,48.26) v2(71.59,50.73) v2(71.59,50.12) v2(71.59,49.51) v2(71.56,48.9) v2(72.15,48.24) v2(72.17,50.75) v2(72.17,50.12) v2(72.17,49.51) v2(72.17,48.9) v3(70.42,57.19)
+1.5V_RUN: length 54.1
  TOP w0.508: RA3.1 283.18,43.63 282.34,43.63 281.91,43.2 281.91,42.56 281.21,41.86 277.16,41.86 276.95,42.07 274.72,42.07 274.49,41.84 v3(273.85,41.84) 272.48,41.84 272.02,42.29 v2(272.02,42.6)
  IN1 w0.508: v2(255.96,41.45) 257.17,40.24 260.67,40.24 261.02,39.88 263.85,39.88 265.11,41.15 266.76,41.15 267.35,41.73 267.49,41.73 269.4,43.65 269.98,43.65 271.03,42.6 v2(272.02,42.6)
  IN3 w1.016: 239.81,85.86 240.45,86.5 240.45,88.09 240.79,88.43 240.79,89.7 241.49,90.4 241.49,90.86 241.69,91.06 241.69,94.8 241.02,95.47 ; 228.97,96.48 228.45,97.01 225.17,97.01 224.63,96.47 ; 214.52,96.27 214.82,95.97 219.38,95.97 219.88,96.46 220.16,96.46
  vias: v2(214.13,97.16) v2(214.72,97.16)
+1.5V_RUN_AUDIO: length 8.9
  TOP w0.203: UA1.40 280.11,37.38 v3(280.7,37.98) 281.56,38.84 283.7,38.84 CA16.1
  TOP w0.508: CA16.1 283.73,39.07 283.09,39.7 283.09,41.23 283.35,41.48 RA3.2
+1.5V_VIN:
  vias: v3(222.22,102.63)
+1.8V_PRIM: length 46.2
  IN3 w1.016: 212.77,93.01 213.07,92.7 213.07,90.02 211.67,88.62 211.67,84.47 212.86,83.28 212.86,82.45 207.6,77.18 197.78,77.18 195.51,74.92 195.51,74.43 194.22,73.14 194.22,72.18 193.03,70.98 191.66,70.98 189.67,68.99 189.67,68.66 188.78,67.77 188.78,65.09 188.77,65.07
  BOTTOM w0.381: UC1.AF16 164.58,64.14 v2(164.25,63.81)
  vias: v2(176.7,65.48) v2(177.28,65.65) v2(188.15,63.99) v2(188.48,63.5) v2(189.07,63.52) v2(210.89,97.41) v2(210.86,94.62) v2(211.5,97.41) v2(211.47,94.62) v2(226.98,98.11) v2(227.56,98.11) v3(172.49,65.75)
+1.8V_RUN_CARD: length 64.8
  IN1 w1.016: 260.11,42.14 260.11,42.96 260.77,43.62 265.06,43.62 265.17,43.51 266.14,43.51 266.14,43.51 267.15,43.51 267.25,43.62 267.3,43.62 268.79,45.11 268.89,45.11 268.92,45.14 270.12,45.14 271.28,46.3 277.13,46.3 278.42,45.01 289,45.01 289.66,44.35 290.41,44.35 293.68,41.09 295.82,41.09 296.82,40.09 296.82,37.59 298.59,35.82 298.59,34.52 299.43,33.68 299.43,26.24 302.37,23.3 302.37,21.95
  BOTTOM w0.203: v3(258,41.29) 258.17,41.13 v2(258.74,41.13) ; v3(259.93,41.71) 259.93,41.67 259.39,41.13 v2(259.32,41.13) 259.22,41.03 259.22,40.16 v3(259.29,40.1)
  vias: v2(302.21,21.1) v2(302.84,21.1)
+1.8VALWP: length 3.5
  BOTTOM w0.508: PC503.1 PR501.1 209.74,101.62 210.68,102.56 211.62,102.56
  vias: v2(213.09,104.09) v2(213.09,103.51) v3(212.44,104)
+1VALWP: length 17.7
  IN4 w0.254: v2(213.55,51.95) 213.57,51.92 213.57,50.07 214.46,49.18 220.55,49.18 220.83,49.46 225.34,49.46 v2(226.68,48.11)
  BOTTOM w0.254: PR306.1 226.25,48.72 PC307.1 227.11,48.54 v2(226.68,48.11)
  vias: v2(211.64,52.61) v2(211.67,51.97) v2(212.23,52.58) v2(212.3,51.97) v2(212.91,52.58) v2(212.94,51.95) v2(213.57,52.61) v3(210.89,52.54)
+1VALWP_B+:
  vias: v2(226.32,57.6) v2(226.28,56.93) v3(227.12,56.86)
+1VS_VCCIOP: length 5.5
  IN3 w0.254: v2(201.61,51.72) 201.61,55.12 v2(200.8,55.93)
  BOTTOM w0.254: v2(201.61,51.72) 201.57,51.76 201.57,52.21 201.7,52.34 PU401.1
  vias: v2(198.23,56.7) v2(198.23,56.11) v2(198.92,55.99) v2(199.55,55.99) v2(200.19,55.96) v3(197.6,56.1)
+2.5V_MEM: length 113
  IN2 w1.016: 227.47,19.71 226.88,20.3 212.13,20.3 211.9,20.53 186.65,20.53 184.03,23.14 146.97,23.14 145.79,21.96 145.79,19.85 146.24,19.4
  IN4 w0.508: v2(222.31,39.02) 224.45,36.88 224.45,35.41 225.34,34.52 226.07,34.52 227.09,33.51 227.09,29.53 231.09,25.53 231.09,23.86 233.77,21.18 v2(233.77,20.91)
  BOTTOM w0.305: JDIMM1.257 144.87,18.49 v2(145.35,18.01) ; JDIMM1.259 145.37,18.9 145.43,18.85 v2(145.43,18.7)
  vias: v2(227.81,18.84) v2(227.81,18.2) v3(230.78,20.01)
+2.5V_VIN:
  vias: v1(227.45,40.01)
+3.3V_1.8V_PGPPA: length 14.3
  IN3 w1.524: 173.38,54.88 173.69,54.57 179.69,54.57 181.73,56.61 181.98,56.61 182.02,56.65 185.84,56.65
  BOTTOM w0.254: UC1.AK15 165.23,61.45 165.59,61.1 v2(165.67,61.1)
  vias: v2(187.29,56.47) v2(187.63,55.99) v2(188.05,55.58) v3(188.71,55.59)
+3.3V_1.8V_PGPPG:
  vias: v2(164.91,65.38) v2(165.57,65.38) v2(174.23,64.65) v2(174.81,64.65)
+3.3V_ALW: length 597.3
  TOP w0.305: JKBTP1.6 207.3,34.7 207.86,35.26 ; v2(282.51,10.62) 282.15,10.26 JLED1.8
  TOP w0.381: PC101.2 230.75,64.65 230.75,63.92 PU101.5 ; v2(225.11,75.96) 225.11,76.19 225.49,76.57 225.67,76.57 225.92,76.83 UE4.5 225.92,77.84 226.08,77.99 227.04,77.99 227.22,78.17 UE3.5
  TOP w0.406: CE52.1 254.72,67.96 UE5.5
  TOP w0.457: v2(225.11,75.96) 225.11,75.29 CE53.1
  TOP w0.508: v2(185.11,60.96) 185,60.85 185,60.2 RC73.2 ; v2(223.66,47.96) 223.61,48.01 PR307.1 ; RE79.1 276.57,64.09 277,64.52 277,65.84 276.47,66.37 RE300.1 276.19,66.58 274.99,67.78 v2(274.99,69.09) ; v2(278.93,54.75) 279.01,54.67 RE301.2 ; v2(29.98,87.79) 30.54,87.79 32.6,85.73 PR931.2 ; 253.58,71.94 253.61,71.94 254.24,71.3 255.73,71.3 ; 259.37,75.54 259.35,75.57 v2(259.35,77.17) 259.35,77.93 259.17,78.11 258.63,78.11 RE83.1 ; 259.37,75.54 258.61,75.54 RE25.1 258.58,73.56 257.67,72.65 256.87,72.65 256.51,72.29 256.51,71.76 256.05,71.3 255.73,71.3 ; 259.37,75.54 RE84.2 260.16,75.54 260.95,74.75 261.22,74.75 ; 207.86,35.26 209.38,36.78 214.9,36.78 216.59,38.47 216.61,38.47 216.84,38.7 216.89,38.75 CZ28.1 217.54,38.75 217.76,38.97 219.29,38.97 220.14,38.13 221.71,38.13 223.72,36.12 v2(223.72,35.17) ; PR410.1 205.57,72.88 206.31,73.62 206.31,75.23 205.2,76.34 198.65,76.34 197.04,74.73 PR418.1 PR417.1 197.04,72.77 198.23,71.57 198.23,69.09 199.2,68.12 199.2,64.25 200.97,62.49 204.99,62.49 205.91,63.4 v2(205.98,63.4) ; 289.8,64.49 290.55,65.25 290.55,68.04 288.21,70.38 v2(287.53,70.38) ; 255.73,71.3 255.73,71.3 255.73,68.74 255.15,68.16 CE52.1 ; RD30.2 78.6,14.43 v2(78.27,14.1) ; v2(205.01,48.93) 204.53,48.93 204.4,49.06 PR404.1 ; RC214.1 180.59,59.26 v2(180.51,59.17) ; PC101.2 230.69,65.08 230.03,65.74 228.82,65.74 v2(228.82,65.74) ; RE63.1 255.92,60.33 v2(256.37,60.79) 256.55,60.96 RE36.1 ; PR3.1 63.08,14.76 63.16,14.69 v2(63.16,14.57) ; v2(224.06,66.58) 224.06,66.73 223.51,67.29 PR107.1 ; v2(218.76,48.54) 219.54,47.76 RC68.2 ; 91.05,81.24 90.59,81.24 90.59,81.23 90.19,81.23 89.21,82.21 86.54,82.21 84.65,84.1 75.25,84.1 74.82,84.54 72.27,84.54 69.71,87.09 69.71,87.42 68.39,88.74 66.52,88.74 64.84,90.42 64.84,91.82 PR834.2 64.41,92.41 64.86,92.86 64.86,93.74 64.81,93.79 v2(64.81,94.21) ; PR6.2 58.25,99.22 v2(59.06,100.02) ; v2(227.29,51.46) PC312.1 ; v2(295.95,49.84) 295.95,48.66 295.31,48.02 RE74.1
  IN1 w0.508: v2(205.98,63.4) 205.98,63.4 204.81,62.23 200.98,62.23 198.38,59.63 190.68,59.63 190.17,59.12 185.87,59.12 184.95,60.04 184.95,60.8 v2(185.11,60.96) ; v2(227.19,60.07) 227.19,59.3 228.31,58.19 228.31,52.48 v2(227.29,51.46) ; v2(265.85,14) v2(265.85,13.34) 265.85,10.29 267.7,8.44 270.39,8.44 270.78,8.06 270.78,7.4 271.21,6.96 273.04,6.96 273.82,7.75 276.95,7.75 277.66,7.04 280.58,7.04 282.51,8.97 v2(282.51,10.62)
  IN2 w0.508: 231.89,33.42 231.75,33.28 230.99,33.28 230.44,32.73 227.56,32.73 v2(226.34,31.51) ; v2(218.76,48.54) 222.28,48.54 222.86,47.96 v2(223.66,47.96) 223.92,48.23 224.79,48.23 PC312.1 v2(227.29,51.46) ; v2(185.11,60.96) 185.08,60.98 185.08,62.46 v2(186.66,64.03) ; v2(29.98,87.79) 29.98,90.31 31.27,91.6 33.28,91.6 33.64,91.95 33.64,91.98 37.11,91.98 40.02,89.07 42.51,89.07 42.85,88.73 46.39,88.73 54.33,96.67 54.33,98.6 55.18,99.44 58.48,99.44 v2(59.06,100.02)
  IN2 w1.524: 240.01,32.03 242.37,32.03 242.89,31.51 245.35,31.51 245.86,32.02 246.75,32.02 247.61,32.87 247.61,33.46 248.12,33.98 248.12,34.05 248.33,34.26
  IN3 w0.508: v2(278.93,54.75) 278.93,56.23 279.7,57.01 v2(279.7,58.75) ; v2(89.88,33.71) 90.74,33.71 91.77,32.68 110.23,32.68 112.53,34.98 125.43,34.98 127.18,33.23 127.44,32.97 127.58,32.83 151.5,32.83 152.52,31.8 180.44,31.8 ; v2(38.82,82.22) 38.82,82.12 38.49,81.79 36.2,81.79 30.21,87.79 v2(29.98,87.79) ; v2(265.45,39.46) 264.92,38.92 264.92,37.65 264.92,37.13 265.9,36.15 v2(265.9,34.78) ; v2(205.98,63.4) 205.68,63.1 205.68,57.03 208.44,54.26 208.44,52.12 207.45,51.13 207.45,48.72 207.12,48.39 205.55,48.39 v2(205.01,48.93)
  IN3 w1.016: 220.5,29.39 219.95,29.39 217.8,31.55 181.26,31.55
  IN4 w0.508: v2(89.88,33.71) 90.77,33.71 91.65,32.82 91.65,28.4 83.55,20.29 81.9,20.29 79.98,18.37 79.98,15.05 79.02,14.1 v2(78.27,14.1) 72.84,14.1 72.37,14.57 72.37,14.86 71.15,16.08 67.3,16.08 65.01,13.8 63.75,13.8 63.16,14.39 v2(63.16,14.57) ; v2(243.65,71.81) 246.42,69.04 250.79,69.04 252.18,67.64 252.18,66.7 253.81,65.07 253.81,62.64 255.66,60.79 v2(256.37,60.79) ; v2(185.11,60.96) 184.62,60.47 184.62,59.2 183.91,58.49 181.19,58.49 v2(180.51,59.17) ; v2(227.19,60.07) 227.19,60.4 227.69,60.9 228.99,60.9 229.39,61.31 229.39,61.91 228.82,62.48 228.82,63.4 229.21,63.79 229.21,65.34 v2(228.82,65.74) 228.82,65.74 228.46,65.74 228.2,65.49 225.15,65.49 v2(224.06,66.58) ; v2(226.34,31.51) 226.34,31.82 224.5,33.67 224.5,34.4 v2(223.72,35.17)
  BOTTOM w0.381: RZ24.1 287.47,70.45 v2(287.53,70.38)
  BOTTOM w0.508: v2(169.48,95.18) 170.27,94.39 CC271.1 170.3,93.9 UC13.5 ; v2(59.06,100.02) 59.75,99.32 59.75,99.17 61.94,96.98 63.26,96.98 63.59,97.31 65.01,97.31 66.05,96.27 66.05,95.56 64.81,94.31 v2(64.81,94.21) ; v2(257.06,85.09) 257.41,84.75 RE309.1 ; v2(205.98,63.4) 205.88,63.31 PR413.1 206.11,57.53 206.51,57.13 207.2,57.13 207.68,56.65 PR414.1 ; v2(279.7,58.75) 279.39,58.75 278.22,59.92 278.22,63.79 274.99,67.02 v2(274.99,69.09) ; RE69.1 135.88,91.01 v2(136.56,91.7) ; v2(38.82,82.22) 38.95,82.1 PR913.1 ; PR903.1 253.91,95.48 v2(254.42,95.99) 255.55,97.12 257.72,97.12 258.41,96.43 258.41,94.39 PR902.1 ; PR113.1 226.68,60.07 v2(227.19,60.07)
  vias: v2(91.53,81.11) v2(92.11,81.13) v2(92.61,81.44) v2(180.6,32.73) v2(181.18,32.73) v2(205.7,64.62) v2(205.68,63.99) v2(205.78,66.65) v2(205.8,65.99) v2(205.83,65.28) v2(206.29,64.65) v2(206.26,64.01) v2(206.39,65.99) v2(206.41,65.28) v2(206.84,64.01) v2(206.79,63.43) v2(206.87,64.62) v2(207.45,64.57) v2(207.48,63.99) v2(207.62,103.93) v2(207.62,103.34) v2(209.54,100.53) v2(210.15,100.53) v2(221.32,28.83) v2(221.91,28.83) v2(233.06,35.4) v2(233.06,34.81) v2(233.16,34.23) v2(243.27,76.2) v2(243.27,75.6) v2(243.93,48.85) v2(243.88,48.22) v2(244.26,49.64) v2(244.54,48.72) v2(244.46,48.09) v2(244.74,49.97) v2(244.74,49.28) v2(245.58,92.56) v2(246.19,92.56) v2(247.7,86.52) v2(247.72,85.93) v2(248.07,39.93) v2(248.32,40.46) v2(248.45,47.5) v2(248.45,46.89) v2(248.68,39.98) v2(249,47.75) v2(248.98,47.15) v2(248.96,40.55) v2(249.19,45.75) v2(249.47,46.28) v2(249.52,45.27) v2(249.95,45.67) v2(250.39,45.27) v2(251.66,39.91) v2(251.83,40.47) v2(251.88,41.11) v2(252.26,40.02) v2(252.42,40.62) v2(252.52,41.21) v2(252.94,40.19) v2(252.96,40.83) v2(259.77,48.25) v2(259.78,47.67) v3(232.82,37.16) v3(249.6,70.98) v3(265.59,12.78)
+3.3V_ALW2: length 653.2
  TOP w0.508: RE57.2 267.93,48.01 267.97,47.97 v2(267.98,47.98) ; PR917.1 65.65,17.3 v2(66.31,16.64) ; v2(30.39,76.94) 30.46,76.94 30.82,76.58 PR932.1 ; v2(26.05,76.56) 25.69,76.2 PR920.1 ; PR909.2 PC905.2 71.99,11.66 PU903.5 71.15,10.82 v2(70.55,10.82) ; PR104.2 219.01,67.14 218.83,66.96 v2(218.38,66.96) ; R272.2 170.09,109.38 171.16,110.44 177.51,110.44 v2(179.36,108.59) ; RZ84.1 v2(273.57,10.75) ; PR914.1 v2(68.01,10.88)
  IN1 w0.508: v2(260.41,29.68) 261.35,28.74 265.85,28.74 267.5,27.09 v2(267.93,27.09)
  IN2 w0.508: v2(244.52,59.29) 243.65,59.29 241.05,61.89 241.05,62.4 239.86,63.58 239.86,66.5 238.31,68.05 235.52,68.05 233.59,69.98 233.59,72.27 232.5,73.36 230.08,73.36 229.38,72.65 229.38,71.33 228.36,70.31 225.99,70.31 225.96,70.28 225.95,70.28 225.22,69.56 225.22,69.54 224.52,68.84 224.52,68.58 224.5,68.56 224.5,68.51 223.86,67.87 219.9,67.87 218.99,66.96 v2(218.38,66.96) ; v2(66.31,16.64) 66.55,16.88 68.87,16.88 75.92,23.93 ; v2(241.39,21.88) 241.39,20.66 239.76,19.03 234.38,19.03 229.59,23.82 216.14,23.82 214.7,25.26 202.88,25.26 200.28,27.87 192.83,27.87 191.03,29.67 112.45,29.67 107.38,24.59 86.3,24.59 85.19,23.49 79.86,23.49 79.41,23.93 75.92,23.93 ; 75.92,23.93 75.92,26.15 73.24,28.83 73.24,38.42 70.13,41.53 70.13,50.67 69.2,51.6 69.2,52.33 68.94,52.59 68.94,64.57 64.18,69.33 63.35,69.33 60.11,72.58 56.66,72.58 56.33,72.91 v2(55.96,72.91)
  IN3 w0.508: v2(241.39,21.88) 241.39,20.23 239.76,18.6 239.76,17.65 241.14,16.26 244.45,16.26 244.97,15.74 245.31,15.4 250.03,15.4 250.95,14.48 254.03,14.48 255.08,13.44 255.08,12.12 255.51,11.7 255.51,9.91 256.61,8.8 262.75,8.8 264.68,10.73 v2(264.68,11.08) ; v2(55.96,72.91) 56.41,72.91 56.76,72.56 56.76,71.59 55.85,70.68 52.52,70.68 45.39,77.8 38.69,77.8 36.13,75.24 31.86,75.24 30.39,76.71 v2(30.39,76.94) 29.55,76.1 26.5,76.1 v2(26.05,76.56) ; v2(275.7,14.74) 274.65,14.74 274.39,15 274.37,15 274.13,15.25 274.13,15.26 274.01,15.37 274,15.37 273.93,15.45 273.93,15.85 272.6,17.17 272.15,17.17 271.17,18.15 271.17,22.42 270.39,23.19 269.85,23.19 267.93,25.11 v2(267.93,27.09) 267.56,27.09 267.19,27.46 267.19,30.1 267.7,30.61 267.7,32.69 267.7,33.51 267.6,33.62 267.19,34.02 267.19,39.85 267.19,40.84 267.55,41.19 267.55,42.91 268.4,43.77 268.4,47.31 267.98,47.73 v2(267.98,47.98) ; v2(179.36,108.59) 179.69,108.26 179.69,101.14 181.38,99.44 188.56,99.44 192.74,95.26 199.47,95.26 199.54,95.33 201.11,95.33 206.1,100.33 206.1,101.48 206.59,101.97 206.59,106.25 209.26,108.92 210.65,108.92 211.42,109.68 215.91,109.68 216.34,109.25 216.34,106.21 216.78,105.78 217.63,105.78 218,106.15 219.59,106.15 220.25,105.49 227.52,105.49 228.81,104.19 234.76,104.19 235.56,103.39 237.7,103.39 238.15,102.95 244.41,102.95 v2(245.91,101.45) ; v2(229.17,81.51) 229.17,80.78 228.64,80.24 224.15,80.24 221.89,77.98 221.89,75.61 222.8,74.69 225.14,74.69 225.89,73.93 225.89,70.08 224.93,69.12 224.93,68.66 224.42,68.15 220.23,68.15 219.04,66.96 v2(218.38,66.96)
  IN4 w0.508: v2(260.41,29.68) 260.23,29.86 260.23,31.43 259.9,31.76 259.9,31.94 259.44,32.41 258.34,32.41 257.6,33.15 256.6,33.15 254.66,35.09 254.66,36.01 254.04,36.63 251.02,36.63 250.56,37.09 247.27,37.09 246.06,38.3 244.97,38.3 242.78,40.48 242.78,41.91 241.63,43.06 241.63,45.05 242.25,45.67 242.25,47.15 242.74,47.64 242.74,49.8 242.78,49.84 242.78,49.86 243.62,50.7 244.23,50.7 246.32,52.79 246.32,56.93 245.45,57.79 245.45,58.92 245.09,59.29 v2(244.52,59.29)
  BOTTOM w0.508: v2(66.31,16.64) 66.64,16.31 66.64,12.25 v2(68.01,10.88) 68.06,10.82 v2(70.55,10.82) ; v2(245.91,101.45) 245.91,98.53 245.46,98.07 244.48,98.07 244.25,97.84 244.25,97.22 242.78,95.76 242.78,92.59 243.39,91.98 243.39,87.56 242.63,86.8 241.74,86.8 239.99,85.04 234.33,85.04 233.74,84.46 233.74,82.65 232.6,81.51 v2(229.17,81.51) ; v2(275.7,14.74) 275.14,14.17 275.14,11.83 274.06,10.75 v2(273.57,10.75) 273.46,10.86 266.95,10.86 266.64,11.18 264.78,11.18 v2(264.68,11.08)
+3.3V_ALW2_R: length 2.9
  TOP w0.305: v3(271.21,9.87) 271.21,9.8 271.43,9.58 271.81,9.58 271.96,9.43 JUSH1.25
  TOP w0.508: v3(271.21,9.87) 271.21,9.91 RZ84.2
+3.3V_ALW_DSW: length 461.4
  TOP w0.254: RC72.2 168.04,44.32 168.04,41.27 172.46,36.85 198.22,36.85 200.65,39.28 210.18,39.28 v2(211.59,40.69) ; 302.28,29.35 302.28,29.2 300.03,26.95 JAPS1.3 ; v2(300.29,35.74) 300.29,35.35 302.7,32.94 302.7,30.16 302.4,29.86
  TOP w0.305: JAPS1.7 300.04,28.95 300.28,29.19 300.28,29.56 300.46,29.73 302.02,29.73
  TOP w0.381: v2(220.18,39.04) 220.04,39.04 v3(219.33,39.75) 218.92,40.17 218.92,43.34 217.74,44.52 RC243.2 RC67.1
  TOP w0.508: v2(257.01,86.36) 257.01,91.06 RC323.1 ; v2(86.83,38.21) 86.6,38.43 RC241.1
  IN1 w0.254: v2(300.29,35.74) 299.48,36.55 299.48,37.82 298.74,38.56 298.74,39.66 293.29,45.11 289.98,45.11 289.32,45.77 279.34,45.77 278.05,47.06 270.9,47.06 269.99,46.15 265.58,46.15 264.47,47.26 263.8,47.26 263.13,47.93 262,47.93 261.16,48.77 258.56,48.77 258.25,48.47 258.25,45.95 256.6,44.3 256.6,43.74 255.1,42.24 252.59,42.24 v2(252.26,41.91)
  IN1 w0.508: v2(257.01,86.36) 257.72,86.36 258.07,86 258.07,85.66 259.86,83.87 260.45,83.87 261.24,83.09 261.24,82.18 266.27,77.15 267.83,77.15 270.37,74.6 272.47,74.6 274.01,73.07 274.01,71.99 274.54,71.45 275.95,71.45 276.82,72.33 278.34,72.33 278.84,72.82 278.84,72.82 278.92,72.9 281.75,72.9 282.43,72.23 284.32,72.23 284.85,71.69 287.94,71.69 288.44,71.19 288.44,69.84 287.57,68.96 287.57,68.4 289.79,66.18 289.79,60.51 289.17,59.89 289.17,56.62 v2(290,55.78)
  IN1 w1.016: 218.83,38.04 218.02,38.04 215.72,40.34 214.26,40.34 213.54,41.06 213.19,41.06 213.01,41.24 212.14,41.24 v2(211.59,40.69) 208.98,38.08 189.77,38.08 184.58,43.27 182.14,43.27 177.16,48.25 177.16,50.73 177.15,50.74 177.15,51 176.18,51.97 175.64,51.97 172.9,54.71 172.9,56.21 172.78,56.33 172.78,57.69 173.39,58.3 175.3,58.3
  IN2 w0.508: v2(300.29,35.74) 301.43,36.88 301.43,39.07 290.84,49.66 290.84,54.94 v2(290,55.78)
  IN3 w0.254: v2(220.18,39.04) 220.66,38.56 220.66,37.7 220.97,37.39 225.39,37.39 226.19,38.19 228.7,38.19 229.37,38.87 231.26,38.87 231.35,38.95 238.45,38.95 238.92,39.42 240.5,39.42 240.82,39.75 246.13,39.75 246.79,40.42 247.56,40.42 248.35,41.2 249.3,41.2 250.02,41.91 v2(252.26,41.91)
  IN3 w0.508: v2(220.18,39.04) 219.82,38.69 219.82,35.18 219.02,34.38 217.29,34.38 216.83,33.92 214.91,33.92 214.16,34.67 214.12,34.67 214.12,34.67 209.93,34.67 209.7,34.9 128.37,34.9 125.85,37.42 125.27,37.42 125.27,37.42 105.39,37.42 103.35,35.39 93.55,35.39 92.2,36.74 90.16,36.74 89.91,36.49 89.07,36.49 88.68,36.87 88.68,36.95 88.16,37.47 87.45,37.47 86.83,38.1 v2(86.83,38.21)
  BOTTOM w0.254: UC1.AJ17 163.93,62.55 v2(163.61,62.87)
  vias: v2(163.59,65.49) v2(176.19,59.91) v2(176.67,59.55)
+3.3V_ALW_PCH: length 613.8
  TOP w0.254: RC26.2 174.11,42.68 174.11,40.66 176.68,38.09 181.13,38.09 182.23,39.19 182.23,42.15 182.81,42.73 RC288.2 184.66,42.73 RC317.2 184.7,42.76 185.26,43.32 188.31,43.32 191,40.63 203.62,40.63 205.4,42.41 ; v2(300.14,36.91) 302.36,34.69 302.74,34.69 303.49,33.93 303.49,29.34 300.1,25.95 JAPS1.1 ; RC187.1 166.51,41.19 171.62,36.08 198.66,36.08 201.01,38.43 213.19,38.43 214.25,39.5 217.75,39.5 v2(217.85,39.6) ; v2(164.9,62.93) 164.5,63.33 163.23,63.33 CC224.1
  TOP w0.305: v2(160.96,62.89) 160.96,62.85 161.24,62.57 LC1.1
  TOP w0.381: v2(160.96,62.89) 160.86,62.89 160.58,63.17 160.58,63.52 160.29,63.81 CC215.1 ; CC223.1 163.52,61.42 v2(163.84,61.09)
  TOP w0.508: v2(176.69,84.64) 177,84.33 179.61,84.33 180.51,85.23 RC236.1 ; RC133.1 92.59,36.77 92.83,36.53 v2(93.51,36.53)
  TOP w1.016: 214.73,42.79 212.89,42.79 212.51,42.41 210.99,42.41 209.56,40.98 206.84,40.98 203.35,44.47 193.86,44.47 191.28,47.04 191.28,47.62 191.19,47.71 191.19,48.19 191.11,48.19
  IN1 w0.254: v2(255.69,43.97) 257.87,46.16 257.87,48.63 258.48,49.23 261.24,49.23 262.16,48.31 263.29,48.31 263.96,47.64 264.62,47.64 265.74,46.53 269.83,46.53 270.74,47.44 278.43,47.44 279.7,46.17 289.47,46.17 290.14,45.5 293.69,45.5 299.3,39.88 299.3,38.87 300.14,38.03 v2(300.14,36.91)
  IN1 w0.381: v2(34.2,76.46) 33.34,76.46 v2(32.88,76.91)
  IN1 w0.508: v2(34.2,76.46) 35.4,77.66 44.75,77.66 48.23,74.18 54.95,74.18 55.69,74.92 56.68,74.92 57.7,73.91 62.57,73.91 63.21,73.27 64.54,73.27 65.86,74.59 v2(69.89,74.59)
  IN2 w0.381: v2(163.84,61.09) 163.84,61.77 164.9,62.83 v2(164.9,62.93)
  IN2 w0.508: v2(180.36,67.81) 180.16,68.01 180.16,69.5 180.57,69.91 180.95,69.91 181.37,70.34 v2(181.37,70.53) 181.37,70.65 180.72,71.3 178.42,71.3 178.01,71.71 178.01,72.43 178.33,72.74 179.41,72.74 180.02,73.34 180.02,74.62 178.64,75.99 178.64,82.41 176.69,84.36 v2(176.69,84.64)
  IN3 w0.508: v2(252.41,64.8) 252.41,66.53 252.34,66.6 252.34,68.72 248.33,72.73 247.53,72.73 247.35,72.92 246.79,72.92 246.65,73.05 246.39,73.32 245.39,73.32 243.98,74.73 243.72,74.99 243.01,74.99 242.66,75.34 242.66,75.35 242.32,75.69 242.32,76.31 242.18,76.45 242.18,77.08 240.91,78.35 240.91,79 241.29,79.38 241.29,82.28 241.66,82.66 243.13,82.66 244.09,83.61 244.09,86.98 243.98,87.08 v2(243.98,93.58) ; v2(80.17,44.68) 80.56,45.08 86.52,45.08 89.28,42.32 89.28,40.35 91.35,38.27 92.22,38.27 93.51,36.97 v2(93.51,36.53) 94.02,36.02 103.09,36.02 105.13,38.06 125.01,38.06 125.01,38.06 125.59,38.06 126.11,38.06 126.27,38.06 128.79,35.54 209.96,35.54 210.19,35.31 214.39,35.31 214.39,35.31 217.16,35.31 218.2,36.35 218.2,36.96 219.04,37.8 219.04,39.16 v2(218.49,39.71) ; v2(243.69,40.6) 243.55,40.46 240.77,40.46 240.27,39.96 238.59,39.96 238.39,39.75 ; v2(183.44,64.04) 184.58,65.18 184.58,65.77 v2(186.23,67.42)
  IN3 w1.016: 222.5,39.91 222.88,40.29 230.8,40.29 231.18,39.91 235.85,39.91 ; 188.2,51.08 187.74,51.08 185.14,48.48 181.25,48.48 179.47,50.26 177.89,50.26 176.08,52.07 171.11,52.07 170.22,52.96 165.01,52.96 163.92,54.06 163.92,55.3
  IN4 w0.508: 245.66,47.24 245.66,48.15 245.66,48.16 245.66,48.67 245.66,48.68 245.66,50.67 247.84,52.85 247.84,55.16 v2(249.19,56.51) 248.15,57.55 247.21,57.55 246.52,58.24 246.52,63.2 248.12,64.8 v2(252.41,64.8) ; 245.66,47.24 245.66,46.21 246.21,45.65 246.21,44.84 247.76,43.3 249.1,43.3 250.3,42.1 251.38,42.1 253.4,44.12 255.54,44.12 v2(255.69,43.97) ; 245.66,47.24 245.56,47.15 244.28,47.15 243.94,46.81 243.94,45.87 242.75,44.67 242.75,43.12 243.69,42.18 v2(243.69,40.6) ; v2(80.17,44.68) 79,45.85 79,57.09 78.4,57.69 76.1,57.69 74.92,58.87 74.92,60.39 73.12,62.2 73.12,67.91 71.95,69.08 71.59,69.08 70.3,70.37 70.3,72.2 69.89,72.61 v2(69.89,74.59)
  BOTTOM w0.254: UC1.AJ21 160.96,62.87 v2(160.96,62.89) ; v2(164.9,62.93) 165.23,63.26 UC1.AG15 ; v2(162.26,67.97) 162.46,67.76 162.63,67.6 UC1.V19 ; UC1.AK17 163.93,61.18 v2(163.84,61.09)
  BOTTOM w0.381: RC246.2 181.01,71.77 181.37,71.41 v2(181.37,70.53) 182.06,71.21 RC341.1 ; RC331.1 34.4,76.66 v2(34.2,76.46) ; v2(32.88,76.91) 32.84,76.91 32.46,77.3 RC330.1 ; v2(249.19,56.51) 248.34,55.65 248.34,54.25 247.93,53.84 RC344.2 ; RC17.2 RC15.2 RC25.2 179.45,67.81 v2(180.36,67.81)
  BOTTOM w0.508: RC222.1 244.89,94.49 v2(243.98,93.58) ; v2(186.23,67.42) 186.23,67.46 UC7.5 ; v2(183.44,64.04) 183.55,63.92 RC283.1
  vias: v2(164.22,66.27) v2(164.93,66.27) v2(189.57,51.08) v2(190.16,51.01) v2(236.94,39.68) v2(237.53,39.68) v3(236.44,40.28)
+3.3V_ALW_PCH_UZ24:
  vias: v3(242.08,48.66)
+3.3V_ALW_UE1: length 31.6
  TOP w0.279: CE4.1 251.01,75.98 251.01,76.69 250.89,76.81 UE1.A43 ; v2(255.82,81.18) 255.62,81.38 UE1.A54
  TOP w0.305: v2(251.8,76.15) 251.65,76.15 251.6,76.2 251.27,76.2 CE4.1 ; CE5.1 256.32,80.67 256.32,80.68 v2(255.82,81.18) ; UE1.A17 243.84,86.38 243.6,86.62 243.6,87.94 CE2.1 ; v2(246.04,80.67) 245.99,80.63 UE1.B30
  TOP w0.381: UE1.B5 v2(251.64,86.42) ; v2(242.82,80.49) 242.84,80.52 CE6.1
  IN1 w0.508: v2(255.82,81.18) 256.25,81.18 256.49,81.42 256.49,82.18 256.06,82.6 252.54,82.6 251.46,81.53 249.59,79.66 249.59,78.52 251.8,76.31 251.8,76.2 251.78,76.18 v2(251.8,76.15) ; v2(251.64,86.42) 251.64,87.15 252.73,88.24 252.73,89.16 252.19,89.71 250.64,89.71 v2(249.59,90.76)
  vias: v3(249.24,90.01)
+3.3V_ALW_UE2: length 87.3
  TOP w0.254: UE2.A26 265.15,67.56 265.01,67.69 CE23.1 ; v2(265.59,68.08) 265.47,68.2 265.39,68.2 265.24,68.35 265.24,68.43 CE23.1 ; UE2.A22 267.15,68.45 267.12,68.48 267.12,68.57 CE13.1 266.69,68.49 v2(266.69,68.13) ; CE23.1 264.3,68.66 CE14.1
  TOP w0.279: UE2.A58 266.65,55.36 266.7,55.31 266.7,54.9 266.43,54.63 266.2,54.63 265.8,54.23 265.8,54.08 CE20.1
  TOP w0.305: 262.83,51.24 262.83,53.23 263.16,53.56 263.16,54.16 263.31,54.31 CE16.1 263.65,54.35 UE2.A52 ; CE19.1 258.62,66.73 259.7,66.73 261.14,65.29 UE2.B35 ; UE2.A11 273.24,62.54 CE18.1 273.26,62.59 v2(272.78,63.07) ; v2(269.86,58.36) 269.93,58.29 UE2.B3 ; UE2.A41 260.1,61.04 259.9,61.24 259.88,61.24 259.78,61.34 259.49,61.34 259.31,61.52 258.24,61.52 CE22.1
  TOP w0.356: CE19.1 258.16,66.03 257.79,65.65 v2(257.64,65.65)
  TOP w0.381: CE17.1 274.01,59.88 273.65,59.52 v2(273.29,59.52) ; CE22.1 258.06,61.82 258.32,62.08 v2(258.84,62.08)
  TOP w0.508: CE20.1 265.77,53.49 CE15.1 265.6,52.89 v2(265.19,52.48)
  IN4 w0.508: v2(272.78,63.07) 272.78,62.69 272.4,62.31 271.28,62.31 270.7,62.89 270.7,65.43 269.86,66.27 268.24,66.27 267.47,67.03 267.47,67.9 267.25,68.13 v2(266.69,68.13) 266.61,68.05 265.62,68.05 v2(265.59,68.08) 265.31,68.08 263.49,66.25 260.33,66.25 259.6,66.98 258.08,66.98 257.64,66.55 v2(257.64,65.65) 257.64,65.3 257.31,64.96 257.31,64.11 257.64,63.77 257.64,63.04 258.6,62.08 v2(258.84,62.08)
  BOTTOM w0.254: v2(269.86,58.36) 269.93,58.36 269.93,58.31 270.64,58.31 271.84,57.1 273.54,57.1 274.22,57.78
  BOTTOM w0.508: 263.82,49.81 264.22,49.41 270.1,49.41 271.16,50.46 271.16,53.47 272.63,54.94 275.12,54.94 275.68,55.5 275.68,56.32 273.29,58.7 v2(273.29,59.52) 273.82,59.52 274.41,60.1 274.41,62.13 274,62.54 273.16,62.54 272.78,62.92 v2(272.78,63.07)
  vias: v2(262.5,50.04) v3(263.26,50.46)
+3.3V_ALWP: length 32
  TOP w0.254: v2(208.34,66.17) 208.34,66.1 208.88,65.56 212.03,65.56 212.97,64.62 217.83,64.62 218.51,65.3 220.43,65.3 220.8,65.67 220.8,66.85 220.64,67.01 v2(220.64,67.24) PR109.1
  IN1 w0.254: v2(220.46,68.94) 220.46,68.08 219.59,67.21 219.59,66.37 218.78,65.56 209.47,65.56 208.98,66.05 v2(208.98,66.15)
  BOTTOM w0.254: v2(220.64,67.24) 220.66,67.26 221.13,67.26 PR108.2 ; PU100.14 220.73,69.4 220.46,69.13 v2(220.46,68.94)
  vias: v2(208.34,66.91) v2(208.95,66.93) v2(209.61,71.58) v2(209.61,70.74) v2(209.61,70.11) v2(209.64,69.3) v2(209.61,68.59) v2(209.59,66.93) v2(209.61,66.15) v2(210.22,66.91) v2(210.25,66.12)
+3.3V_CAM: length 35.1
  TOP w0.203: v3(110.16,87.56) 110.93,87.56 v2(112.2,88.84)
  TOP w0.381: v2(91.53,87.71) 91.53,86.91 91.32,86.7 CZ1.1
  IN3 w0.254: v2(91.53,87.71) 92.09,87.15 97.34,87.15 101.64,91.45 104.93,91.45 105.29,91.09 107,91.09 107.94,90.15 111.36,90.15 112.2,89.3 v2(112.2,88.84)
  BOTTOM w0.254: QZ1.1 112.79,89.71 112.2,89.12 v2(112.2,88.84)
  BOTTOM w0.381: v2(91.53,87.71) 91.71,87.71 92.25,87.17 JEDP1.11
+3.3V_HDD:
  vias: v2(258.1,31.5) v2(258.61,31.04) v2(258.66,31.75) v2(258.69,26.88) v2(259.24,31.7) v2(259.22,31.04) v2(264.22,22.64) v2(264.25,22.05) v2(264.83,22.64) v2(264.83,22.05) v2(267.5,20.4) v2(273.7,19.13) v2(273.7,18.5) v2(274.28,19.13) v2(274.28,18.5) v3(258.65,32.61) v3(267.58,17.45) v3(268.27,19.31)
+3.3V_HDD_M2: length 76.3
  TOP w0.457: RN25.1 228.64,37.14 230.78,37.14 231.77,36.16 231.77,34.09 232.57,33.28 v2(235.19,33.28)
  TOP w0.508: v2(237.38,23.32) 237.17,23.54 RN57.1 235.92,24.11 v3(235.09,24.94) 234.48,25.55 234.48,26.75 233.99,27.24 ; CN20.1 233.08,31.83 234.86,31.83 RN42.1 235.07,31.68 RN56.1 ; v2(233.56,24.52) 233.56,24.93 RN44.1 ; RN69.1 235.55,27.24 v2(235.44,27.13) 235.34,27.24 233.99,27.24 ; RN43.1 v2(234.73,29.04) ; RN56.1 235.95,31.05 RN58.1 ; RN56.1 235.95,32.13 235.19,32.89 v2(235.19,33.28) 235.19,33.46 236.03,34.31 236.03,34.87 236.74,35.58 v3(237.44,35.58) 237.69,35.33 237.69,34.51 237.7,34.5 RN55.1 ; v2(242.63,26.9) 243.11,26.9 244.04,25.97 RN65.1 ; 233.99,27.24 RN50.1 ; RN70.1 RN64.1 v2(246.4,29.65) ; RN51.1 228.79,24.87 229.14,24.52 v2(229.2,24.52) ; 238.42,27.28 237.48,26.35 CN30.1 v2(237.12,25.71) ; v2(254.8,10.95) 255.68,10.95 RN37.1 ; RN71.1 v2(241.87,23.43)
  IN3 w0.508: v2(254.8,10.95) 254.8,5.11 254.72,5.03
  IN3 w1.016: 237.6,21.67 237.78,21.49 237.78,18.37 240.78,15.37 244.08,15.37 244.94,14.51 246.01,14.51 246.7,13.82 246.7,10.75 247.81,9.63 250.71,9.63 251.04,9.3 251.04,6.02 251.17,5.9
  IN4 w0.508: v2(235.19,33.28) 235.19,30.97 234.73,30.51 v2(234.73,29.04)
  vias: v2(225.28,24.43) v2(243.43,32.72) v2(250.61,4.47) v2(251.22,4.47) v2(264.68,4.65) v2(265.39,4.63) v2(266.05,4.63) v2(272.17,11.64) v2(272.3,12.27) v2(272.96,12.25) v2(273.09,11.64) v2(273.57,12.12) v2(273.95,11.64) v3(224.27,25.49)
+3.3V_LAN: length 138.6
  TOP w0.203: v2(276.43,83.18) 276.43,83.17 276.4,83.2 UL4.39
  TOP w0.305: v2(272.77,83.24) 272.77,82.92 272.96,82.72 UL4.1
  TOP w0.508: RL29.1 274.26,71.73 274.61,71.38 275.91,71.38 276.85,72.31 276.85,72.82
  IN1 w1.524: 241.31,92.23 241.74,92.66 241.74,93.02 243.42,94.7 244.79,94.7 245.15,95.05 248.28,95.05 249.46,93.87 253.56,93.87 255.5,91.93 256.63,91.93
  IN3 w0.254: v2(181.14,67.8) 181.56,68.22 182.29,68.22 182.59,67.91 182.59,67.07 182.83,66.83 184.84,66.83 185.94,67.94 186.66,67.94 188.78,70.06 189.66,70.06 191.18,71.57 191.18,73.28 194.61,76.71 196.05,76.71 197.41,78.07 205.28,78.07 210.91,83.7 210.91,89.19 210.09,90.01 210.09,92.68 210.4,92.99 210.4,93.73 209.99,94.14 209.99,94.78 210.62,95.41 211.96,95.41 213,94.36 217.1,94.36 217.93,93.53 223.05,93.53 223.77,94.25 227.51,94.25 229.45,92.31 236.9,92.31
  IN3 w1.524: 236.71,87.41 236.97,87.15 236.97,81.18 236.52,80.72 236.52,75.85 238.06,74.3 238.06,72.23 239.73,70.57 241.79,70.57 242.25,70.11
  BOTTOM w0.254: RC19.2 RC20.2 180.48,67.14 v2(181.14,67.8)
  BOTTOM w0.381: UL2.5 282.51,75.62 v2(282.3,75.84)
  BOTTOM w0.508: CL19.1 261,98.06 262.53,99.58 v2(262.93,99.58) ; RL5.1 258.63,90.61 258.63,92.97 258.59,93.02 v2(258.59,93.08) ; v2(284.92,78.39) 285.42,78.89 RL30.1 ; RL70.1 260.95,90.07 v2(260.49,90.53)
  vias: v2(239.79,92.43) v2(239.9,91.86) v2(240.37,92.43) v2(248.9,55.21) v2(249.53,55.22) v2(250.15,55.33) v2(254.27,89.96) v2(254.27,89.35) v2(258.31,93.64) v2(263.67,99.61) v2(271.24,80.99) v2(271.64,76.08) v2(272.1,79.18) v2(272.43,80.9) v2(276.31,72.9) v2(277.96,78.64) v2(288.79,92.25) v2(289.39,92.27) v3(272.35,86.45)
+3.3V_LAN_OUT: length 9.6
  TOP w0.203: v2(262.44,83.06) 262.69,83.31 UL1.15 ; UL1.29 266.59,86.33 265.95,86.96 v2(265.95,87.24) ; v2(264.3,82.92) 264.3,83.95 UL1.19
  BOTTOM w0.508: v2(264.3,82.92) 264.13,83.09 264.13,86.63 264.73,87.24 v2(265.95,87.24)
  vias: v2(259.6,87.74) v2(260.23,87.74) v3(257.19,87.01)
+3.3V_LAN_UZ2:
  vias: v3(251.5,52.56)
+3.3V_M: length 85.2
  TOP w0.508: RZ72.1 188.97,61.33 189.96,61.33 191.02,60.26 195.01,60.26 195.7,59.58 198.32,59.58 199.47,60.73 204.06,60.73 v2(204.56,61.23) ; RC276.2 v3(216.58,47.71) 217.12,47.71 217.44,48.02 v2(217.44,48.57)
  IN1 w0.508: v2(253.96,42.85) 253.96,43.16 253.73,43.39 252.69,43.39 251.42,42.12 250.25,42.12 249.44,41.3 ; 244.69,40.21 244.4,39.92 242.1,39.92 240.16,37.98 238.49,37.98 237.46,39.01 237.4,39.07 231.93,39.07 231.92,39.05 229.03,39.05 v2(228.81,39.27)
  IN2 w0.508: v2(204.56,61.23) 206.14,59.64 206.14,58.45 209.51,55.08 209.51,54.19 209.51,54.19 209.51,53 209.28,52.77 209.28,49.16 210.57,47.87 217.01,47.87 217.44,48.3 v2(217.44,48.57)
  IN4 w0.508: v2(228.81,39.27) 228.05,39.27 225.68,41.64 225.68,44.64 223.15,47.17 223.15,47.6 222.74,48.01 221.61,48.01 220.7,47.11 217.88,47.11 217.44,47.56 v2(217.44,48.57)
+3.3V_M_TPM: length 48.1
  TOP w0.254: CZ74.1 193.87,68.32 192.75,68.32 192.6,68.17 UZ12.14
  TOP w0.381: CZ74.1 193.93,68.38 CZ76.1
  TOP w0.508: CZ76.1 193.93,69.72 v2(194.33,70.12) ; v2(194.33,70.12) 194.58,70.12 195.52,71.06 197.02,71.06 197.55,70.53 197.55,68.83 198.5,67.89 v3(198.5,66.44) 198.5,64 198.14,63.64 ; v2(194.33,70.12) 193.79,70.65 193.79,71.44 194.33,71.97 194.33,73.09 194.91,73.68 RZ69.1 194.91,76.9 194.02,77.79 189.43,77.79 187.54,75.9 187.54,73.23
  IN2 w0.508: v2(189.98,62.74) 189.98,63.14 193.01,66.16 193.01,67.61 194.33,68.93 v2(194.33,70.12)
  IN3 w0.508: v2(189.98,62.74) 187.94,62.74 187.29,63.39 186.31,63.39 v2(185.36,64.34)
+3.3V_M_UZ8:
  vias: v3(250.03,43.58)
+3.3V_MMI_AUX:
  vias: v3(268.29,42.13)
+3.3V_MMI_IN:
  vias: v2(258.35,45.35) v2(258.36,44.76) v2(266.18,44.43) v2(266.76,44.43)
+3.3V_PGPPD: length 0.8
  BOTTOM w0.254: UC1.Y15 165.42,66.5 v2(165.95,66.5)
  vias: v2(181.98,64.14) v2(182.56,64.14) v3(182.31,63.59)
+3.3V_PGPPE: length 1.9
  TOP w0.203: v2(180.94,63.58) 180.94,62.45 v3(181.52,61.87)
  vias: v2(163.63,67.95) v2(164.27,67.95) v2(180.76,64.15)
+3.3V_RTC_LDO: length 120.8
  TOP w0.508: PD1.3 278.83,13.32 v2(278.12,12.61) ; v2(234.15,34.46) 234.33,34.46 235.3,35.42 235.3,38.7 234.05,39.95 234.05,42.49 233.51,43.02 233.51,44.47 232.45,45.53 232.45,48.84 237.18,53.56 237.18,54.44 237.11,54.5 237.11,59.4 233.45,63.06 232.44,63.06 231.36,64.14 231.36,65.99 230.62,66.73 v3(230.62,68.82) v2(230.62,71.28) ; PR105.2 219.92,66.91 v2(220.28,66.55)
  IN2 w0.508: v2(230.62,71.28) 229.02,69.68 226.25,69.68 226.23,69.65 226.21,69.65 225.86,69.29 225.86,69.28 225.16,68.58 225.16,68.32 225.13,68.29 225.13,68.24 224.13,67.24 221.73,67.24 221.04,66.55 v2(220.28,66.55)
  IN3 w0.508: v2(278.12,12.61) 277.88,12.37 274.33,12.37 273.62,13.08 268.49,13.08 266.99,14.58 266.99,15.98 264.58,18.39 264.58,20.35 263.51,21.42 262.7,21.42 261.33,22.79 258.97,22.79 257.49,24.26 253.12,24.26 252.21,25.18 251.09,25.18 250.13,26.14 250.13,33.07 249.36,33.84 248.78,33.84 247,35.62 247,36.66 246.32,37.34 241.98,37.34 240.78,36.15 236.68,36.15 234.99,34.46 v2(234.15,34.46)
+3.3V_RUN: length 807.5
  TOP w0.203: CV125.1 230.42,90.83 230.47,90.83 230.71,90.58 231.25,90.58 231.5,90.83 UV16.32 ; CV126.1 234.92,94.83 234.61,94.53 UV16.23 ; v2(257.36,31.86) 256.96,31.86 256.69,32.12 254.54,32.12 UN1.9 ; v2(249.26,32.24) 249.41,32.09 UN1.2 ; v2(257.39,32.47) 257.26,32.59 UN1.10 ; UV16.4 234.21,89.56 234.17,89.52 234.17,88.54 CV127.1 ; UV16.29 231.5,92.03 231.26,92.26 230.22,92.26 CV124.1 ; UN1.3 v2(249.26,31.59)
  TOP w0.254: RV251.1 v2(238.11,86.59) ; 98.36,42.7 98.73,43.07 UC8.14 ; RC272.1 183.65,45.11 v2(183.86,45.33) ; v2(215.32,41.82) 215.32,41.45 215.15,41.28 211.33,41.28 209.82,39.77 187.62,39.77 187.34,40.05 RC326.2 186.33,39.74 186.33,38.52 185.03,37.23 172.71,37.23 171.11,38.83 RC59.1
  TOP w0.305: v2(73.95,63.48) 72.44,63.48 67.28,68.65 63.67,68.65 59.81,72.51 57.6,72.51 55.85,70.76 52.9,70.76 50.44,73.22 44.33,73.22 44.05,73.5 v2(30.67,73.5)
  TOP w0.381: CV603.1 201.59,87.29 v2(201.7,87.18) ; v2(196.32,54.66) 196.19,54.53 QC2.5 ; RZ89.1 192.09,61.23 v2(191.76,60.9) ; QC2.2 196.19,51.4 196.06,51.27 v2(196.06,51.02) ; v2(235.7,86.44) 235.62,86.52 RV121.1 RV250.1 ; v2(145.81,71.48) 145.73,71.4 RC179.1 ; v2(190.13,83.11) 190.13,83.24 189.99,83.38 189.99,83.39 189.83,83.55 CV601.1 ; CV128.1 230.26,93.6 230.26,92.62 230.25,92.6 230.25,92.57 230.21,92.53 CV124.1 ; CC287.2 123.34,70.31 v2(123.34,70.04) ; CC30.2 97.71,40.55 98.23,41.08 98.23,41.93 98.32,42.02 98.32,42.63 98.36,42.66 98.36,42.7
  TOP w0.406: v2(237.09,98.21) 237.09,95.57 236.35,94.83 CV126.1
  TOP w0.457: v2(199.43,82.07) 199.27,81.92 CV600.1 ; CV125.1 230.31,91.04 230.31,91.46 v2(230.53,91.69)
  TOP w0.508: RD71.1 205.9,12.22 206.29,11.84 206.29,10.82 v2(205.95,10.49) ; v2(146.99,82.48) 146.14,81.62 146.14,81.11 145.43,80.39 145.43,79.1 145.12,78.79 145.12,76.69 145.45,76.36 145.48,76.36 145.55,76.28 ; RD70.1 230.58,12.02 231.05,12.49 231.05,13.28 230.54,13.8 RD69.1 ; v2(245.61,68.02) 245.58,68.02 245.58,68.05 247.14,69.61 249.43,69.61 RE67.1 ; PR507.1 224.75,102.95 v2(226.66,104.86) ; v2(98.14,49.05) 98.67,48.52 RC137.1 ; v2(124.45,10.29) 124.45,10.67 124.78,11 RD64.1 ; v2(230.92,93.09) 230.92,93.43 230.75,93.6 CV128.1 ; v2(79.72,99.88) 78.95,99.11 RV19.1 ; RE51.1 265.08,72.15 v2(265.54,71.68) 265.75,71.47 265.75,69.65 RE48.1 ; CC30.2 97.27,40.5 v2(97.27,42.04) ; v2(280,14.81) 280.17,14.81 281.02,13.96 281.99,13.96 282.49,14.46 282.49,16.16 RN2.1
  IN1 w0.305: v2(31.38,80.34) 32.34,81.3 33.93,81.3 v2(34.3,81.68)
  IN1 w0.381: v2(189.64,47.72) 189.64,47.92 189.18,48.38 188.57,48.38 186.96,49.99 ; v2(186.31,60.63) 186.98,61.31 191.35,61.31 v2(191.76,60.9)
  IN1 w0.508: v2(243.58,56.79) 242.78,57.58 241.06,57.58 239.99,56.51 236.42,56.51 236.08,56.85 233.51,56.85 232.42,57.94 231.96,57.94 231.52,58.37 231.52,59.53 231.26,59.79 v2(230.89,59.79)
  IN1 w1.27: 188.71,51.9 188.34,51.9 187.47,51.02 187.47,50.5 186.41,49.44 186.41,47.15 187.98,45.58 188.71,45.58 191.46,42.84 202.05,42.84 204.89,45.67 207.68,45.67 208.33,45.02 208.78,45.02
  IN2 w0.457: v2(83.96,83.38) 83.96,83.14 82.07,81.25 78.81,81.25 77.71,80.15 77.71,78.56 78.62,77.65 78.62,74.15 73.42,68.94 73.42,64.01 v2(73.95,63.48)
  IN2 w0.508: v2(123.34,70.04) 123.34,69.82 122.82,69.3 121.68,69.3 121.42,69.55 117.26,69.55 116.85,69.96 114.31,69.96 113.91,69.55 111.47,69.55 110.44,68.52 105.48,68.52 104.51,67.55 101.29,67.55 99.11,65.38 99.11,62.98 98.78,62.65 98.78,49.69 v2(98.14,49.05) ; v2(201.7,87.18) 201.7,84.55 v2(202.63,83.62) ; v2(124.45,10.29) 124.45,10.61 125.07,11.23 145.83,11.23 146.65,12.04 147.48,12.04 v2(148.14,11.38) 150.89,14.13 156.65,14.13 159.3,11.48 204.45,11.48 205.44,10.49 v2(205.95,10.49) 207.2,11.74 227.75,11.74 230.47,14.46 v2(231.51,14.46) ; v2(115.09,95.6) 114.87,95.81 114.17,95.81 113.64,95.28 107.28,95.28 107.14,95.34 107.03,95.38 106.94,95.42 106.67,95.54 106,95.86 105.82,96.04 104.63,96.04 102.37,98.3 97.04,98.3 97.01,98.33
  IN3 w0.254: v2(183.86,45.33) 183.86,45.63 184.14,45.91 186.44,45.91 186.45,45.92 187.13,46.6 189.27,46.6 189.64,46.96 v2(189.64,47.72)
  IN3 w0.305: v2(30.67,73.5) 27.34,73.5 24.06,76.77 24.06,77.84 24.62,78.39 29.74,78.39 31.38,80.03 v2(31.38,80.34)
  IN3 w0.508: v2(79.72,99.88) 89.85,99.88 90.7,100.72 92.61,100.72 93.81,99.52 v2(93.81,98.4) ; v2(114.61,95.1) 114.49,94.97 107.09,94.97 106.88,95.19 106.4,95.38 106.39,95.38 106.3,95.38 106.12,95.38 104.72,95.38 101.62,98.48 v2(95.24,98.48) ; v2(91.83,88.52) 91.83,89.12 91.45,89.5 90.88,89.5 90.31,90.07 83.35,90.07 80.86,87.58 80.86,84.74 81.67,83.93 82.31,83.93 82.86,83.38 v2(83.96,83.38)
  IN3 w1.524: 234.67,84.42 234.67,83.18 233.77,82.28 233.77,80.97 233.95,80.8 233.95,74.96 234.8,74.12 234.98,74.12 235.56,73.54 235.57,73.54 236.36,72.75 236.36,71.56 239,68.91 240.6,68.91 241.8,67.72
  IN4 w0.381: v2(123.34,70.04) 132.03,70.04 134.01,72.03 137.57,72.03 139.36,70.23 145.02,70.23 145.81,71.02 v2(145.81,71.48)
  IN4 w0.508: v2(227.29,104.86) 227.29,105.26 226.99,105.57 226.43,105.57 225.36,104.5 224.21,104.5 222.86,103.15 219.32,103.15 217.97,104.5 217.97,106.46 216.72,107.7 216.72,108.16 215.33,109.55 211.8,109.55 208.11,105.87 v2(207.73,105.87) ; 190.79,52.91 194.12,52.91 196.01,51.02 v2(196.06,51.02) ; v2(245.58,67.36) 245.58,66.41 244.57,65.4 244.57,62.35 243.58,61.36 v2(243.58,56.79)
  IN4 w1.016: 116.75,95.31 117.68,96.24 123.2,96.24 123.56,96.6 135.42,96.6
  IN4 w1.27: 187.29,60.84 188.65,59.47 188.65,57.46 189.88,56.23 189.88,55.35
  BOTTOM w0.203: UV26.57 189.45,86.13 189.11,86.47 189.11,86.57 189.12,86.57 189.12,86.6 v2(189.1,86.6) ; v2(199.43,82.07) 199.22,82.28 199.22,83.45 UV26.30 ; v2(201.7,87.18) 201.35,87.18 200.56,87.96 199.91,87.96 199.27,87.33 UV26.21 ; CV604.1 189.7,90 190.16,89.54 191.97,89.54 192.29,89.22 192.29,88.05 UV26.5
  BOTTOM w0.254: v2(92.32,87.96) 92.75,87.53 JEDP1.10
  BOTTOM w0.305: RC335.1 34.3,80.73 v2(34.3,81.68) ; v2(31.38,80.34) 31.68,80.64 RC336.1
  BOTTOM w0.381: 107.58,95.38 107.51,95.38 107.48,95.41 106.89,95.41 106.67,95.19 106.67,94.46 107.91,93.22 QV3.2 ; CV604.1 189.37,90.43 187.72,92.08 187.72,93.84 187.81,93.93 187.81,94.71 188.07,94.97 ; v2(196.32,54.66) 196.28,54.62 RC318.1 RC319.1 196.09,52.91 196.09,51.05 v2(196.06,51.02)
  BOTTOM w0.457: RV602.1 200.54,92 201.3,92 201.85,91.45 201.85,90.47 202.17,90.15 202.17,88.19 201.7,87.72 v2(201.7,87.18) ; 204.71,94.66 205.4,95.34 205.4,100.5 206.59,101.7 206.59,104.73 v2(207.73,105.87) ; 204.71,94.66 202.26,94.66 ; 204.71,94.66 205.65,93.72 205.65,91.85 RC181.1 ; v2(184.94,89.62) 184.94,88.21 RV614.1 ; RV604.1 202.6,83.65 v2(202.63,83.62) ; 201.93,94.32 200.61,93
  BOTTOM w0.508: RC346.2 230.24,59.79 v2(230.89,59.79) ; RC281.1 244.74,86.29 245.22,86.29 245.5,86.57 v2(245.73,86.57) ; v2(83.96,83.38) 83.41,83.38 83.1,83.06 RV623.1 ; v2(114.61,95.1) 110.91,95.1 QZ1.3 109.79,93.98 108.62,93.98 108.52,94.09 ; RV615.1 v2(185.58,89.62) ; RV615.1 186.32,89.11 RV601.1 ; RV615.1 RV603.1 185.89,90.63 185.31,91.21 185.31,94.28 186.01,94.97 190.35,94.97 RV610.1 191.76,95.04 201.21,95.04 201.93,94.32 202.26,94.66 ; v2(245.58,67.36) 245.58,67.99 v2(245.61,68.02) 246.41,68.82 247.84,68.82 249.84,70.82 255.64,70.82 256.75,71.94 256.75,72.27 257.11,72.62 257.64,72.62 258.58,71.68 v2(265.54,71.68) ; v2(146.99,82.48) 147.1,82.38 148.34,82.38 148.73,82.76 148.73,87.78 151.1,90.15 151.1,92.02 v2(152,92.93) ; v2(115.09,95.6) 115.49,95.6 117.16,93.93 117.16,93.02 QV8.3 ; v2(97.27,42.04) 97.27,42.07 96.4,42.93 96.4,45.22 98.14,46.95 v2(98.14,49.05) ; RV605.1 201.97,81.36 201.97,81.14 201.53,80.7 200.48,80.7 199.81,81.37 199.81,81.69 v2(199.43,82.07) ; 189.6,82.48 189.57,82.5 188.1,82.5 186.63,83.98 186.45,83.98 186.32,84.11 185.94,84.49 185.59,84.49 185.36,84.71 185.36,84.74 185.08,85.02 RV611.1 RV612.1 RV613.1 RV614.1 ; PR612.1 v2(73.95,63.48) ; RV602.1 199.78,91.4 199.78,92.18 200.61,93
  vias: v2(139.2,98.66) v2(139.58,98.15) v2(152.61,92.93) v2(153.24,92.9) v2(179.34,89.14) v2(184.8,68.81) v2(185.25,68.41) v2(185.7,61.23) v2(185.68,60.63) v2(189.44,53.8) v2(189.47,53.19) v2(225.82,33.91) v2(225.79,33.25) v2(226.18,101.51) v2(233.23,87.84) v2(239.97,83.42) v2(254.02,40.37) v2(254.49,40.76) v2(255.42,37.31) v2(255.48,36.54) v2(255.75,36) v2(255.89,36.97) v2(256.11,35.3) v2(256.21,36.45) v2(256.35,35.86) v2(262.83,10.8) v2(265.52,47.45) v2(265.95,47.02) v2(271.11,16.51) v2(271.72,16.45) v2(271.72,15.86) v2(272.31,15.73) v2(272.68,16.18) v2(273.09,15.75) v2(278.34,42.7) v2(279.06,42.7) v2(279.54,50.3) v2(279.79,49.74) v2(291.94,82.95) v2(291.94,82.36) v2(292.52,82.95) v2(292.52,82.36) v2(294.01,42.65) v2(294.01,42.07) v2(294.59,42.65) v2(294.59,42.07) v3(159.26,94.07)
