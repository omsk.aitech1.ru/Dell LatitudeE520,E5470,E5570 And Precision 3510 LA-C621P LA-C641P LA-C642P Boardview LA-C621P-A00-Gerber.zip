# Allegro board LAC621PR10-0924-A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_RUN_AUDIO: length 72.7
  TOP w0.203: UA1.9 275.67,32.48 274.74,31.55 274.74,31.44 CA11.1 274.21,31.1 273.98,30.86 273.73,30.86
  TOP w0.254: v2(273.09,37.1) 273.55,36.64 RA18.1
  TOP w0.381: v2(271.94,30.05) 271.97,30.05 272.78,30.86 273.73,30.86 ; RA38.2 277.61,26.16 277.05,26.72 v2(276.99,26.72)
  TOP w0.508: RA26.1 272.76,22.05 272.94,21.87 277.55,21.87 278.53,20.88 280.01,20.88 280.62,21.5 280.62,21.58 ; RA4.1 286.47,43.95 285.05,45.37 281.14,45.37 ; 280.62,21.58 283.95,21.58 284.36,22 284.36,24.05 RA45.2 ; 280.62,21.58 279.43,22.78 279.43,23.71 278.96,24.17 RA29.1 278.76,24.17 278.02,24.91 278.02,25.58 RA38.2 ; RA1.1 296.3,28.53 v2(296.56,28.78)
  IN1 w0.508: v2(280.53,42.65) 280.53,42.68 281.67,43.81 288.64,43.81 289.21,43.25 289.96,43.25 293.22,39.98 295.35,39.98 295.71,39.62 295.71,37.13 296.98,35.86 296.98,29.21 v2(296.56,28.78)
  IN2 w0.457: v2(275.01,35.35) 274.65,35.35 273.85,34.55 273.85,33.57 273.02,32.74 273.02,31.13 v2(271.94,30.05)
  vias: v2(279.89,42.63) v3(281.14,42.66)
+3.3V_RUN_AUDIO_UZ5:
  vias: v3(280.27,48.24)
+3.3V_RUN_CARD:
  vias: v2(258.74,41.74) v2(259.32,41.71) v2(271.92,37.09) v2(271.92,36.5) v3(270.01,32.53) v3(270.22,34.61) v3(270.56,36.47)
+3.3V_RUN_DIMM1: length 2.4
  BOTTOM w0.305: v2(143.65,22) 144.37,21.27 JDIMM1.255
  vias: v2(142.24,21.47) v2(142.33,22.05) v2(143.01,22.05) v3(144.49,22.88)
+3.3V_RUN_DIMM2:
  vias: v2(227.8,17.61) v2(227.8,16.97) v3(228.54,17.36)
+3.3V_RUN_UZ3:
  vias: v2(252.68,38.21)
+3.3V_RUN_VDDA: length 4.9
  TOP w0.203: UV8.J4 v2(219.43,86.87) ; UV8.H5 v2(218.78,87.52) ; UV8.K6 v2(220.08,88.17) ; UV8.K7 v2(220.08,88.82)
  TOP w0.254: UV8.H12 v2(218.13,92.07) ; v2(214.88,91.42) 215.21,91.09 UV8.C10
  BOTTOM w0.076: v2(214.88,91.42) 214.91,91.42 v3(215.48,91.99)
  BOTTOM w0.381: CV98.1 218.13,92.7 v2(218.13,92.07) ; CV100.1 214.35,91.42 v2(214.88,91.42)
+3.3V_RUN_VDDIO: length 7.2
  TOP w0.203: v2(220.08,92.72) 219.76,92.39 UV8.K12 ; UV8.K3 219.76,86.54 v2(220.08,86.87) UV8.K4 ; v2(214.88,92.72) 215.21,92.39 UV8.C12
  TOP w0.254: UV8.C4 v2(214.88,86.87) 215.21,86.54 UV8.C3 ; v2(214.88,92.07) 215.21,91.74 UV8.C11 ; v2(220.08,92.07) 219.76,91.74 UV8.K11 ; UV8.B6 214.56,88.49 v2(214.88,88.17) UV8.B5
  BOTTOM w0.381: CV96.1 214.18,86.87 v2(214.88,86.87) ; v2(214.88,92.07) 214.68,92.07 214.34,92.41 CV95.1
  BOTTOM w0.508: v2(220.08,86.87) 220.48,86.87 220.66,86.69 CV97.1
  vias: v3(220.07,91.48)
+3.3V_RUN_VMM: length 120.5
  TOP w0.254: v2(128.15,89.88) 128.69,90.41 v3(130.95,90.41) 131.27,90.41 133.7,92.85 136.54,92.85 138.48,94.79 147.62,94.79 v2(147.65,94.76)
  TOP w0.305: v2(207.71,93.5) 208.16,93.5 208.37,93.3 RV85.2
  TOP w0.508: v2(207.71,93.5) 207.43,93.5 206.97,93.04 RV86.1 ; v2(209.3,96.38) 209.77,95.91 RV519.1 210.4,95.92 RV518.1 ; v2(230.52,85.34) 230.36,85.5 RV88.1
  IN3 w0.254: v2(206.04,89.7) 205.92,89.59 v2(203.72,89.59) 202.75,88.62 194.49,88.62 193.53,89.58 188.53,89.58 184.51,93.61 179.55,93.61 178.82,92.88 178.82,92.34 178.82,91.93 177.21,90.33 176.81,90.33 176.8,90.33 173.81,90.33 171.97,92.17 171.97,93.7 170.94,94.74 170.94,95.2 169.71,96.42 158.25,96.42 157.64,97.04 149.93,97.04 v2(147.65,94.76)
  IN3 w0.508: v2(223.48,92.84) 224.29,93.65 226.83,93.65 227.24,93.25 227.24,91.16 226.53,90.45 226.53,88.85 228.59,86.8 229.06,86.8 v2(230.52,85.34)
  BOTTOM w0.254: UV12.14 147.98,91.57 147.9,91.65 CV121.1 ; v2(147.65,94.76) 147.51,94.62 147.51,92.6 CV121.1 ; CV121.1 146.38,92.21 RV91.1 ; RV90.1 125.52,89.2 127.08,89.2 127.38,89.5 CV118.1 127.41,89.67 127.94,89.67 v2(128.15,89.88) 128.18,89.91 128.18,90.28 127.77,90.69 UV11.14
+3.3V_SPI: length 112.8
  TOP w0.254: v2(216.78,48.59) 216.72,48.64 v3(214.93,48.64) 214.11,48.64 212.41,46.94 RC41.2 212.14,46.55 JSPI1.6 ; v2(191.02,54.92) 190.86,54.92 190.51,54.57 190.51,51.84 191.01,51.34 191.01,50.55 RC31.1 191.68,49.88 v2(191.68,49.31)
  IN1 w0.254: v2(201.76,47.3) 200.85,46.38 194.25,46.38 193.4,47.24 193.4,48.4 192.65,49.15 191.83,49.15 v2(191.68,49.31)
  IN3 w0.254: v2(192.49,69.73) 192.66,69.89 193.28,69.89 193.74,69.43 195.25,69.43 v2(196.06,70.25) 196.53,69.78 196.53,69.32 198.51,67.34 198.51,60.88 197.39,59.76 194.21,59.76 192.8,58.34 192.8,57.68 191.58,56.46 191.58,55.47 v2(191.02,54.92) 185.68,54.92 185.09,55.5 182.06,55.5 178.39,51.83 177.4,51.83 176.39,52.84 175.62,52.84 175.01,53.45 171.5,53.45 171.15,53.8 167.07,53.8 164.91,55.96 164.91,57.31 165.21,57.61 165.21,58.79 165.22,58.8 165.22,60.81 164.9,61.13 v2(164.9,62.02)
  BOTTOM w0.254: UC1.AJ16 164.58,62.45 164.9,62.12 v2(164.9,62.02) ; v2(201.76,47.3) 201.76,47.45 202.1,47.78 204.88,47.78 205.18,48.09 207.86,48.09 208.04,47.91 216.09,47.91 v2(216.78,48.59) ; UC6.8 190.58,52.72 190.14,53.16 190.14,53.79 189.85,54.08 CC10.1 189.86,54.33 190.21,54.33 190.79,54.92 v2(191.02,54.92) ; v2(196.06,70.25) 196.06,70.79 RC30.1 ; v2(192.49,69.73) 192.37,69.6 191.5,69.6 191.24,69.34 190.48,69.34 189.83,68.68 CC9.1 189.86,68.53 190.77,68.53 UC5.8
+3.3V_SPI_R: length 3.6
  TOP w0.305: RC41.1 213.32,46.48 212.64,45.8 JSPI1.5
  TOP w0.508: RC276.1 RC289.1 RC41.1
+3.3V_TP: length 21.3
  TOP w0.254: 210.98,35.26 210.98,35.06 210.3,34.37 JKBTP1.12
  TOP w0.508: v2(219.04,32.54) 219.01,32.57 RZ117.1 218.43,31.69 RZ116.1 ; 210.98,35.26 211.42,35.7 215.87,35.7 216.5,36.33 216.5,36.86 216.71,37.08 217.13,37.49 217.53,37.49 218.34,38.3 219.01,38.3 219.82,37.49 221.45,37.49 222.13,36.81
  IN2 w0.508: v2(223.08,33.91) 222.3,33.14 220.17,33.14 219.57,32.54 v2(219.04,32.54)
  vias: v3(222.85,33.09)
+3.3V_TSP: length 22.1
  TOP w0.457: v2(112.84,88.85) 112.84,87.96 111.62,86.74 106.8,86.74 105.3,85.25 101.66,85.25 100.94,85.97 99.52,85.97
  BOTTOM w0.254: v2(98.13,86.39) 98.13,86.85 97.86,87.13 97.42,87.13 97.25,86.96 JEDP1.1
  BOTTOM w0.508: v2(112.84,88.85) 113.33,89.35 113.49,89.35 v3(113.93,89.79) 113.93,90.4 114.34,90.81 QV8.1
+3.3V_VCCHDA: length 2
  TOP w0.381: LC1.2 162.27,62.48 v2(162.27,62.89) 162.27,63.37 CC310.1
  BOTTOM w0.254: UC1.AJ19 162.63,62.53 v2(162.27,62.89)
+3.3V_WLAN:
  vias: v2(244.21,21.26) v2(244.66,20.63) v2(244.87,21.24) v2(245.2,33.33) v2(245.51,33.83) v2(245.81,33.33) v2(246.39,33.33) v2(261.07,21.16) v2(261.66,21.16) v3(244.47,34.65) v3(245.88,20.95) v3(247.39,32.29)
+3.3V_WLAN_UZ3:
  vias: v3(246.7,37.58)
+3.3V_WWAN:
  vias: v2(239.65,60.37) v2(240.09,77.27) v2(240.17,60.66) v2(240.17,60.07) v2(240.31,76.69) v3(238.17,75.8) v3(238.9,71.3) v3(240.05,64.79)
+3.3V_WWAN_UZ2: length 2.8
  TOP w0.508: 244.93,53.3 244.32,53.92 v3(244.32,55.88)
+5V_ALW: length 626
  TOP w0.203: v2(250.18,40.11) 250.02,39.96 UZ3.4 ; 247.31,45.77 247.74,46.21 247.74,48.46 247.8,48.52 247.8,48.53 247.86,48.6 UZ2.4 ; UZ4.4 244.56,46.44 v2(244.66,46.54) ; PU602.9 83.83,62.74 84.7,61.87 v2(85.22,61.87) 85.22,61.93 84.23,62.92 PU602.10 ; v2(273.7,43.21) 274.15,43.21 275.19,44.25 UZ5.4
  TOP w0.254: v2(263.77,32.51) 264.04,32.24 UZ23.4
  TOP w0.305: JUSH1.9 263.96,5.97 264.53,5.4 269.31,5.4 270.53,4.18 275.24,4.18 275.6,4.54 277.42,4.54 278.65,5.78 278.65,8.95 JLED1.1 v2(278.65,9.9) ; 160.33,37.61 UZ26.3
  TOP w0.406: v2(50.86,98.25) 50.93,98.32 PU1.5
  TOP w0.508: v2(229.59,103.56) 229.59,103.95 228.05,105.49 226.29,105.49 225.23,104.43 221.36,104.43 219.53,106.25 217.25,106.25 v2(217.08,106.42) ; v2(278.4,15.85) 278.37,15.88 278.37,16.01 277.86,16.52 277.86,19.67 276.3,21.23 272.03,21.23 271.11,22.15 271.11,22.84 270.52,23.42 269.65,23.42 268.69,24.38 268.69,26.75 269.55,27.6 269.55,29.11 269.25,29.41 269.25,32.12 268.53,32.84 267.28,32.84 ; v2(228.15,96.04) 227.58,95.47 RV662.2 ; v2(50.86,98.25) 50.2,97.59 50.2,94.92 48.07,92.79 33.62,92.79 v2(33.03,92.21) ; PR937.2 v2(22.74,87.91) ; v2(70.83,68.33) 71.73,68.33 72.25,68.85 73.1,69.7 73.11,69.7 73.18,69.78 74.79,69.78 75.26,69.31 75.72,69.31 PR602.2 ; LED3.2 v2(298.5,90.24) ; 160.33,37.61 160.82,37.11 166.34,37.11 170.23,33.23 177.18,33.23 180.25,30.16 180.25,29.21 181.3,28.17 198.2,28.17 199.12,27.26 210.86,27.26 216.02,22.1 221.67,22.1 221.95,21.82 224.89,21.82 225.43,21.29 v2(226.77,21.29) ; PU1500.6 229.98,42.85 230.14,42.7 PC1500.1 v2(230.8,43.39) ; v2(59.17,97.92) 59.94,98.7 60.98,98.7 61.48,98.19 PR9.1
  TOP w1.016: 203.09,79.01 203.94,78.16 205.16,78.16 208.41,74.91
  IN1 w0.508: v2(168.62,89.31) 168.62,91.69 168.36,91.95 v2(168.36,92.44) ; v2(59.17,97.92) 59.17,97.99 58.63,98.53 56.65,98.53 55.66,97.54 54.06,97.54 53.82,97.79 51.33,97.79 v2(50.86,98.25)
  IN2 w0.508: v2(70.83,68.33) 72.53,66.62 72.53,62.93 73.55,61.92 74.59,61.92 75.23,62.55 75.23,63.82 75.5,64.1 76.85,64.1 77.26,63.69 77.26,61.69 79.25,59.69 80.53,59.69 81.36,60.52 83.87,60.52 v2(85.22,61.87)
  IN2 w1.016: 208.42,63.4 207.19,62.17 200.44,62.17 198.82,63.79 198.82,66.87 200.09,68.14 200.09,71.86 200.6,72.37
  IN3 w0.508: 208.46,87.95 208.45,87.95 ; 20.97,88.12 20.97,89.38 22.33,90.74 v2(22.4,90.74) 23.86,92.21 v2(33.03,92.21) ; 20.97,88.12 20.67,87.82 19.18,87.82 v2(18.88,87.53) ; 20.97,88.12 21.01,88.08 22.58,88.08 v2(22.74,87.91) ; 284.29,62.69 284.29,64.66 283.98,64.97 283.98,66.31 284.33,66.67 284.33,67.34 285.44,68.44 285.44,71.43 287.19,73.18 287.19,77.12 289.79,79.72 289.79,83.67 296.36,90.24 v2(298.5,90.24) ; v2(228.15,96.04) 228.15,95.69 227.87,95.41 226.57,95.41 226.21,95.77 225.57,95.77 224.75,94.95 221.62,94.95 220.72,94.05 218.3,94.05 217.27,95.08 213.18,95.08 212.22,96.04 210.06,96.04 209.76,95.75 209.09,95.75 207,93.65 207,89.15 207.46,88.69 ; v2(243.81,44.72) 243.62,44.91 243.62,46.18 243.98,46.54 v2(244.66,46.54) ; v2(273.7,43.21) 272.67,43.21 272.43,43.45 271.52,43.45 270.01,41.94 v2(270.01,41.23)
  IN3 w1.016: 208.46,87.95 209.52,86.89 209.52,85.82 205.53,81.83 202.1,81.83 ; 169.21,90.92 170.35,89.78 172.4,89.78 174.1,88.08 177.62,88.08 178.4,88.87 178.4,90.05 180.42,92.07 184.42,92.07 188,88.48 189.96,88.48 191.05,87.39 197.86,87.39 201.08,84.17 201.08,82.19 201.06,82.21
  IN3 w4.064: 216.16,28.69 216.12,28.65 151.1,28.65 149.51,30.24 92.45,30.24
  IN4 w2.032: 72.05,84.99 70.62,83.57 67.8,83.57 66.34,82.1 66.34,76.88 68.21,75.01 68.21,69.96 63.41,69.96 60.34,73.03 58.42,73.03
  BOTTOM w0.305: v2(228.15,96.04) 228.15,95.91 228.49,95.57 UV28.3 ; v2(168.62,89.31) 168.62,89.18 168.28,88.84 168.28,88.83 168.27,88.83 168.27,88.47 168.28,88.46 168.28,88.27 168.56,88 UZ20.3
  BOTTOM w0.381: UZ19.3 168.11,91.7 168.36,91.95 v2(168.36,92.44) ; v2(168.62,89.31) 168.62,89.87 168.27,90.23 167.54,90.23 166.66,89.34 UZ21.3
  BOTTOM w0.508: v2(75.98,49.31) 77.3,49.31 78.19,48.42 78.19,46.89 79.12,45.96 80.85,45.96 81.32,45.5 92.49,45.5 93.89,46.89 PR201.2 94.02,49.42 PR205.1 ; v2(278.65,9.9) 279.07,10.31 279.07,14.29 278.87,14.49 278.85,14.49 278.65,14.7 278.65,15.6 v2(278.4,15.85) ; PU502.6 PC507.1 217.52,105.98 v2(217.08,106.42) ; v2(266.21,32.86) 266.38,32.86 266.89,33.37 266.89,39.91 268.21,41.23 v2(270.01,41.23) ; v2(229.59,103.56) 229.12,103.09 229.12,97.32 228.15,96.35 v2(228.15,96.04) ; v2(22.4,90.74) 22.85,90.29 JUART1.1
  BOTTOM w1.016: 208.5,74.74 207.23,76.01 201.39,76.01 201.37,76 201.34,76 201.08,75.74 200.41,75.74 200.04,75.37 200.04,75.01 200.01,74.98 200.01,74.94 199.96,74.89 199.96,74.65
  vias: v2(18.3,86.06) v2(18.88,86.06) v2(19.52,86.06) v2(55.31,72.24) v2(55.31,71.66) v2(55.92,72.22) v2(55.92,71.63) v2(72.3,87.25) v2(72.3,86.64) v2(73.04,87.3) v2(73.01,86.67) v2(87.57,33.02) v2(87.59,32.44) v2(88.18,33.05) v2(88.18,32.41) v2(88.78,33.02) v2(88.76,32.41) v2(89.37,33.02) v2(89.37,32.41) v2(200.37,73.74) v2(200.78,73.29) v2(202.15,80.43) v2(202.6,80.04) v2(208.14,73.87) v2(208.63,64.63) v2(208.88,73.87) v2(209.43,64.11) v2(209.43,63.46) v2(209.76,64.62) v2(210.04,63.46) v2(210.1,64.14) v2(210.73,64.14) v2(210.65,63.48) v2(211.34,64.16) v2(211.26,63.49) v2(243.62,44.1) v2(244.21,44.07) v2(244.33,36.07) v2(244.44,44.66) v2(244.36,36.66) v2(244.79,44.1) v2(244.92,36.05) v2(245.05,44.66) v2(244.95,36.66) v2(245.53,36.66) v2(245.5,36.05) v2(246.14,36.66) v2(246.09,36.07) v2(266.18,32.2) v2(266.16,31.59) v2(281.4,64.82) v2(282.38,60.57) v2(282.76,61.04) v2(283.15,60.54) v2(283.32,61.21) v2(283.73,60.71) v3(204.98,57.17) v3(205.6,61.91) v3(209.04,74.46)
+5V_ALW2: length 102.8
  IN1 w0.508: v2(221.22,59.64) 222.03,58.83 224.5,58.83 224.84,59.18 225.34,59.18 226.96,60.8 228.93,60.8 229.32,60.41 229.32,58.45 230.46,57.31 232.16,57.31 233.25,56.21 v2(235.55,56.21)
  IN3 w0.508: v2(263.46,12.41) 263.46,10.5 262.49,9.53 256.78,9.53 256.14,10.17 256.14,11.96 255.71,12.39 255.71,13.91 254.31,15.32 252.13,15.32 250.55,16.9 241.41,16.9 240.61,17.69 v2(240.61,18.56)
  BOTTOM w0.254: PU102.15 222.01,60.07 221.86,59.92 221.86,59.26 PC126.1
  BOTTOM w0.508: v2(240.61,18.56) 238.66,18.56 236.36,20.85 236.36,22.71 235.16,23.91 235.16,24.91 234.63,25.44 234.63,27.26 235.18,27.8 236.35,27.8 238.16,29.62 238.16,29.65 239.84,31.32 240.06,31.32 241.62,32.88 242.71,33.97 242.71,39.06 241.91,39.86 241.91,41.33 242.43,41.85 242.43,42.55 242.52,42.64 242.52,45.97 242.3,46.18 242.3,50.83 241.34,51.79 241.34,52.67 240.85,53.16 240.05,53.16 240.04,53.15 238.53,54.66 237.1,54.66 v2(235.55,56.21) ; PC126.1 221.4,58.93 221.22,59.11 v2(221.22,59.64)
+5V_ALW2_R:
  vias: v3(264.5,10.33)
+5V_ALWP: length 42.5
  TOP w0.254: v2(222.59,57.33) 222.95,57.69 PR115.1
  IN2 w0.254: v2(208.16,60.61) 208.11,60.56 208.11,57.53 209.94,55.71 221.55,55.71 222.59,56.75 v2(222.59,57.33) ; v2(222.36,59.67) 222.36,57.89 221.98,57.51 221.98,56.75 221.37,56.14 210.07,56.14 208.49,57.71 208.49,60.1 208.75,60.35 v2(208.75,60.61)
  BOTTOM w0.254: v2(222.36,59.67) 222.46,59.76 PU102.14 ; PR115.1 222.95,57.69 v2(222.59,57.33)
  vias: v2(207.56,60.61) v2(208.09,61.24) v2(208.75,61.27) v2(209.33,61.24) v2(209.38,60.61) v2(209.97,61.27) v2(210,60.63) v3(207.36,61.26)
+5V_HDD: length 14.2
  TOP w0.508: v3(277.51,20.95) 278.44,20.02 RN1.1
  BOTTOM w1.524: 269.23,26.27 269.33,26.37 270.39,26.37 271.61,25.15 271.61,22.46 273.16,20.91 276.85,20.91 277.68,20.07
  vias: v2(267.87,28.83) v2(268.09,28.29) v2(268.15,27.7) v2(278.68,19.38) v3(268.76,28.09) v3(278.58,18.59)
+5V_HDD_UZ2:
  vias: v3(267.78,31.94)
+5V_RUN: length 276.5
  TOP w0.203: UV16.16 238.41,92.43 239.03,93.04 CV144.1
  TOP w0.254: PC685.1 100.6,84.15 v2(100.47,84.28) 100.06,84.69 98.84,84.69 97.32,83.17 97.32,79.25 95.47,77.4 v2(94.91,77.4)
  TOP w0.305: JKBTP1.5 206.8,34.41 205.73,35.48 CZ29.1
  TOP w0.508: CZ29.1 204.41,37.42 214.58,37.42 v2(215.4,38.23) ; CV144.1 v2(240.12,93.93)
  IN1 w0.381: 106.97,70.07 108.33,71.43 109.28,71.43 110.35,72.5 110.35,75.98 108.11,78.21 108.06,78.21 107.3,78.97 100.54,78.97 99.73,78.16 95.67,78.16 v2(94.91,77.4)
  IN1 w0.508: v2(96.13,56.72) 96.47,56.72 98.59,58.84 98.59,63.16 99.86,64.43 99.86,66.64 101.21,67.98 v2(101.21,68.38) 101.96,67.63 104.54,67.63 106.97,70.07
  IN3 w0.508: v2(264.67,16.14) 262.04,16.14 259.96,14.06 259.96,12.92 260.9,11.98 261.64,11.98 262.19,11.42 v2(262.19,10.77)
  IN3 w1.016: 232.09,74.1 232.09,74.05 233.49,72.65 233.49,72.57 233.54,72.52 233.54,71.43 234.43,70.54 234.43,69.09 234.78,68.74 ; 245.2,57.31 246.14,56.37 246.14,53.38 246,53.24 246,49.87 246.89,48.98
  IN3 w1.524: 210.38,37.21 210.15,36.98 130.32,36.98 127.34,39.96 104.31,39.96 101.51,37.16 97.24,37.16 96.48,37.93 96.48,41.25 95.99,41.74 95.99,45.03 93.99,47.02 93.99,49.58 95.01,50.6 95.01,55.88
  IN4 w0.508: v2(264.67,16.14) 264.4,16.14 263.77,16.77 263.77,18.24 264.63,19.1 264.63,20.73 263.61,21.75 263.61,26.59
  BOTTOM w0.203: PU603.2 93.5,76.46 93.53,76.43 93.79,76.43 ; PC677.1 100.09,67.73 99.65,67.29 PU605.2
  BOTTOM w0.254: 93.79,76.43 94.09,76.43 PC661.1 94.45,76.81 94.91,77.27 v2(94.91,77.4) ; v2(100.47,84.28) 100.55,84.2 PU606.6
  BOTTOM w0.381: v2(101.21,68.38) 101.21,67.86 PC677.1
  BOTTOM w0.508: v2(243.45,65.31) 244.46,66.32 248.44,66.32 248.96,66.84 248.96,67.62 250.82,69.49 255.88,69.49 v2(256.6,70.21)
  vias: v2(64.89,76.53) v2(64.88,75.94) v2(64.88,75.34) v2(64.86,74.76) v2(74.71,93.27) v2(75.32,93.27) v2(75.91,93.27) v2(76.11,59.36) v2(76.44,58.8) v2(76.49,93.27) v2(76.62,59.67) v2(231.91,83.82) v2(232.4,83.44) v2(245.56,40.78) v2(245.66,41.36) v2(246.13,40.94) v2(246.18,41.68) v2(246.72,41.94) v2(246.69,41.28) v2(247.31,41.99) v2(247.27,41.38) v2(264.3,26.89) v2(264.87,27.62) v2(264.88,27.01) v2(271.97,44.43) v2(272.1,45.01) v2(272.55,44.43) v2(272.66,45.22) v2(273.06,44.78) v3(247.05,40.58)
+5V_RUN_AUDIO: length 3.1
  TOP w0.508: LA5.2 v2(286.6,21.44)
  vias: v2(271.31,40.82) v2(271.33,40.19) v3(270.52,39.9)
+5V_RUN_AUDIO_UZ5:
  vias: v3(274.16,48.02)
+5V_RUN_PVDD: length 2.3
  TOP w0.203: 277.56,37.27 277.71,37.12 UA1.46 ; UA1.41 279.71,37.79 279.9,37.98
  vias: v2(272.44,41) v2(273.02,41) v2(280.33,41.2) v2(280.91,41.2) v2(281.49,41.2) v3(276.6,38.67)
+5V_RUN_UZ4:
  vias: v3(241.82,43.4)
+5V_USB_CHG_PWR:
  vias: v2(284.92,65.79) v2(285.53,65.77) v2(285.51,65.17) v2(286.13,65.76) v2(286.12,65.17) v2(287.8,61.01) v2(288.44,61.6) v2(288.45,61) v2(289.03,61.01) v2(289.05,61.6) v3(284.5,59.79) v3(287.43,57.83)
+GND_CHASSIS:
  vias: v2(283.1,95.27) v2(283.2,94.33)
+VCC_1P8: length 18.4
  IN4 w0.508: v2(178.12,63.59) 177.13,64.58 176.57,64.58 175.91,65.24 173.93,65.24 173.7,65.47 173.7,65.83 171.58,67.95 167.9,67.95 167.71,68.14 166.84,68.14 166.49,67.78 v2(166.49,67.53)
  BOTTOM w0.254: v2(166.49,67.53) 166.49,67.88 UC1.U12 UC1.U11 ; v3(177.06,63.83) 177.3,63.59 v2(178.12,63.59)
  BOTTOM w0.508: RC313.2 179.11,63.77 CC222.1 v2(178.12,63.59)
+VCC_CORE: length 46.5
  TOP w0.381: PC1066.1 155.18,68.18 v2(154.72,68.18) ; PC1073.1 152.69,68.05 v2(152.36,68.05) ; PC1064.1 152.67,69.24 v2(152.36,69.24)
  TOP w0.508: CC283.2 CC284.2 160.64,91.93 158.48,89.77 v2(154.16,89.77)
  BOTTOM w0.203: UC1.K40 150.96,72.21 ; UC1.K40 150.2,72.21 ; UC1.K40 150.58,71.83 ; UC1.K40 150.58,72.59 ; 149.28,72.21 UC1.K42 ; UC1.K42 149.66,72.59 ; UC1.K42 150.04,72.21 ; UC1.K42 149.66,71.83 ; 154.16,72.67 UC1.J33 ; UC1.J33 153.4,72.67 ; UC1.J33 153.78,72.29 ; UC1.J33 153.78,73.05 ; 151.49,71.83 UC1.K38 ; UC1.K38 151.87,72.21 ; UC1.K38 151.49,72.59 ; UC1.K38 151.11,72.21 ; v2(152.41,71.7) UC1.K37 ; v2(153.12,77.8) 153.16,77.77 UC1.A34 ; 153.32,71.83 UC1.K35 ; UC1.K35 153.7,72.21 ; UC1.K35 152.94,72.21 ; UC1.K35 153.32,72.59 ; UC1.AL33 154.31,61.37 ; UC1.AL33 154.69,60.99 ; UC1.AL33 155.07,61.37 ; 150.58,61.46 UC1.AK40 ; UC1.AK40 150.96,61.84 ; UC1.AK40 150.58,62.22 ; UC1.AK40 150.2,61.84 ; 155.21,73.07 UC1.J30 156,73.07 ; 152.33,72.67 UC1.J37 ; UC1.J37 151.57,72.67 ; UC1.J37 151.95,72.29 ; UC1.J37 151.95,73.05 ; UC1.K33 154.59,72.21 154.6,72.2 ; UC1.K33 154.23,72.59 ; UC1.K33 154.23,71.83 ; UC1.K33 153.85,72.21 ; UC1.K37 152.79,72.21 ; UC1.K37 152.41,72.59 ; UC1.K37 152.02,72.21 ; 153.32,62.22 UC1.AK35 ; UC1.AK35 153.32,61.46 ; UC1.AK35 152.94,61.84 ; v2(150.95,77.76) 150.68,77.49 UC1.A39 ; UC1.K43 148.69,72.21 148.65,72.17 v2(148.65,71.71) ; UC1.K43 149.13,72.21 ; UC1.K43 148.75,71.83 ; UC1.K43 148.75,72.59 ; 150.5,72.67 UC1.J40 ; UC1.J40 149.74,72.67 ; UC1.J40 150.12,72.29 ; UC1.AL37 152.86,61.75 ; UC1.AL37 153.24,61.37 ; UC1.AL37 152.48,61.37 ; UC1.AL37 152.86,60.99 ; 151.49,61.46 UC1.AK38 ; UC1.AK38 151.49,62.22 ; UC1.AK38 151.11,61.84 ; UC1.AK37 152.41,61.95 152.64,62.18 ; UC1.AK37 152.79,61.84 ; UC1.AK37 152.41,61.46 ; 154.23,62.22 UC1.AK33 154.23,61.46 ; UC1.AL40 151.03,60.99 ; UC1.AL40 150.65,61.37 ; UC1.AL40 151.03,61.75 ; UC1.AL40 151.42,61.37 ; UC1.A44 v2(148.2,77.74)
  BOTTOM w0.381: v2(155.41,77.55) 155.41,77.55 155.64,77.32 UC1.A30
  vias: v2(104.84,73.03) v2(104.81,72.34) v2(104.86,75.09) v2(104.86,74.4) v2(104.86,73.69) v2(105.52,72.29) v2(105.57,75.06) v2(105.57,74.4) v2(105.6,73.71) v2(105.57,73) v2(107.53,74.68) v2(107.53,73.26) v2(107.83,73.94) v2(108.09,69.93) v2(108.19,74.65) v2(108.19,73.26) v2(108.44,73.94) v2(108.75,69.93) v2(108.83,74.63) v2(108.83,73.23) v2(109.1,73.92) v2(109.49,74.6) v2(109.51,73.23) v2(109.46,69.93) v2(110.15,69.96) v2(111.49,77.93) v2(111.49,74.76) v2(111.49,71.58) v2(112.89,77.93) v2(112.89,74.76) v2(112.89,71.58) v2(114.29,77.93) v2(114.29,74.76) v2(114.29,71.58) v2(115.68,71.58) v2(117.08,71.58) v2(118.48,71.58) v2(119.87,71.58) v2(149.47,66.6) v2(149.49,65.76) v2(149.47,65) v2(149.47,63.99) v2(150.05,69.3) v2(150.02,68.13) v2(150.1,73.42) v2(150.06,71.84) v2(150.06,71.25) v2(151.93,73.46) v2(151.95,60.51) v2(152.39,71.11) v2(152.95,65) v2(152.95,63.99) v2(152.86,60.51) v2(153,66.45) v2(152.97,65.76) v2(153.81,73.44) v2(154.75,71.81) v2(154.72,69.37) v2(154.75,71.21) v2(155.64,73.44) v2(156.4,67.47) v2(156.4,66.6) v2(156.42,65.76) v2(156.4,65) v2(156.4,63.99) v3(115.92,77.82)
+VCC_CORE_G0: length 3.3
  TOP w0.203: T122.1 156.33,69.76 v2(156.33,70.24)
  BOTTOM w0.254: v2(156.33,70.24) 155.89,70.24 155.43,70.69 155.43,71.99 155.21,72.21 UC1.K32
+VCC_CORE_G1: length 2.8
  TOP w0.102: T123.1 155.59,63.34 154.93,63.34 154.69,63.1 v2(154.69,62.06)
  BOTTOM w0.254: UC1.AK32 154.92,62.06 v2(154.69,62.06)
+VCC_GT: length 29
  TOP w0.381: v2(140.45,65.36) 140.45,65.76 PC1130.1 ; v2(144.31,68.23) 144.31,68.63 PC1134.1 ; PC1132.1 140.42,68.63 v2(140.42,68.23) ; PC1028.1 142.94,65.78 v2(142.94,65.36) ; v2(144.13,65.36) 144.13,65.78 PC1129.1 ; v2(143.34,71.61) 143.34,71.09 PC1029.1 ; PC1131.1 143.01,68.63 v2(143.01,68.23) ; v2(141.74,68.23) 141.74,68.66 PC1137.1 ; v2(142.12,71.58) 142.12,71.06 PC1136.1 ; PC1027.1 141.64,65.78 v2(141.64,65.38) ; PC1133.1 139.15,65.79 v2(139.15,65.36) ; v2(139.13,68.23) 139.13,68.66 PC1138.1
  IN2 w0.508: v2(143.04,77.83) 143.53,77.33 v2(145.9,77.33)
  BOTTOM w0.076: UC1.J53 142.8,72.29
  BOTTOM w0.102: UC1.J55 141.89,73.05 ; UC1.J52 143.72,73.05
  BOTTOM w0.152: UC1.J46 146.46,73.05 ; UC1.J56 140.98,73.05
  BOTTOM w0.203: UC1.K55 141.97,72.21 ; v2(140.78,77.73) 140.77,77.72 UC1.A58 ; UC1.J50 144.63,72.29 ; UC1.K48 146.01,72.59 ; v2(145.9,77.33) 145.9,77.01 UC1.A48 ; UC1.J58 140.06,72.29 ; UC1.W63 137.93,66.97 ; UC1.M62 138.78,70.56 ; UC1.K50 145.09,72.59 ; UC1.T62 138.78,68.73 ; UC1.K56 141.43,72.59 ; UC1.J60 139.53,72.67 ; UC1.Y62 138.78,66.9 ; UC1.L63 138.31,71.01 ; UC1.K53 143.26,72.59 ; UC1.A53 143.12,76.97 143.12,77.75 v2(143.04,77.83) ; UC1.J45 147.38,72.29 ; v2(138.04,77.98) 138.13,77.88 138.13,77.71 138.17,77.66 138.17,77.64 138.24,77.58 138.24,77.56 138.29,77.51 UC1.A62 ; UC1.A66 v2(135.81,77.83) ; UC1.N63 138.31,70.1 ; UC1.K52 144.18,72.59 ; UC1.AA63 137.93,66.06 ; UC1.L62 138.4,71.09 ; UC1.J48 145.55,72.29 ; UC1.R63 138.31,69.18 ; UC1.K60 139.99,72.21
  BOTTOM w0.457: PC1024.1 112.89,61.94 v2(112.89,62.34) ; v2(114.39,62.31) 114.39,61.92 PC1025.1
  vias: v2(106.14,55.36) v2(106.14,54.4) v2(106.14,53.43) v2(106.14,52.47) v2(107.1,58.26) v2(107.1,57.29) v2(107.1,56.33) v2(107.1,55.36) v2(107.1,54.4) v2(107.1,53.43) v2(107.1,52.47) v2(107.15,59.2) v2(107.92,65.27) v2(107.92,64.3) v2(107.92,63.34) v2(108.07,59.22) v2(108.07,58.26) v2(108.07,57.29) v2(108.07,56.33) v2(108.07,55.36) v2(108.07,54.4) v2(108.07,53.43) v2(108.07,52.47) v2(108.88,65.27) v2(108.88,64.3) v2(108.88,63.34) v2(109.03,59.22) v2(109.03,58.26) v2(109.03,57.29) v2(109.03,56.33) v2(109.03,55.36) v2(109.03,54.4) v2(109.03,53.43) v2(109.03,52.47) v2(109.85,65.27) v2(109.85,64.3) v2(109.85,63.34) v2(110,59.22) v2(110,58.26) v2(110,57.29) v2(110,56.33) v2(110,55.36) v2(110,54.4) v2(110,53.43) v2(110.81,65.27) v2(110.81,64.3) v2(110.81,63.34) v2(110.96,59.22) v2(110.96,58.26) v2(110.96,57.29) v2(111.67,62.37) v2(111.67,61.41) v2(111.78,65.27) v2(111.78,64.3) v2(111.78,63.34) v2(112.89,67.57) v2(112.94,64.88) v2(113.02,59.69) v2(113.35,63.64) v2(113.45,60.1) v2(113.93,60.51) v2(114.36,67.59) v2(114.39,64.88) v2(115.21,67.61) v2(115.18,66.34) v2(115.15,64.94) v2(115.15,63.49) v2(115.15,61.99) v2(116.55,63.06) v2(116.7,67.57) v2(116.7,64.93) v2(118.12,64.85) v2(118.17,67.56) v2(133.03,69.68) v2(133.03,67.8) v2(133.01,65.97) v2(133.03,65.1) v2(133.69,69.68) v2(133.74,65.97) v2(134.33,67.8) v2(134.33,65.1) v2(134.35,70.62) v2(134.35,69.68) v2(134.38,65.97) v2(135.04,70.62) v2(135.04,67.8) v2(135.04,65.1) v2(135.65,70.64) v2(135.62,69.68) v2(135.62,65.97) v2(135.7,65.13) v2(136.31,70.62) v2(136.33,69.68) v2(136.28,67.8) v2(136.31,65.97) v2(136.38,65.1) v2(136.92,70.62) v2(136.99,67.8) v2(137.6,70.62) v2(137.63,69.68) v2(137.58,65.94) v2(137.65,65.1) v2(139.18,71.63) v2(139.86,71.63) v2(140.5,71.63) v2(140.98,71.96) v2(145.43,69.83) v2(145.43,67.72) v2(145.4,64.98) v2(145.5,68.3) v2(145.48,66.15) v2(145.45,64.11) v2(146.49,71.91) v2(146.77,71.38) v2(147.56,71.63) v3(112.54,59.27)
+VCC_GTUS: length 25.1
  BOTTOM w0.203: 149.66,62.22 UC1.AK42 ; UC1.AK42 149.28,61.84 ; UC1.AK42 149.66,61.46 ; 146.92,61.46 UC1.AK46 ; UC1.AK46 147.3,61.84 ; UC1.AK46 146.92,62.22 ; UC1.AK46 146.54,61.84 ; UC1.AK60 139.6,62.22 ; UC1.AK60 139.22,61.84 ; UC1.AK60 139.6,61.46 ; UC1.AK60 139.99,61.84 ; UC1.AK45 147.83,62.22 ; UC1.AK45 147.83,61.46 ; UC1.AK45 148.21,61.84 ; UC1.AK45 147.45,61.84 ; 148.75,62.22 UC1.AK43 ; UC1.AK43 148.37,61.84 ; UC1.AK43 148.75,61.46 ; UC1.AK43 149.13,61.84 ; UC1.AL56 141.89,61.75 ; UC1.AL56 142.27,61.37 ; UC1.AL56 141.89,60.99 ; UC1.AL56 141.51,61.37 ; 146.01,61.46 UC1.AK48 ; UC1.AK48 145.62,61.84 ; UC1.AK48 146.01,62.22 ; UC1.AK48 146.39,61.84 ; 140.52,62.22 UC1.AK58 ; UC1.AK58 140.14,61.84 ; UC1.AK58 140.52,61.46 ; UC1.AL60 140.06,60.99 ; UC1.AL60 139.68,61.37 ; UC1.AL60 140.44,61.37 ; UC1.AL60 140.06,61.75 ; UC1.AK52 143.8,61.84 ; UC1.AK52 144.18,62.22 ; UC1.AK52 144.18,61.46 ; UC1.AK56 141.43,62.22 ; UC1.AK56 141.43,61.46 ; UC1.AK56 141.81,61.84 ; UC1.AL50 145.93,61.37 ; UC1.AL50 145.55,61.75 ; UC1.AL50 145.17,61.37 ; UC1.AK55 141.97,61.84 ; UC1.AK55 142.35,62.22 ; UC1.AK55 142.73,61.84 ; UC1.AK55 142.35,61.46 ; UC1.AL53 143.72,60.99 ; UC1.AL53 143.34,61.37 ; UC1.AL53 143.72,61.75 ; UC1.AL53 144.1,61.37 ; UC1.AL43 149.21,60.99 ; UC1.AL43 149.21,61.75 ; UC1.AL43 148.82,61.37 ; UC1.AL43 149.59,61.37 ; UC1.AL46 147.38,60.99 ; UC1.AL46 147.76,61.37 ; UC1.AL46 147,61.37 ; UC1.AL46 147.38,61.75 ; UC1.AK50 145.47,61.84 ; UC1.AK50 145.09,62.22 ; UC1.AK50 145.09,61.46 ; 143.26,61.46 UC1.AK53 ; UC1.AK53 142.88,61.84 ; UC1.AK53 143.64,61.84 ; UC1.AK53 143.26,62.22
  vias: v2(140.04,62.23) v2(141.92,62.21) v2(143.75,62.25)
+VCC_SA: length 72
  TOP w0.254: PC637.2 PC633.2 74.99,71.58 PR643.1 ; PC644.1 PR643.1 ; PR643.1 73.67,71.12 v2(73.52,71.12)
  IN3 w0.254: v2(112.19,85.91) 112.01,86.08 112.01,86.63 111.65,87 108.58,87 106.26,84.69 106.26,83.89 105.52,83.15 100.17,83.15 98.87,81.85 96.82,81.85 94.9,79.94 89.59,79.94 89.14,79.49 89.14,78.73 89.14,78.73 89.14,76.29 88.64,75.8 86.33,75.8 85.8,75.26 84.67,75.26 81.34,71.94 74.33,71.94 v2(73.52,71.12)
  BOTTOM w0.076: 160.18,72.96 160.13,73
  BOTTOM w0.127: 156.15,72.75 156.42,73.03 156.42,73.05
  BOTTOM w0.203: 158.88,72.67 UC1.J23 ; UC1.J23 159.26,72.29 ; UC1.J23 159.26,73.05 ; UC1.J23 159.64,72.67 ; UC1.K23 159.72,72.59 ; UC1.K23 159.34,72.21 ; UC1.K23 160.1,72.21 ; UC1.J27 157.82,72.67 ; UC1.J27 157.44,73.05 ; UC1.J27 157.44,72.29 ; UC1.J27 157.05,72.67 ; 156.98,72.59 UC1.K28 157.36,72.21 ; 159.34,61.84 UC1.AK23 159.72,62.22 ; 157.89,72.59 UC1.K27 157.51,72.21 ; UC1.J22 159.8,72.67 ; UC1.J22 160.18,72.29 ; UC1.J22 160.18,72.96 ; UC1.K25 158.81,72.59 ; UC1.K25 158.81,71.83 ; UC1.K25 159.19,72.21 ; 158.43,61.84 UC1.AK25 ; UC1.AK25 158.81,62.22 ; UC1.AK25 159.19,61.84 ; v2(156.13,71.65) 156.13,71.68 156.06,71.75 UC1.K30 156.06,72.67 156.15,72.75
  BOTTOM w0.254: PH604.2 112.24,85.86 v2(112.19,85.91) 112.13,85.91 111.17,84.94 111.17,82.83 111.5,82.5 PL601.2 113.51,82.5 ; v2(73.52,71.12) 73.98,71.58 PR641.2 PR636.2
  vias: v2(116.06,84.43) v2(116.34,83.9) v2(116.7,84.43) v2(117,83.9) v2(117.28,84.43) v2(117.59,83.9) v2(117.89,84.43) v2(118.25,83.9) v2(156.65,69.35) v2(157.51,71.61) v2(157.59,66.25) v2(158.03,69.32) v2(158.38,73.44) v2(158.96,66.25) v2(159.22,62.31) v2(159.33,71.63) v2(159.4,69.3) v3(115.71,83.86)
+VCC_SFR_OC: length 0.7
  BOTTOM w0.254: UC1.AL23 v2(160.18,62.08)
  vias: v3(159.67,43.86)
+VDDA_AVDD1: length 13.6
  TOP w0.203: CA8.1 284.31,31.7 284.12,31.51 283.63,31.51 283.23,31.91 283.06,31.91 282.88,32.08 UA1.27
  TOP w0.508: CA8.1 284.91,31.43 284.3,30.82 CA9.1 284.25,30.81 v2(283.6,30.16) ; v2(286.85,28.27) 287.26,28.27 287.87,27.66 v3(287.87,26.81) 287.87,26.12 287.11,25.35 LA5.1
  IN1 w0.508: v2(286.85,28.27) 285.94,29.19 284.58,29.19 v2(283.6,30.16)
+VDDA_PVDD: length 9.4
  TOP w0.203: CA17.1 285.99,38.12 284.78,38.12 284.72,38.18 284.15,38.18 283.82,37.85 v3(283.25,37.85) 281.8,37.85 280.91,36.96 UA1.38
  TOP w0.508: RA4.2 286.47,40.49 286.41,40.43 CA18.1 286.82,39.42 CA17.1
GND: length 4237.3
  TOP w0.076: UV8.C13 215.21,93.04
  TOP w0.203: UN1.8 256.43,31.59 256.83,31.2 v2(257.34,31.2) ; UN1.5 253.24,28.22 v2(253.12,28.1) ; v2(219.43,92.72) 219.11,92.39 UV8.J12 ; v2(257.34,30.61) 256.75,30.61 256.27,31.09 UN1.7 ; v2(233.52,89.03) 233.81,89.32 UV16.3 ; v2(231.56,93.04) 231.44,92.93 231.44,92.57 231.59,92.43 UV16.28 ; UV16.11 237.01,89.73 237.58,89.16 v2(237.58,88.88) ; PU901.5 v2(26.68,77.44) ; v2(275.22,49.76) 275.22,48.27 275.19,48.24 UZ5.11 UZ5.15 ; UV8.E4 v2(216.18,86.87) ; UZ2.11 v2(247.86,50.25) ; UN1.6 253.74,28.16 v2(253.81,28.1) ; v2(26.84,85.16) 26.68,84.99 PU901.23 ; v2(230.95,91.16) 231.01,91.23 UV16.31 ; UZ4.11 v2(242.91,46.44)
  TOP w0.254: UV8.H10 218.46,91.09 v2(218.78,91.42) ; UV8.J5 v2(219.43,87.52) ; PU901.14 30.94,81.29 v2(31.25,80.98) ; UV8.D4 v2(215.53,86.87) ; UZ23.5 264.04,29.24 263.88,29.09 263.59,29.09 263.44,29.24 v2(263.44,29.59) ; UV8.D9 v2(215.53,90.12) 215.86,89.79 UV8.D8 ; UV8.E11 v2(216.83,92.07) 217.16,91.74 UV8.F11 ; v2(251.07,65.99) 250.8,66.26 JLPDE1.9 ; CZ36.2 249.91,38.35 v2(250.02,38.23) UZ3.11 ; UV8.J8 v2(219.43,90.12) ; UE2.B66 268.9,57.18 v2(269.25,57.53) ; v2(216.83,91.42) 217.16,91.09 UV8.F10 ; UV8.H4 218.46,87.19 v2(218.13,86.87) UV8.G4 ; v2(188.63,68.91) 188.4,69.15 UZ12.23 ; v2(228.28,31.2) 228.07,31.41 UN4.7 ; v2(269.84,64.88) 269.9,64.94 UE2.B18 ; UV8.D5 v2(215.53,87.52) ; UV8.F6 217.16,88.5 v2(216.83,88.82) UV8.F7 ; UV8.C14 214.88,93.37 v2(214.88,93.37) 215.21,93.04 v2(215.53,93.37) ; UV8.D14 v2(215.53,93.37) ; v2(215.53,93.37) 215.86,93.04 UV8.D13 ; CL21.2 271.12,83.46 270.61,83.96 RL12.2 ; CL21.2 CL20.2 ; CL21.2 271.29,83.2 v2(271.57,82.92) ; UZ8.5 247.3,43.44 247.83,43.96 v2(248.05,43.96) ; UV8.J11 219.11,91.74 v2(219.43,92.07) ; v2(191.14,66.01) 191.48,65.67 UZ12.9 ; UZ12.16 192.78,69.17 v2(192.99,69.37) ; UI3.17 283.29,63.83 UI3.14 283.29,66.2 v2(283.04,66.45) ; UV8.F9 217.16,90.44 v2(216.83,90.77) ; UV8.J6 v2(219.43,88.17) ; UV8.G6 218.13,88.17 v2(218.13,88.17) 217.81,87.85 UV8.G5 ; v2(238.57,30.91) 238.11,30.91 237.97,30.77 237.97,30.52 238.11,30.37 UN5.7 ; UV8.G10 v2(218.13,91.42) 218.13,91.42 UV8.G11 ; UV8.F4 v2(216.83,86.87) ; UV8.C5 v2(215.53,88.17) UV8.D6 ; UV8.D7 v2(215.53,88.82) ; v2(88.43,49.89) 88.6,49.72 88.6,49.31 JXDP1.38 ; RPE10.5 279.28,60.65 279.45,60.82 v2(279.45,61.15) RPE10.6 ; UV8.F8 217.16,89.79 v2(216.83,90.12) ; UV8.D10 215.86,91.09 v2(215.53,91.42) 215.53,91.42 UV8.D11 ; UV8.J9 v2(219.43,90.77) ; UV8.L6 220.41,88.5 v2(220.73,88.82) 220.73,88.82 UV8.L7 UV8.L8 ; UV8.J7 v2(219.43,88.82) ; PU901.32 23.1,81.29 v2(22.74,81.64) ; RC311.1 165.69,60.41 166.14,60.86 166.14,60.98 166.42,61.26 CC204.2 ; UV8.G9 v2(218.13,90.77) ; RPE10.7 279.19,61.65 v2(279.44,61.9) 279.2,62.15 RPE10.8 ; UV8.K5 v2(220.08,87.52) ; UV8.G7 v2(218.13,88.82) ; CE18.2 273.85,62.72 273.47,63.1 v2(273.47,63.15) ; UV8.F5 v2(216.83,88.17) ; v2(262.12,24.44) 260.15,24.44 UN7.3 ; UV8.G8 v2(218.13,90.12)
  TOP w0.279: v2(80.71,46.59) 81.11,46.99 JXDP1.8 ; JXDP1.50 91.61,49.49 v2(91.93,49.81) ; JXDP1.14 82.61,47.14 82.36,46.89 v2(82.36,46.84) ; v2(86.5,49.91) 86.02,49.91 85.61,49.51 JXDP1.26 ; v2(94.63,41.95) 94.75,41.84 94.75,41.48 94.59,41.33 94.35,41.33 94.11,41.57 JXDP1.59 ; v2(91.27,40.97) 91.59,41.29 JXDP1.49 ; JXDP1.37 88.61,41.59 88.27,41.25 87.91,41.25 87.68,41.02 v2(87.34,41.02) 87.11,41.25 JXDP1.31 ; JXDP1.2 v2(79.61,46.71) ; JXDP1.20 84.11,47.31 84.02,47.22 84.02,47.19 83.76,46.92 v2(83.76,46.79) ; JXDP1.13 82.61,43.84 v2(82.89,44.12) ; v2(86.18,40.97) 86.11,40.97 85.61,41.47 JXDP1.25 ; JXDP1.19 v2(84.09,41.1) ; JXDP1.32 87.11,48.54 87.11,49.62 87.41,49.91 v2(87.74,49.91) ; v2(81.01,40.97) 81.11,41.07 JXDP1.7
  TOP w0.305: CZ44.2 242.95,43.93 243.4,43.49 v2(243.59,43.49) ; UE2.B11 269.97,62.29 v2(269.84,62.16) ; CL25.2 271.45,79.62 v2(271.61,79.79) ; v2(214.46,43.77) 214.64,43.95 JSPI1.1 ; v2(258.26,36.55) 258.15,36.44 CN2.2 ; v2(266.58,7.57) 267.52,7.57 267.96,8.01 JUSH1.17 ; CZ114.2 161.31,41.51 160.98,41.18 UZ26.5 ; UE2.B60 265.9,57.26 v2(266,57.36) ; JSPI1.2 214.14,44.39 v2(214.01,44.25) ; v2(304.3,42.63) 304.3,43.45 302.96,44.8 JDEG1.10 ; CN49.2 257.54,26.98 v2(257.01,27.51) ; CN19.2 224.35,27.24 224.04,26.93 v2(224.04,26.95) ; v2(229.53,18.41) 229.7,18.23 CD64.2 ; JSPI1.3 213.64,44.61 213.45,44.41 213.45,44.02 v2(213.8,43.67) ; v2(281.15,9.83) JLED1.6 ; UE3.3 228.52,77.57 229.34,78.39 229.34,79.92 228.83,80.43 225.11,80.43 224.62,79.95 UE4.3 224.62,78.7 224.5,78.58 223.82,78.58 223.28,79.11 222.16,79.11 221.3,78.25 221.3,76.42 221.77,75.95 v2(222.51,75.95) ; v2(242.18,79.95) 241.96,79.95 241.62,80.29 CE6.2 ; v2(186.88,72.86) 186.74,72.72 CZ75.2 ; CZ28.2 217.06,38.16 216.83,37.94 216.81,37.94 215.89,37.01 v2(215.89,36.58) 215.56,36.25 210.76,36.25 208.8,34.29 JKBTP1.9 ; v2(153.88,110.09) 153.88,109.01 154.27,108.63 C43.2 ; v2(256.2,83.77) 256.3,83.67 256.3,82.73 RE85.2 ; v2(122.59,70.16) 122.44,70.01 RC141.2 ; CV115.2 224.2,82.11 224.4,81.91 224.4,81.68 224.74,81.33 v2(225.46,81.33) ; RC338.2 164.25,61.67 163.67,62.26 CC223.2 163.45,62.32 CC270.2 ; CZ71.2 v2(186.81,62.27) ; JKBTP1.3 205.8,31.29 205.07,30.56 202.84,30.56 JKBTP1.21 203.83,31.83 204.68,31.83 205.3,32.45 JKBTP1.2 205.3,34.15 204.88,34.57 202.8,34.57 CZ29.2 ; UE2.B54 262.9,57.15 v2(263.08,57.33) ; CZ39.2 245.83,50.25 v2(246.87,50.25) ; v2(263.49,53.17) 263.61,53.29 CE16.2 ; JAPS1.14 298.92,32.45 298.49,32.89 v2(298.49,33.07) ; v2(220.41,40.29) 220.41,40.92 220.27,41.06 PC1503.2 ; RV74.2 v2(211.75,92.89) ; v2(298.49,32.07) 298.49,31.87 298.91,31.45 JAPS1.12 ; JUSH1.3 260.96,7.89 v2(261.1,7.75) ; JUSH1.2 v2(260.46,7.7) ; v2(76.32,10.79) 76.36,10.75 CD30.2 ; JAPS1.10 298.89,30.45 298.51,30.83 v2(298.51,31.07) ; v2(267.55,21.92) 266.99,21.92 CN46.2 ; JAPS1.8 298.88,29.45 298.49,29.84 v2(298.49,30.07) ; UE1.B27 245.32,82.13 245.48,81.97 v2(245.73,81.97)
  TOP w0.356: v2(282.41,39.5) 282.23,39.32 CA45.2 ; CE19.2 257.28,66.57 v2(256.92,66.57)
  TOP w0.381: PC1008.2 112.08,71.92 v2(112.08,71.61) ; CE5.2 256.42,80.04 v2(256.42,79.46) ; PC1066.2 154.37,68.76 v2(154.72,68.76) ; v2(163.54,48.62) 163.54,46.77 163.61,46.69 163.61,46.03 164.25,45.39 RC89.2 ; CN14.2 v2(279.14,16.04) ; v2(112.28,67.57) 112.28,67.95 PC1179.2 ; v2(142.23,65.36) 142.23,65.21 141.92,64.9 PC1027.2 ; CR39.1 269.28,34.73 269.28,36.06 268.95,36.4 v2(268.72,36.4) ; v2(163.61,69.6) 163.61,69.43 162.84,68.66 CC208.2 ; v2(139.74,65.33) 139.74,65.18 139.41,64.85 PC1133.2 ; v2(184.34,67.47) 184.34,68.27 RC44.2 ; CV603.2 202.5,87.25 v2(202.4,87.15) ; v2(120.46,71.61) 120.46,71.92 PC1174.2 ; PC1002.2 116.27,71.92 v2(116.27,71.61) ; PC1136.2 141.54,71.87 v2(141.54,71.56) ; CE17.2 275.3,59.88 275.35,59.82 v2(275.88,59.82) ; PC1024.2 112.31,62.75 v2(112.31,62.36) ; v2(158.05,70.03) 157.52,70.03 PC1143.2 ; v2(114.87,77.96) 114.87,78.27 PC1005.2 ; CZ27.2 221.34,36.58 v2(221.14,36.78) ; CZ47.2 v2(252.59,39.4) ; CI12.2 70.34,88.98 v2(69.94,89.38) ; CZ114.2 161.73,42.44 CC27.2 161.67,42.73 160.62,43.78 v2(160.62,45.06) 160.81,45.06 161.17,45.42 RC6.2 RC7.2 ; v2(194.32,61.17) 194.23,61.08 RZ111.2 ; v2(55.02,98.24) 54.94,98.32 PU1.2 ; v2(142.33,68.23) 142.33,68.08 142,67.75 PC1137.2 ; v2(116.12,67.57) 116.12,68.1 PC1178.2 ; CC311.2 164.91,68.26 v2(164.91,67.92) ; v2(275.75,10.95) 275.75,11.48 CN42.2 CN41.2 ; v2(143.57,13.36) 143.64,13.36 144.19,13.91 CD24.2 ; PC1025.2 113.8,62.73 v2(113.8,62.31) ; PC1004.2 113.47,75.1 v2(113.47,74.78) ; CZ43.2 250.66,44.73 v2(250.32,44.4) ; CC214.2 174.89,45.77 v2(175.56,45.1) ; PU902.3 255.69,92.63 v2(256.33,93.27) ; CE22.2 256.58,61.7 v2(256.37,61.9) ; CV27.2 92.11,96.86 v2(92.09,96.83) ; v2(113.47,71.61) 113.47,71.92 PC1007.2 ; v2(259.82,44.18) 259.82,44.23 259.57,44.47 259.3,44.47 CR13.2 ; PC1146.2 156.74,70.93 v2(156.74,71.63) ; PC1177.2 116.12,65.42 v2(116.12,64.93) ; v2(154.72,73.44) 154.75,73.41 154.75,72.8 PC1067.2 ; v2(149.8,62.92) 149.8,62.44 CC186.2 ; 165.09,61.46 165.64,62.01 v2(165.64,62.19) ; 165.09,61.46 164.45,61.46 RC338.2 ; 165.09,61.46 165.09,60.88 RC311.1 ; v2(139.81,68.2) 139.81,68.15 139.38,67.72 PC1138.2 ; PC1064.2 151.9,69.88 v2(152.36,69.88) ; PC1061.2 154.39,70.01 v2(154.72,70.01) ; v2(114.87,74.78) 114.87,75.1 PC1009.2 ; v2(141.03,65.36) 141.03,65.15 140.73,64.85 PC1130.2 ; CE4.2 251.83,75.39 v2(252.01,75.57) ; v2(91.2,97.69) 91.23,97.72 CV26.2 ; CA11.2 274.21,30.33 v2(273.06,30.33) ; CE25.2 260.66,53.09 v2(260.44,52.86) ; v2(88.81,33.76) 88.84,33.79 RC122.2 ; v2(275.05,72.07) 275.3,72.07 275.4,72.17 CL27.2 ; PU101.3 228.76,62.18 228.76,61.67 v2(228.76,61.67) ; PC1029.2 142.76,71.9 v2(142.76,71.58) ; v2(271.97,35.46) 272.55,34.88 CA50.2 ; v2(166.51,69.81) 165.95,70.37 CC211.2 ; PC1026.2 117.5,65.28 v2(117.5,64.85) ; v2(113.78,67.59) 113.78,68 PC1176.2 ; CZ74.2 195.22,68.37 v2(195.79,67.8) ; PC1023.2 112.36,65.35 v2(112.36,64.88) ; v2(112.08,74.78) 112.08,75.1 PC1006.2 ; CZ2.2 98.46,85.39 98.08,85 98.07,85 98.03,84.97 97.45,84.97 v2(97.27,85.14) ; v2(141.01,68.23) 141.01,68 140.7,67.69 PC1132.2 ; CR8.2 266.9,39.89 267.59,39.89 268.21,40.51 CR42.2 ; CZ99.2 266.42,31.11 266.26,30.94 v2(266.1,30.94) ; CZ76.2 195.71,69.27 v2(196.03,68.95) ; PC1172.2 119.06,71.92 v2(119.06,71.61) ; CC28.2 88.54,39.96 88.15,39.57 88.15,38.56 87.88,38.29 87.85,38.29 87.76,38.21 v2(87.67,38.21) ; v2(158.14,71.61) 158.15,71.61 PC1145.2 ; CL15.2 274.13,84.06 v2(273.93,83.86) ; v2(151.19,66.6) 151.52,66.93 PC1032.2 ; v2(193.69,64.34) 193.69,64.12 193.39,63.82 192.6,63.82 192.32,63.54 192.32,63.01 191.84,62.53 CZ73.2 ; v2(279.79,16.03) 279.84,16.08 279.84,17.15 CN13.2 ; CV124.2 229.54,92.17 v2(229.54,91.66) 229.67,91.53 CV125.2 ; PC1022.2 113.8,65.29 v2(113.8,64.88) ; v2(188.43,87.61) 188.31,87.49 CV602.2 ; v2(157.26,67.62) 157.01,67.87 PC1149.2 PC1147.2 ; CC29.2 v2(77.18,87.33) ; v2(250.89,49.36) 250.02,50.22 CZ50.2 ; v2(112.08,77.96) 112.08,78.27 PC1010.2 ; v2(117.66,71.61) 117.66,71.92 PC1173.2 ; v2(143.52,65.33) 143.52,65.15 143.19,64.82 PC1028.2 ; v2(98.84,40.06) CC30.1 ; v2(152.36,68.63) 151.88,68.63 PC1073.2 ; CE11.2 272.36,53.84 v2(272.81,53.39) ; CL9.2 266.95,82.44 v2(267.42,81.97) ; PC1175.2 117.55,67.98 v2(117.55,67.56) ; PC1131.2 143.29,67.75 143.62,68.08 v2(143.62,68.2) ; v2(265.06,70.59) 265.06,70.39 265.01,70.34 CE23.2 ; PC1081.2 114.87,71.92 v2(114.87,71.61) ; v2(252.94,67.39) 252.52,67.81 QE2.1 ; v2(287.22,66.67) 287.51,66.37 UZ10.3 ; v2(144.72,65.33) 144.72,65.18 144.39,64.85 PC1129.2 ; v2(76.13,15) UD1.3 ; v2(144.92,68.2) 144.92,68.08 144.59,67.75 PC1134.2 ; CE15.2 266.36,53.48 CE20.2 ; CL26.2 272.12,75.65 271.66,75.19 271.61,75.19 v2(271.59,75.21) ; v2(113.47,77.96) 113.47,78.27 PC1080.2 ; CD76.2 v2(228.18,21.8) ; CZ48.2 v2(288.17,63.67) ; RC1.1 167.53,69.4 167.39,69.26 CC281.2
  TOP w0.406: DI6.3 v2(66.75,95.98) ; v2(161.64,62.89) 161.64,62.99 161.14,63.49 CC310.2 ; v2(289.83,59.38) 289.68,59.53 DI4.3 ; UC14.3 189.61,30.82 189.25,31.18 187.23,31.18 ; v2(256.67,65) 256.67,64.79 256.48,64.6 256.25,64.6 256.02,64.82 UE5.3
  TOP w0.457: v2(142.3,23.93) 142.17,23.81 CD32.2 ; CV600.2 197.45,81.31 v2(197.45,80.37) ; v2(104.35,18.62) 104.35,19.43 CD7.2 ; RA35.2 296.54,22.28 296.3,22.04 v2(296.3,21.3) ; CC269.2 87.49,38.38 v2(87.67,38.21) ; R271.2 C311.2 144.71,109.67 v2(144.71,110.16) ; v2(159.93,71.64) 159.93,71.89 159.57,72.24 RC166.2 ; v2(264.26,27.59) 263.92,27.93 CZ100.2 ; CC199.2 v2(163.21,86.25) ; CD86.2 103.85,12.93 v2(103.97,13.06) ; v2(258.28,37.14) 258.63,37.14 CR23.2 ; CA10.2 272.71,33.74 v2(273.09,33.74) ; v2(163.6,63.79) 163.46,63.94 CC224.2 ; v2(259.83,46.97) 259.77,46.97 259.19,46.38 RR20.2 ; v2(158.86,45.9) 158.37,45.9 157.9,45.43 CC178.2 ; RN13.1 v2(261.87,27.56) ; CV128.2 229.35,93.2 v2(229.69,92.86) ; CC4.1 175.98,40.92 176.24,40.67 v2(176.24,40.42) ; v2(223.91,75.94) 223.91,75.55 224.21,75.25 CE53.2 ; v2(279.31,19.36) 279.31,18.95 279.59,18.67 280.4,18.67 280.76,18.32 280.76,17.77 QN1.4 ; v2(240.75,94.34) 240.75,93.03 CV144.2 ; CV113.2 224.19,85.48 224.38,85.68 v2(225.16,85.68)
  TOP w0.508: PQ908.3 73.83,27.05 v2(73.9,26.99) ; v2(161.09,60.49) 161.3,60.7 RC167.2 161.48,61.47 RC5.2 ; v2(119.7,10.29) 119.7,10.75 RD20.2 ; JUSH1.27 v2(256.92,5.55) ; CD92.2 117.89,12.73 v2(118.22,13.06) 118.63,12.64 CD82.2 ; v2(229.83,24.52) 229.83,24.94 229.67,25.1 RN54.2 ; RV660.2 234.66,97.97 v2(234.41,98.22) ; CZ23.2 247.74,54.41 247.08,55.07 v2(247.05,55.07) 246.85,54.87 CZ38.2 ; CC5.1 179.79,40.85 v2(180.15,40.49) ; RE299.2 261.2,77.55 260.51,78.24 v2(260.51,78.31) ; v2(276.82,16.29) 276.82,16.41 277.14,16.73 RN23.2 ; PR110.2 222.08,67.06 v2(222.08,66.6) ; v2(246.44,27.56) 246.13,27.87 RN73.2 ; v2(95.9,68.61) 96.33,68.18 PR680.2 ; v2(33.57,90.73) 33.8,90.5 PR15.2 ; RN53.2 233.97,28.13 RN72.2 RN31.2 235.37,29.02 v2(235.37,29.01) ; QV4.3 v2(76.02,99.86) ; RD24.2 RD25.2 73.44,10.7 v2(73.11,10.37) ; v2(114.31,13.85) 114.08,13.85 113.45,13.21 113.45,12.48 CD90.2 ; v2(235.53,26.35) CN30.2 ; PR118.2 224.42,58.09 v2(224.52,57.99) ; CC33.2 93.66,39.63 93.99,39.63 94.09,39.53 94.09,39.52 94.32,39.3 94.32,39.3 94.6,39.02 RC139.1 94.96,38.82 v2(94.96,38.36) ; RE17.1 CE9.2 v2(239.41,81.89) 239.1,82.2 RE24.2 ; CE28.2 267.37,53.95 267.6,54.18 v2(267.93,54.18) ; CA6.2 93.99,85.47 94.3,85.17 v2(94.3,85.2) ; v2(297.86,31.83) DA3.1 296.38,32.81 v2(296.26,32.93) ; v2(92.87,85.25) 92.87,85.78 CA5.2 ; RN40.2 v2(226.12,24.44) ; v2(273.42,22.53) 273.42,23.39 274.08,24.05 QA3.4 ; v2(257.75,81.06) 257.68,80.99 YL1.4 ; PC4.2 v2(54.65,15.47) ; RN19.1 263.18,17.66 v2(262.32,16.79) ; PU903.3 69.56,12.78 v2(69.28,12.5) ; v2(75.6,74.12) 75.04,73.56 PC644.2 ; RC86.1 132.51,86.96 133.1,87.55 133.1,88 v2(133.66,88.56) ; CD13.2 113.63,19.18 v2(114.1,18.7) ; CD105.2 190.87,12.3 CD94.2 191.1,12.91 190.33,13.67 189.75,13.67 v2(189.65,13.77) ; v2(83.53,72.24) 82.41,72.24 81.98,71.81 PC631.2 81.14,71.58 PC628.2 ; v2(209.21,84.2) 209.41,84.41 RV79.2 ; v2(304,37.17) 303.38,36.55 JAPS1.20 ; JSPI1.22 194.8,42.04 191.46,45.38 RH359.2 191.23,44.9 190.24,43.91 185.94,43.91 v2(184.52,45.33) ; CC288.2 159.13,62.94 CC215.2 159.13,64.63 CC217.2 159.04,65.33 v2(159.17,65.46) ; CZ77.2 192.24,76.15 193.86,74.53 v2(193.86,74.12) ; v2(219.6,105.27) 220,104.87 PC510.2 ; v2(229.45,83.98) 229.91,84.43 RV73.2 ; v2(115.56,18.47) 114.77,19.26 CD9.2 ; v2(162.77,10.34) 162.83,10.39 CD109.2 ; v2(218.12,12.98) 218.12,12.53 CD102.2 ; v2(142.62,14.27) 142.76,14.14 CD25.2 ; RN38.2 v2(227.16,35.89) ; v2(256.37,61.9) 255.83,61.36 RE86.1 ; PD6.1 50.96,94.8 v2(51.01,94.85) ; CC6.1 181.39,42.5 v2(181.39,40.44) 181.39,39.78 RC75.1 ; RE20.1 245.76,71.89 v2(245.83,71.96) ; v2(191.07,54.28) 191.07,53.39 RC316.1 ; CZ42.2 248.88,41.58 249.36,42.07 v2(249.36,42.12) ; PQ809.3 53.19,89.22 PR837.2 53.17,88.55 53.55,88.17 v2(54.04,88.17) 54.72,88.17 PR817.2 ; CD80.2 102.7,13.11 103.29,13.69 104,13.69 v2(104.02,13.67) ; CD71.2 CD70.2 147.71,18.31 v2(147.46,18.56) ; CV618.2 v2(225.86,98.16) ; CE1.2 245.67,94.21 v2(245.95,93.93) ; PR925.2 29.25,91.09 v2(29.35,91.19) ; v2(81.52,13.24) 81.62,13.14 81.62,12.15 CD79.2 ; CD18.2 118.11,19.59 CD11.2 116.95,19.09 117.59,18.46 117.59,17.66 117.16,17.23 v2(116.98,17.23) ; CD95.2 184.59,13.19 v2(184.59,14.18) ; RN45.2 RN46.2 235.48,29.93 v2(235.5,29.9) RN62.2 ; v2(252.46,63.33) 253.03,63.33 JLPDE1.11 ; v2(255.89,95.18) 255.82,95.25 PC903.1 ; v2(234.56,86.44) 234.73,86.62 RV78.2 ; v2(230.21,21.77) 230.21,21.72 229.46,20.97 CD77.2 ; v2(257.15,36.18) 257.15,36.75 CN1.2 ; v2(191.76,86.44) 190.92,87.28 RC242.1 ; RN83.2 v2(260.87,27.59) ; v2(73.09,90.66) 73.38,90.36 CI35.2 ; JLPDE1.12 244.7,63.19 v2(245.45,62.44) ; RE58.2 v2(266.36,48.67) ; RI14.1 279.71,64.11 v2(279.39,63.79) 279.05,63.45 278.44,63.45 278.1,63.8 278.1,65.04 CI33.2 ; v2(225.34,47.53) 225.23,47.53 224.73,48.03 PC313.2 ; RZ38.1 252.72,42.91 253.2,42.91 v2(253.33,42.78) ; v2(91.94,37.38) 91.72,37.16 RC219.1 ; v2(57.49,95.56) 57.57,95.64 PQ4.3 ; v2(21.85,88.69) 21.95,88.59 CI34.2 ; CL11.2 263.3,81.83 v2(263.74,81.39) ; RC312.1 180.13,68.87 180.38,68.62 v2(180.81,68.62) 180.99,68.44 RC96.2 ; JUSH1.28 274.56,6.53 v2(275.17,7.14) ; CV7.2 v2(89.14,88.17) ; v2(246.58,47.22) 247.08,47.22 RZ40.1 ; RA37.2 284.97,42.73 v2(284.77,42.73) ; PQ911.1 v2(67.75,15.22) ; CD46.2 191.73,18.85 192.42,18.16 v2(192.42,18.11) ; v2(83.88,72.8) 83.27,73.41 PC601.2 ; RN74.2 v2(240.98,23.43) ; v2(174.13,13.47) 174.71,12.88 CD98.2 ; CC3.1 178.7,41.02 178.69,41.02 178.35,40.68 178.35,40.67 178.29,40.62 v2(178.29,40.39) ; RN61.2 v2(238.31,23.44) ; QN1.1 282.03,19.31 282.18,19.15 282.18,18.95 v2(282.23,18.9) ; QA3.1 277.81,22.75 278.74,21.82 v2(278.74,21.58) ; v2(222.49,47.4) 222.49,47.93 PR302.2 ; v2(279.34,15.42) 278.9,14.98 PC2.2 ; CA54.2 271.36,33.86 270.88,33.86 270.83,33.91 v2(270.75,33.91) ; CE10.2 279.9,51.83 280.28,52.2 280.28,53.22 v2(280.05,53.45) 279.82,53.45 279.16,52.79 CE12.2 ; PC905.1 72.48,10.75 72.76,11.03 72.79,11.03 73.01,11.25 73.01,11.28 v2(73.04,11.28) ; CD84.2 106.13,12.56 v2(105.17,13.52) ; v2(94.48,58.14) 94.61,58.27 94.61,59 94.06,59.54 PR209.2 PC213.2 ; v2(183.34,13.32) 183.34,12.92 183.98,12.27 CD108.2 ; YV2.4 226.05,81.78 226.05,81.57 226.28,81.34 v2(226.33,81.34) ; RN60.2 v2(236.82,34.75) ; RV2.2 85.56,87 85.78,87.22 85.78,88.63 v2(85.56,88.85) ; v2(229.64,88.32) 229.64,88.3 230.42,87.52 RV89.2 ; CE8.2 v2(255.94,75.52) ; CE14.2 RE78.2 263.13,69.85 263.13,70.04 263.05,70.11 v2(263.05,70.44) ; v2(191.68,84.66) 191.59,84.57 CV601.2 ; RN11.1 267.42,19.51 v2(267.47,19.56) ; CD45.2 194.41,19.55 194.88,19.08 194.88,17.99 194.58,17.68 v2(194.27,17.68) ; v2(161.63,66.25) 161.63,66.98 CC209.2 160.72,67.16 CC206.2 ; RE55.1 263.08,72.58 262.72,72.93 v2(262.72,72.95) ; v2(296.32,35.56) 296.27,35.61 CA12.2 ; JAPS1.19 302.56,25.87 v2(303.69,27) ; CL12.2 260.2,94.03 v2(259.45,94.03) ; v2(267.91,51.97) 267.91,52.18 268.49,52.76 CE29.2 ; RN47.2 232.47,24.87 v2(232.88,24.46) ; QV2.3 v2(90.24,84.46) ; v2(277.1,11.65) 277.1,10.94 PC8.1 ; H16.1 137.85,86.3 RC136.1 ; CD41.2 192.87,18.72 193.37,18.23 193.37,17.29 192.65,16.57 v2(192.45,16.57) ; v2(148.27,73.41) 147.46,72.6 RC324.2 ; CD42.2 190.59,18.47 v2(190.77,18.29) 190.08,18.29 189.44,18.93 CD51.2 ; v2(51.7,95.53) PR10.1 ; v2(147.03,21.5) 147.34,21.2 CD72.2 ; v2(173.04,13.9) 173.04,12.7 CD106.2 ; CA49.1 v2(285.1,35.89) ; v2(265.53,37.4) 265.24,37.11 265.24,37.11 265.14,37.01 CR35.2 ; v2(142.35,17.38) 142.66,17.38 143.63,16.41 143.63,15.26 CD73.2 ; PC602.2 74.28,68.38 v2(74.64,68.03) ; RE56.1 256.46,63.06 v2(256.35,62.95) ; v2(192.45,14.74) 192.69,14.74 193.51,13.92 CD96.2 ; v2(188.38,17.58) 188.43,17.63 188.43,19.61 CD44.2 ; CD14.2 111.34,17.32 111.92,16.74 v2(112.03,16.74) ; RC91.2 140.75,70.87 v2(140.83,70.95) 140.83,70.31 140.5,69.98 RC90.2 ; CD38.2 223.23,19.57 v2(222.37,18.71) ; CC297.2 CC194.2 151.98,62.21 v2(152.01,62.23) ; CE15.2 266.52,52.83 266.46,52.77 v2(266.46,52.58) ; PQ907.1 71.21,15.07 v2(71.18,15.04) ; CZ46.2 252.79,35.77 252.79,35.76 v2(252.82,35.76) ; CD28.2 139.6,12.55 v2(140.12,13.08) ; CD29.2 139.44,10.71 v2(139.65,10.5) ; CN20.2 232.93,32.59 231.58,32.59 v2(231.51,32.67) ; RC220.2 177.66,41.02 v2(177.66,40.39) 177.53,40.26 CC266.2 ; CC213.2 166.03,45.39 RC88.2 RC89.2 ; v2(69.91,14.84) PQ907.4 ; CZ30.2 v2(221.14,36.78) ; CE7.2 v2(255.88,72.03) ; v2(246.36,30.54) RN67.2 RN66.2 ; v2(56.7,16.54) 57.31,17.15 PD2.1 ; v2(193.69,64.34) 193.69,64.88 CC8.1 ; v2(169.73,10.52) 169.84,10.62 CD35.2 ; v2(106.69,14.56) 106.92,14.56 107.5,13.97 107.5,12.75 CD87.2 ; CE47.2 275.02,66.4 274.33,65.71 v2(274.33,65.74) ; v2(108.7,17.99) 109.13,17.99 110.27,19.13 CD2.2 ; PC3.2 v2(62.19,19.41) ; RC180.1 143.85,85.45 v2(144.49,86.09) ; CD104.2 192.24,12.93 v2(192.52,13.21) ; C316.2 v2(165.9,107.4) ; RN30.2 v2(223.75,29.14) ; RN30.2 RN41.2 ; RN30.2 RN52.2 ; v2(119.47,18.09) 119.72,18.34 CD10.2 ; CD81.2 114.77,12.3 115.07,12.6 115.07,12.96 v2(115.78,13.67) ; RD72.2 v2(230.34,12.91) ; v2(186.12,70.79) 186.12,70.26 RZ62.2 ; YV2.2 227.77,84.62 v2(228.03,84.37) ; v2(90.51,88.04) 90.51,87.53 CV12.2 ; v2(228.44,64.91) 229.57,64.91 PC101.1 ; v2(244.61,58.67) 244.02,58.08 CZ54.2 243.62,58.19 CZ105.2 ; RC1.1 167.97,69.4 v2(168.35,69.78) ; RC3.2 175.52,85.42 176.11,86.01 v2(176.11,86.19) ; v2(246.65,26.86) RN68.2 ; RN7.2 265.56,33.14 265.95,33.53 v2(266.1,33.53) ; PC1501.2 v2(232.51,42.41) ; RE88.2 CE30.2 v2(256.44,59.19) JTAG1.2 255.56,59.17 RE65.2 ; JDEG1.12 303.33,38.2 v2(304.03,38.89) ; v2(229.73,10.34) 229.65,10.42 RD73.2 ; CD15.2 103.14,18.6 103.92,17.81 v2(104.33,17.81) ; CE31.2 274.15,69.02 v2(274.33,69.19) ; v2(160.97,69.6) 160.44,69.07 CC202.2 ; PC1500.2 v2(231.71,43.36) ; CA46.2 282.38,40.44 v2(282.38,41.2) ; JSPI1.21 v2(216.74,40.56) ; v2(86.57,87.71) 86.42,87.56 RV1.2 ; v2(95.8,100.08) 95.44,99.72 RV20.2 ; v2(170.4,18.19) 169.91,18.19 168.87,19.23 CD43.2 ; v2(65.92,15.93) 65.92,16.11 65.52,16.52 PQ911.4 ; PR929.2 25.87,85.75 v2(26.2,85.42) ; CD78.2 101.81,12.75 v2(101.41,13.16) ; CC214.2 174.81,45.7 RC48.2 ; v2(244.31,60.54) 244.31,61.02 244.05,61.27 CZ53.2 CZ55.2 ; PC502.1 209.27,103.94 208.86,104.35 v2(208.62,104.35) ; CD8.2 112.48,18.88 v2(111.97,18.37) ; RN9.1 v2(267.47,21.29) ; CD88.2 108.55,13.08 109.03,13.57 109.05,13.57 109.31,13.82 v2(109.54,13.82) ; v2(156.7,105.87) 156.69,105.87 156.69,105.91 156.73,105.95 156.73,106.3 156.04,106.99 C42.2 ; v2(232.45,86.41) 232.55,86.52 RV77.2 RV76.2 ; v2(191.1,56.09) 191.62,56.09 191.95,55.76 CC7.1 ; v2(70.7,87.25) CI11.2 ; CV127.2 233.87,86.49 v2(233.79,86.41) ; v2(238.32,34.78) 238.59,34.51 RN59.2 ; QV7.3 97.2,95.56 98.12,96.47 v2(99.81,96.47) ; v2(143.19,24.38) 143.19,23.83 CD31.2 ; CZ72.2 v2(187.7,62.17) ; CC24.2 187.41,46.6 v2(188.24,47.43) ; RE313.2 260.59,50.67 CE21.2 259.84,49.73 v2(259.78,49.79) ; CD83.2 110.86,12.3 CD89.2 111.11,12.55 111.11,13.62 110.5,14.23 v2(110.17,14.23) ; CD26.2 145.12,10.86 v2(144.71,10.45) 144.42,10.73 CD27.2 ; RL13.2 260.67,81.54 v2(260.67,80.85) ; CL13.1 256.61,84.48 256.2,84.08 v2(256.2,83.77) ; CD52.2 176.36,18.8 v2(175.78,18.22) ; JLED1.10 v2(284.25,4.41) ; v2(297.86,26.81) 297.86,25.75 297.34,25.23 DA2.1 ; JKBTP1.21 202.7,30.26 203.11,29.85 211.77,29.85 216.85,24.77 222.79,24.77 223.04,24.51 v2(224.57,24.51) ; CC178.2 157.9,44.96 CZ113.2 ; PC647.1 89.24,65.49 v2(89.45,65.69) ; CD97.2 188.81,12.68 v2(188.2,13.29) 187.69,12.78 CD107.2 ; CL14.1 259.55,82.2 YL1.2 259.48,81.19 v2(259.6,81.07) ; CE2.2 v2(245.07,91.09) ; JLED1.9 v2(277.68,5.9) ; RE21.1 v2(257.36,73.66) ; RN16.1 259.91,27.95 v2(259.5,27.54) ; QE2.4 254.41,69.97 v2(254.6,70.16) 254.93,69.83 CE52.2 ; v2(248.9,36.33) 249.44,35.79 CZ37.2 ; CR37.2 260.85,36.8 v2(260.85,36.28) ; PD3.1 v2(58.51,14.63) ; v2(164.91,67.92) 164.9,67.92 RC337.2 ; CE44.2 271.11,52.06 v2(271.81,52.76) 271.49,53.08 CE45.2 ; PC906.2 22.87,74.73 22.39,74.25 v2(22.14,74.25) ; v2(195.29,10.37) 195.52,10.6 CD103.2 ; CA13.1 v2(296.33,34.24) ; CE40.2 v2(275.3,64.77) ; CV126.2 v2(236,95.42) ; CD63.2 v2(231.15,18.06) ; v2(160.79,68) 161.09,68.29 CC218.2 ; CV619.2 229.31,93.64 CV128.2 ; RN21.1 v2(262.88,27.51) ; RD66.2 v2(146.19,14.76) ; RD67.2 v2(147.03,11.26) ; v2(280.17,55.45) RE82.1 ; RA36.2 v2(285.71,21.44) ; RN39.2 v2(223.76,30.97) ; CE34.2 v2(262.09,72.95)
  GND1 w0.203: 229.54,104.99 JCRT1.17 ; JCRT1.17 228.66,104.99 ; JCRT1.17 230.42,104.99 ; JCRT1.17 230.42,107.51 ; JCRT1.17 228.66,106.25 ; JCRT1.17 228.66,107.51 ; JCRT1.17 229.54,107.51 ; JCRT1.17 230.42,106.25 ; 14.86,81.08 JUSB1.4 ; JUSB1.4 16,81.08 ; JUSB1.4 15.43,82.39 ; JUSB1.4 16,82.22 ; JUSB1.4 14.69,81.65 ; JUSB1.4 16.17,81.65 ; JUSB1.4 15.43,80.91 ; JUSB1.4 14.86,82.22 ; 158.31,105.69 JDOCK1.159 ; JDOCK1.159 159.25,103.49 ; JDOCK1.159 158.31,103.81 ; JDOCK1.159 159.25,106.01 ; JDOCK1.159 157.99,104.75 ; JDOCK1.159 160.51,104.75 ; JDOCK1.159 160.19,103.81 ; JDOCK1.159 160.19,105.69 ; 264.56,105.73 JLOM1.16 ; JLOM1.16 266.39,105.73 ; JLOM1.16 265.48,109.24 ; JLOM1.16 265.48,105.73 ; JLOM1.16 266.39,109.24 ; JLOM1.16 264.56,107.49 ; JLOM1.16 266.39,107.49 ; JHDMI1.8 86.06,101.73 ; JHDMI1.8 85.6,101.61 ; JHDMI1.8 85.6,102.78 ; JHDMI1.8 86.06,102.66 ; JHDMI1.8 85.14,101.73 ; JHDMI1.8 85.14,102.66 ; 283.62,53.85 H21.1 ; H21.1 284.05,52.65 ; H21.1 286.45,52.65 ; H21.1 284.05,55.05 ; H21.1 285.25,52.22 ; H21.1 286.88,53.85 ; H21.1 285.25,55.48 ; H21.1 286.45,55.05 ; 251.26,90.29 SW1.5 ; SW1.5 252.02,92.05 ; SW1.5 250.26,91.29 ; SW1.5 251.26,92.29 ; SW1.5 250.5,90.53 ; SW1.5 250.5,92.05 ; SW1.5 252.02,90.53 ; SW1.5 252.27,91.29 ; 152.05,12.6 H12.1 ; H12.1 151.62,11.4 ; H12.1 153.25,13.03 ; H12.1 154.88,11.4 ; H12.1 153.25,9.77 ; H12.1 154.45,12.6 ; H12.1 152.05,10.2 ; H12.1 154.45,10.2 ; JCRT1.7 236.67,106.63 ; JCRT1.7 236.15,107.81 ; JCRT1.7 235.64,106.63 ; JCRT1.7 236.15,106.49 ; JCRT1.7 236.67,107.67 ; JCRT1.7 235.64,107.67 ; JHDMI1.11 87.56,104.16 ; JHDMI1.11 87.56,103.23 ; JHDMI1.11 87.1,104.28 ; JHDMI1.11 87.1,103.11 ; JHDMI1.11 86.64,103.23 ; JHDMI1.11 86.64,104.16 ; 277.93,66.81 H7.1 ; H7.1 277.39,68.3 ; H7.1 279.42,66.27 ; H7.1 277.93,69.79 ; H7.1 280.91,66.81 ; H7.1 280.91,69.79 ; H7.1 279.42,70.33 ; H7.1 281.45,68.3 ; 146.2,109.65 JDOCK1.154 ; JDOCK1.154 148.3,108.67 ; JDOCK1.154 146.2,108.67 ; JDOCK1.154 146.2,107.7 ; JDOCK1.154 148.3,109.65 ; JDOCK1.154 147.25,107.7 ; JDOCK1.154 148.3,107.7 ; JDOCK1.154 147.25,109.65 ; 152.05,20.55 H15.1 ; H15.1 153.25,17.72 ; H15.1 152.05,18.15 ; H15.1 154.45,20.55 ; H15.1 154.45,18.15 ; H15.1 153.25,20.98 ; H15.1 151.62,19.35 ; H15.1 154.88,19.35 ; JDOCK1.158 148.19,105.69 ; JDOCK1.158 146.31,105.69 ; JDOCK1.158 147.25,103.49 ; JDOCK1.158 148.51,104.75 ; JDOCK1.158 148.19,103.81 ; JDOCK1.158 147.25,106.01 ; JDOCK1.158 145.99,104.75 ; JDOCK1.158 146.31,103.81 ; JUSB3.4 291.38,63.98 ; JUSB3.4 290.69,63.29 ; JUSB3.4 290.15,63.44 ; JUSB3.4 291.23,64.52 ; JUSB3.4 290.69,64.67 ; JUSB3.4 290.15,64.52 ; JUSB3.4 290,63.98 ; JUSB3.4 291.23,63.44 ; 181.9,81.2 H2.1 ; H2.1 185.3,81.2 ; H2.1 183.6,77.16 ; H2.1 181.9,77.8 ; H2.1 183.6,81.84 ; H2.1 185.3,77.8 ; H2.1 181.26,79.5 ; H2.1 185.94,79.5 ; 102.48,86.88 H23.1 ; H23.1 105.52,86.88 ; H23.1 102.48,89.92 ; H23.1 104,86.32 ; H23.1 105.52,89.92 ; H23.1 101.92,88.4 ; H23.1 104,90.48 ; H23.1 106.08,88.4 ; 120.56,79.5 H1.1 ; H1.1 124.6,77.8 ; H1.1 122.9,81.84 ; H1.1 124.6,81.2 ; H1.1 121.2,77.8 ; H1.1 122.9,77.16 ; H1.1 121.2,81.2 ; H1.1 125.24,79.5 ; 44.3,13.25 H17.1 ; H17.1 46.7,13.25 ; H17.1 47.13,12.05 ; H17.1 45.5,10.42 ; H17.1 46.7,10.85 ; H17.1 45.5,13.68 ; H17.1 44.3,10.85 ; H17.1 43.87,12.05 ; 291.29,69.21 JUSB3.10 ; JUSB3.10 294.85,69.21 ; JUSB3.10 293.07,67.45 ; JUSB3.10 291.29,67.45 ; JUSB3.10 293.07,69.21 ; JUSB3.10 291.29,68.33 ; JUSB3.10 294.85,68.33 ; 52.25,104.72 H13.1 ; H13.1 53.45,107.55 ; H13.1 52.25,107.98 ; H13.1 51.05,105.15 ; H13.1 50.62,106.35 ; H13.1 53.88,106.35 ; H13.1 53.45,105.15 ; H13.1 51.05,107.55 ; JUSB2.13 72.3,110.33 ; JUSB2.13 72.3,107.67 ; JUSB2.13 73.18,107.67 ; JUSB2.13 73.18,109 ; JUSB2.13 73.18,110.33 ; JCRT1.5 244.69,107.67 ; JCRT1.5 243.65,107.67 ; JCRT1.5 244.17,107.81 ; JCRT1.5 244.69,106.63 ; JCRT1.5 244.17,106.49 ; JCRT1.5 244.83,107.15 ; JCRT1.5 243.65,106.63 ; 298.75,52.63 JUSB3.12 ; JUSB3.12 301.59,52.63 ; JUSB3.12 301.59,51.75 ; JUSB3.12 300.17,51.75 ; JUSB3.12 298.75,51.75 ; 120.56,52.2 H3.1 ; H3.1 124.6,53.9 ; H3.1 125.24,52.2 ; H3.1 122.9,54.54 ; H3.1 121.2,50.5 ; H3.1 121.2,53.9 ; H3.1 122.9,49.86 ; H3.1 124.6,50.5 ; H4.1 185.3,50.5 ; H4.1 181.26,52.2 ; H4.1 181.9,53.9 ; H4.1 185.94,52.2 ; H4.1 183.6,49.86 ; H4.1 183.6,54.54 ; H4.1 185.3,53.9 ; H4.1 181.9,50.5 ; 55.72,100.42 JUSB2.11 ; JUSB2.11 56.6,100.42 ; JUSB2.11 55.72,102.2 ; JUSB2.11 56.6,103.98 ; JUSB2.11 57.48,100.42 ; JUSB2.11 55.72,103.98 ; JCRT1.10 243.02,107.81 ; JCRT1.10 243.54,106.63 ; JCRT1.10 242.51,106.63 ; JCRT1.10 243.02,106.49 ; JCRT1.10 242.51,107.67 ; JCRT1.10 243.54,107.67 ; H24.1 296.88,3.35 ; H24.1 293.62,3.35 ; H24.1 294.05,2.15 ; H24.1 296.45,2.15 ; H24.1 295.25,4.98 ; H24.1 296.45,4.55 ; H24.1 294.05,4.55 ; H24.1 295.25,1.72 ; H16.1 138.45,86.9 ; H16.1 137.25,84.07 ; H16.1 138.88,85.7 ; H16.1 136.05,84.5 ; H16.1 136.05,86.9 ; H16.1 137.25,87.33 ; H16.1 135.62,85.7 ; H16.1 138.45,84.5 ; 119.05,107.95 H14.1 ; H14.1 119.05,105.55 ; H14.1 120.25,105.12 ; H14.1 121.45,107.95 ; H14.1 121.45,105.55 ; H14.1 118.62,106.75 ; H14.1 121.88,106.75 ; H14.1 120.25,108.38 ; JUSB1.10 15.4,78.25 ; JUSB1.10 12.28,77.3 ; JUSB1.10 15.4,76.35 ; JUSB1.10 15.4,77.3 ; JUSB1.10 13.84,78.25 ; JUSB1.10 13.84,76.35 ; JUSB1.10 12.28,76.35 ; 89.64,103.23 JHDMI1.17 ; JHDMI1.17 89.64,104.16 ; JHDMI1.17 90.1,103.11 ; JHDMI1.17 90.1,104.28 ; JHDMI1.17 90.56,104.16 ; JHDMI1.17 90.56,103.23 ; 293.07,51.75 JUSB3.13 ; JUSB3.13 291.29,52.63 ; JUSB3.13 294.85,52.63 ; JUSB3.13 293.07,53.51 ; JUSB3.13 294.85,51.75 ; JUSB3.13 291.29,51.75 ; JUSB3.13 291.29,53.51 ; 79.35,101.04 JHDMI1.20 ; JHDMI1.20 78.47,101.04 ; JHDMI1.20 78.47,102.8 ; JHDMI1.20 80.23,101.04 ; JHDMI1.20 80.23,104.55 ; JHDMI1.20 79.35,104.55 ; JHDMI1.20 80.23,102.8 ; JHDMI1.23 96.93,109.78 ; JHDMI1.23 94.77,109.78 ; JHDMI1.23 96.93,108.2 ; JHDMI1.23 95.85,111.35 ; JHDMI1.23 95.85,108.2 ; JHDMI1.23 94.77,111.35 ; JHDMI1.23 96.93,111.35 ; JHDMI1.23 94.77,108.2 ; 134.45,103.95 JDOCK1.157 ; JDOCK1.157 136.05,103.95 ; JDOCK1.157 134.2,104.75 ; JDOCK1.157 135.25,105.8 ; JDOCK1.157 135.25,103.7 ; JDOCK1.157 134.45,105.55 ; JDOCK1.157 136.05,105.55 ; 8.8,99.05 H11.1 ; H11.1 8.37,97.85 ; H11.1 8.8,96.65 ; H11.1 11.63,97.85 ; H11.1 11.2,96.65 ; H11.1 10,99.48 ; H11.1 11.2,99.05 ; H11.1 10,96.22 ; JUSB3.7 292.19,61.17 ; JUSB3.7 291.65,61.02 ; JUSB3.7 291.65,59.94 ; JUSB3.7 292.19,59.79 ; JUSB3.7 292.88,60.48 ; JUSB3.7 292.73,61.02 ; JUSB3.7 291.5,60.48 ; JUSB3.7 292.73,59.94 ; 128.69,108.67 JDOCK1.153 ; JDOCK1.153 128.69,109.65 ; JDOCK1.153 132.81,109.65 ; JDOCK1.153 132.81,107.7 ; JDOCK1.153 130.75,109.65 ; JDOCK1.153 132.81,108.67 ; JDOCK1.153 130.75,107.7 ; JDOCK1.153 128.69,107.7 ; 236.01,11.85 H25.1 ; H25.1 240.05,10.15 ; H25.1 240.05,13.55 ; H25.1 236.65,10.15 ; H25.1 240.69,11.85 ; H25.1 238.35,9.51 ; H25.1 236.65,13.55 ; H25.1 238.35,14.19 ; 55.72,110.33 JUSB2.12 ; JUSB2.12 55.72,107.67 ; JUSB2.12 56.6,110.33 ; JUSB2.12 56.6,107.67 ; JUSB2.12 55.72,109 ; JDOCK1.163 160.3,99.85 ; JDOCK1.163 159.25,99.85 ; JDOCK1.163 158.2,101.8 ; JDOCK1.163 158.2,100.82 ; JDOCK1.163 160.3,100.82 ; JDOCK1.163 158.2,99.85 ; JDOCK1.163 159.25,101.8 ; JUSB1.13 6.34,93.95 ; JUSB1.13 7.8,93.95 ; JUSB1.13 4.88,93.95 ; JUSB1.13 4.88,93 ; JUSB1.13 7.8,93 ; JHDMI1.2 82.6,102.78 ; JHDMI1.2 82.6,101.61 ; JHDMI1.2 82.14,101.73 ; JHDMI1.2 82.02,102.2 ; JHDMI1.2 83.06,101.73 ; JHDMI1.2 83.06,102.66 ; JHDMI1.2 82.14,102.66 ; 128.69,100.82 JDOCK1.161 ; JDOCK1.161 132.81,99.85 ; JDOCK1.161 128.69,101.8 ; JDOCK1.161 130.75,99.85 ; JDOCK1.161 132.81,101.8 ; JDOCK1.161 132.81,100.82 ; JDOCK1.161 130.75,101.8 ; JHDMI1.5 84.1,104.28 ; JHDMI1.5 84.56,103.23 ; JHDMI1.5 83.64,104.16 ; JHDMI1.5 84.56,104.16 ; JHDMI1.5 84.1,103.11 ; JHDMI1.5 83.64,103.23 ; JDOCK1.164 177.81,99.85 ; JDOCK1.164 175.75,99.85 ; JDOCK1.164 173.69,99.85 ; JDOCK1.164 177.81,101.8 ; JDOCK1.164 177.81,100.82 ; JDOCK1.164 173.69,101.8 ; JDOCK1.164 175.75,101.8 ; JDOCK1.164 173.69,100.82 ; 237.93,106.63 JCRT1.8 ; JCRT1.8 238.96,107.67 ; JCRT1.8 238.45,107.81 ; JCRT1.8 238.96,106.63 ; JCRT1.8 238.45,106.49 ; JCRT1.8 237.93,107.67 ; 248.76,107.51 JCRT1.16 ; JCRT1.16 250.52,104.99 ; JCRT1.16 249.64,107.51 ; JCRT1.16 250.52,106.25 ; JCRT1.16 248.76,104.99 ; JCRT1.16 249.64,104.99 ; JCRT1.16 250.52,107.51 ; JCRT1.16 248.76,106.25 ; 159.25,107.7 JDOCK1.155 ; JDOCK1.155 158.2,107.7 ; JDOCK1.155 158.2,108.67 ; JDOCK1.155 158.2,109.65 ; JDOCK1.155 160.3,108.67 ; JDOCK1.155 159.25,109.65 ; JDOCK1.155 160.3,107.7 ; JDOCK1.155 160.3,109.65 ; 128.02,104.75 JDOCK1.145 ; JDOCK1.145 128.02,102.77 ; JDOCK1.145 130.13,106.73 ; JDOCK1.145 130.13,102.77 ; JDOCK1.145 129.07,106.73 ; JDOCK1.145 130.13,104.75 ; JDOCK1.145 128.02,106.73 ; JDOCK1.145 129.07,102.77 ; JDOCK1.156 177.81,109.65 ; JDOCK1.156 173.69,108.67 ; JDOCK1.156 175.75,107.7 ; JDOCK1.156 177.81,107.7 ; JDOCK1.156 177.81,108.67 ; JDOCK1.156 175.75,109.65 ; JDOCK1.156 173.69,107.7 ; JDOCK1.156 173.69,109.65 ; 63.81,100.64 JUSB2.7 ; JUSB2.7 65.08,100.64 ; JUSB2.7 64.45,100.44 ; JUSB2.7 63.62,101.27 ; JUSB2.7 65.28,101.27 ; 223.25,107.32 H19.1 ; H19.1 224.45,107.75 ; H19.1 221.62,108.95 ; H19.1 224.45,110.15 ; H19.1 224.88,108.95 ; H19.1 222.05,110.15 ; H19.1 223.25,110.58 ; H19.1 222.05,107.75 ; H20.1 254.94,110.16 ; H20.1 255.36,108.96 ; H20.1 252.54,110.16 ; H20.1 252.54,107.76 ; H20.1 253.74,107.33 ; H20.1 254.94,107.76 ; H20.1 252.11,108.96 ; H20.1 253.74,110.58 ; 171.25,103.7 JDOCK1.160 ; JDOCK1.160 172.05,105.55 ; JDOCK1.160 170.45,105.55 ; JDOCK1.160 170.45,103.95 ; JDOCK1.160 172.3,104.75 ; JDOCK1.160 171.25,105.8 ; JDOCK1.160 172.05,103.95 ; 77.35,108.2 JHDMI1.22 ; JHDMI1.22 76.27,111.35 ; JHDMI1.22 76.27,109.78 ; JHDMI1.22 77.35,111.35 ; JHDMI1.22 76.27,108.2 ; JHDMI1.22 78.43,111.35 ; JHDMI1.22 78.43,108.2 ; JHDMI1.22 78.43,109.78 ; JUSB1.11 15.4,93.95 ; JUSB1.11 13.84,93.95 ; JUSB1.11 15.4,93 ; JUSB1.11 15.4,92.05 ; JUSB1.11 12.28,93.95 ; JUSB1.11 13.84,92.05 ; JUSB1.11 12.28,93 ; 146.2,100.82 JDOCK1.162 ; JDOCK1.162 147.25,99.85 ; JDOCK1.162 148.3,100.82 ; JDOCK1.162 147.25,101.8 ; JDOCK1.162 148.3,101.8 ; JDOCK1.162 148.3,99.85 ; JDOCK1.162 146.2,99.85 ; JDOCK1.162 146.2,101.8 ; JUSB1.7 13.93,85.89 ; JUSB1.7 14.5,84.58 ; JUSB1.7 14.5,85.72 ; JUSB1.7 13.93,84.41 ; JUSB1.7 14.67,85.15 ; JUSB2.10 72.3,103.98 ; JUSB2.10 73.18,100.42 ; JUSB2.10 73.18,103.98 ; JUSB2.10 71.42,100.42 ; JUSB2.10 72.3,100.42 ; JUSB2.10 73.18,102.2 ; SW1.4 252.02,98.35 ; SW1.4 252.27,97.59 ; SW1.4 251.26,96.59 ; SW1.4 251.26,98.59 ; SW1.4 252.02,96.83 ; SW1.4 250.5,98.35 ; SW1.4 250.26,97.59 ; SW1.4 250.5,96.83 ; 60.95,98.94 JUSB2.4 ; JUSB2.4 61.58,99.13 ; JUSB2.4 60.31,99.13 ; JUSB2.4 61.78,99.77 ; JUSB2.4 60.12,99.77 ; JUSB2.4 61.58,100.4 ; 230.05,55.55 H22.1 ; H22.1 232.45,53.15 ; H22.1 231.25,52.72 ; H22.1 232.88,54.35 ; H22.1 232.45,55.55 ; H22.1 229.62,54.35 ; H22.1 230.05,53.15 ; H22.1 231.25,55.98 ; 298.75,68.33 JUSB3.11 ; JUSB3.11 300.17,69.21 ; JUSB3.11 298.75,69.21 ; JUSB3.11 301.59,68.33 ; JUSB3.11 301.59,69.21 ; 185.05,106.55 H18.1 ; H18.1 186.25,106.98 ; H18.1 184.62,105.35 ; H18.1 186.25,103.72 ; H18.1 187.45,106.55 ; H18.1 185.05,104.15 ; H18.1 187.88,105.35 ; H18.1 187.45,104.15 ; 4.88,77.3 JUSB1.12 ; JUSB1.12 6.34,76.35 ; JUSB1.12 7.8,77.3 ; JUSB1.12 7.8,76.35 ; 233.35,106.63 JCRT1.6 ; JCRT1.6 234.38,106.63 ; JCRT1.6 233.86,106.49 ; JCRT1.6 234.38,107.67 ; JCRT1.6 233.2,107.15 ; JCRT1.6 233.86,107.81 ; JCRT1.6 233.35,107.67 ; 283.61,109.24 JLOM1.14 ; JLOM1.14 285.44,105.73 ; JLOM1.14 285.44,109.24 ; JLOM1.14 285.44,107.49 ; JLOM1.14 284.53,109.24 ; JLOM1.14 283.61,107.49 ; JLOM1.14 283.61,105.73 ; JLOM1.14 284.53,105.73 ; 92.97,102.8 JHDMI1.21 ; JHDMI1.21 93.85,101.04 ; JHDMI1.21 92.97,101.04 ; JHDMI1.21 92.97,104.55 ; JHDMI1.21 94.73,102.8 ; JHDMI1.21 94.73,101.04 ; JHDMI1.21 93.85,104.55 ; H8.1 252.95,50.38 ; H8.1 254.44,46.86 ; H8.1 251.46,49.84 ; H8.1 250.92,48.35 ; H8.1 254.44,49.84 ; H8.1 252.95,46.32 ; H8.1 254.98,48.35 ; H8.1 251.46,46.86 ; 176.37,104.75 JDOCK1.152 ; JDOCK1.152 176.37,106.73 ; JDOCK1.152 178.48,106.73 ; JDOCK1.152 178.48,104.75 ; JDOCK1.152 176.37,102.77 ; JDOCK1.152 177.42,106.73 ; JDOCK1.152 177.42,102.77 ; JDOCK1.152 178.48,102.77
  GND2 w0.203: JHDMI1.22 78.43,108.2 ; JHDMI1.22 77.35,111.35 ; JHDMI1.22 78.43,111.35 ; JHDMI1.22 77.35,108.2 ; JHDMI1.22 76.27,108.2 ; JHDMI1.22 76.27,111.35 ; JHDMI1.22 76.27,109.78 ; JHDMI1.22 78.43,109.78 ; 63.81,100.64 JUSB2.7 ; JUSB2.7 65.28,101.27 ; JUSB2.7 64.45,100.44 ; JUSB2.7 65.08,100.64 ; JUSB2.7 63.62,101.27 ; JDOCK1.159 160.51,104.75 ; JDOCK1.159 159.25,103.49 ; JDOCK1.159 160.19,103.81 ; JDOCK1.159 160.19,105.69 ; JDOCK1.159 159.25,106.01 ; JDOCK1.159 158.31,105.69 ; JDOCK1.159 157.99,104.75 ; JDOCK1.159 158.31,103.81 ; JUSB1.12 7.8,77.3 ; JUSB1.12 4.88,77.3 ; JUSB1.12 6.34,76.35 ; JUSB1.12 7.8,76.35 ; 55.72,107.67 JUSB2.12 ; JUSB2.12 56.6,110.33 ; JUSB2.12 55.72,110.33 ; JUSB2.12 55.72,109 ; JUSB2.12 56.6,107.67 ; JUSB2.4 61.58,100.4 ; JUSB2.4 61.58,99.13 ; JUSB2.4 61.78,99.77 ; JUSB2.4 60.95,98.94 ; JUSB2.4 60.31,99.13 ; JUSB2.4 60.12,99.77 ; 92.97,101.04 JHDMI1.21 ; JHDMI1.21 92.97,102.8 ; JHDMI1.21 93.85,101.04 ; JHDMI1.21 94.73,101.04 ; JHDMI1.21 94.73,102.8 ; JHDMI1.21 92.97,104.55 ; JHDMI1.21 93.85,104.55 ; JUSB1.7 14.67,85.15 ; JUSB1.7 14.5,85.72 ; JUSB1.7 13.93,85.89 ; JUSB1.7 14.5,84.58 ; JUSB1.7 13.93,84.41 ; 134.45,103.95 JDOCK1.157 ; JDOCK1.157 135.25,105.8 ; JDOCK1.157 134.2,104.75 ; JDOCK1.157 136.05,105.55 ; JDOCK1.157 136.05,103.95 ; JDOCK1.157 134.45,105.55 ; JDOCK1.157 135.25,103.7 ; 173.69,99.85 JDOCK1.164 ; JDOCK1.164 173.69,100.82 ; JDOCK1.164 177.81,99.85 ; JDOCK1.164 177.81,100.82 ; JDOCK1.164 175.75,101.8 ; JDOCK1.164 173.69,101.8 ; JDOCK1.164 175.75,99.85 ; JDOCK1.164 177.81,101.8 ; 242.51,107.67 JCRT1.10 ; JCRT1.10 242.51,106.63 ; JCRT1.10 243.54,107.67 ; JCRT1.10 243.02,107.81 ; JCRT1.10 243.02,106.49 ; JCRT1.10 243.54,106.63 ; 87.1,103.11 JHDMI1.11 ; JHDMI1.11 86.64,103.23 ; JHDMI1.11 87.56,103.23 ; JHDMI1.11 87.1,104.28 ; JHDMI1.11 86.64,104.16 ; JHDMI1.11 87.56,104.16 ; H12.1 154.45,10.2 ; H12.1 154.45,12.6 ; H12.1 152.05,10.2 ; H12.1 152.05,12.6 ; H12.1 151.62,11.4 ; H12.1 153.25,13.03 ; H12.1 154.88,11.4 ; H12.1 153.25,9.77 ; 233.35,107.67 JCRT1.6 ; JCRT1.6 233.86,107.81 ; JCRT1.6 234.38,106.63 ; JCRT1.6 233.35,106.63 ; JCRT1.6 233.86,106.49 ; JCRT1.6 233.2,107.15 ; JCRT1.6 234.38,107.67 ; 128.69,108.67 JDOCK1.153 ; JDOCK1.153 132.81,107.7 ; JDOCK1.153 132.81,108.67 ; JDOCK1.153 132.81,109.65 ; JDOCK1.153 130.75,109.65 ; JDOCK1.153 128.69,109.65 ; JDOCK1.153 128.69,107.7 ; JDOCK1.153 130.75,107.7 ; JUSB2.13 73.18,109 ; JUSB2.13 73.18,110.33 ; JUSB2.13 73.18,107.67 ; JUSB2.13 72.3,110.33 ; JUSB2.13 72.3,107.67 ; JDOCK1.158 148.19,103.81 ; JDOCK1.158 147.25,103.49 ; JDOCK1.158 146.31,103.81 ; JDOCK1.158 145.99,104.75 ; JDOCK1.158 148.51,104.75 ; JDOCK1.158 147.25,106.01 ; JDOCK1.158 146.31,105.69 ; JDOCK1.158 148.19,105.69 ; JHDMI1.8 86.06,101.73 ; JHDMI1.8 85.6,101.61 ; JHDMI1.8 85.14,101.73 ; JHDMI1.8 85.6,102.78 ; JHDMI1.8 85.14,102.66 ; JHDMI1.8 86.06,102.66 ; 71.42,100.42 JUSB2.10 ; JUSB2.10 72.3,103.98 ; JUSB2.10 72.3,100.42 ; JUSB2.10 73.18,100.42 ; JUSB2.10 73.18,103.98 ; JUSB2.10 73.18,102.2 ; JDOCK1.154 148.3,109.65 ; JDOCK1.154 148.3,107.7 ; JDOCK1.154 146.2,108.67 ; JDOCK1.154 148.3,108.67 ; JDOCK1.154 146.2,109.65 ; JDOCK1.154 146.2,107.7 ; JDOCK1.154 147.25,107.7 ; JDOCK1.154 147.25,109.65 ; 290.15,64.52 JUSB3.4 ; JUSB3.4 290.69,64.67 ; JUSB3.4 291.23,63.44 ; JUSB3.4 290.69,63.29 ; JUSB3.4 291.38,63.98 ; JUSB3.4 291.23,64.52 ; JUSB3.4 290,63.98 ; JUSB3.4 290.15,63.44 ; H20.1 255.36,108.96 ; H20.1 254.94,110.16 ; H20.1 253.74,110.58 ; H20.1 252.11,108.96 ; H20.1 253.74,107.33 ; H20.1 254.94,107.76 ; H20.1 252.54,107.76 ; H20.1 252.54,110.16 ; H7.1 281.45,68.3 ; H7.1 277.39,68.3 ; H7.1 277.93,69.79 ; H7.1 280.91,69.79 ; H7.1 280.91,66.81 ; H7.1 277.93,66.81 ; H7.1 279.42,66.27 ; H7.1 279.42,70.33 ; JUSB3.10 293.07,69.21 ; JUSB3.10 291.29,68.33 ; JUSB3.10 291.29,67.45 ; JUSB3.10 291.29,69.21 ; JUSB3.10 294.85,68.33 ; JUSB3.10 293.07,67.45 ; JUSB3.10 294.85,69.21 ; H22.1 231.25,55.98 ; H22.1 232.88,54.35 ; H22.1 232.45,53.15 ; H22.1 231.25,52.72 ; H22.1 230.05,53.15 ; H22.1 229.62,54.35 ; H22.1 230.05,55.55 ; H22.1 232.45,55.55 ; 298.75,68.33 JUSB3.11 ; JUSB3.11 301.59,69.21 ; JUSB3.11 300.17,69.21 ; JUSB3.11 301.59,68.33 ; JUSB3.11 298.75,69.21 ; 181.9,77.8 H2.1 ; H2.1 185.94,79.5 ; H2.1 181.9,81.2 ; H2.1 183.6,77.16 ; H2.1 185.3,77.8 ; H2.1 183.6,81.84 ; H2.1 181.26,79.5 ; H2.1 185.3,81.2 ; 4.88,93.95 JUSB1.13 ; JUSB1.13 7.8,93.95 ; JUSB1.13 6.34,93.95 ; JUSB1.13 4.88,93 ; JUSB1.13 7.8,93 ; 128.69,100.82 JDOCK1.161 ; JDOCK1.161 130.75,99.85 ; JDOCK1.161 128.69,101.8 ; JDOCK1.161 132.81,99.85 ; JDOCK1.161 132.81,101.8 ; JDOCK1.161 130.75,101.8 ; JDOCK1.161 132.81,100.82 ; 177.42,102.77 JDOCK1.152 ; JDOCK1.152 178.48,104.75 ; JDOCK1.152 176.37,104.75 ; JDOCK1.152 176.37,106.73 ; JDOCK1.152 176.37,102.77 ; JDOCK1.152 177.42,106.73 ; JDOCK1.152 178.48,102.77 ; JDOCK1.152 178.48,106.73 ; 236.01,11.85 H25.1 ; H25.1 240.05,13.55 ; H25.1 238.35,9.51 ; H25.1 240.05,10.15 ; H25.1 238.35,14.19 ; H25.1 236.65,10.15 ; H25.1 236.65,13.55 ; H25.1 240.69,11.85 ; 78.47,102.8 JHDMI1.20 ; JHDMI1.20 80.23,104.55 ; JHDMI1.20 80.23,102.8 ; JHDMI1.20 79.35,101.04 ; JHDMI1.20 78.47,101.04 ; JHDMI1.20 80.23,101.04 ; JHDMI1.20 79.35,104.55 ; 283.61,107.49 JLOM1.14 ; JLOM1.14 285.44,105.73 ; JLOM1.14 283.61,109.24 ; JLOM1.14 284.53,109.24 ; JLOM1.14 283.61,105.73 ; JLOM1.14 284.53,105.73 ; JLOM1.14 285.44,107.49 ; JLOM1.14 285.44,109.24 ; 101.92,88.4 H23.1 ; H23.1 102.48,86.88 ; H23.1 104,90.48 ; H23.1 102.48,89.92 ; H23.1 106.08,88.4 ; H23.1 104,86.32 ; H23.1 105.52,89.92 ; H23.1 105.52,86.88 ; 171.25,103.7 JDOCK1.160 ; JDOCK1.160 172.05,105.55 ; JDOCK1.160 170.45,103.95 ; JDOCK1.160 172.3,104.75 ; JDOCK1.160 170.45,105.55 ; JDOCK1.160 172.05,103.95 ; JDOCK1.160 171.25,105.8 ; 8.8,96.65 H11.1 ; H11.1 10,99.48 ; H11.1 10,96.22 ; H11.1 11.2,99.05 ; H11.1 11.2,96.65 ; H11.1 8.8,99.05 ; H11.1 8.37,97.85 ; H11.1 11.63,97.85 ; 298.75,51.75 JUSB3.12 ; JUSB3.12 301.59,51.75 ; JUSB3.12 298.75,52.63 ; JUSB3.12 300.17,51.75 ; JUSB3.12 301.59,52.63 ; H14.1 121.45,105.55 ; H14.1 121.45,107.95 ; H14.1 121.88,106.75 ; H14.1 119.05,105.55 ; H14.1 118.62,106.75 ; H14.1 120.25,108.38 ; H14.1 120.25,105.12 ; H14.1 119.05,107.95 ; 121.2,81.2 H1.1 ; H1.1 120.56,79.5 ; H1.1 122.9,77.16 ; H1.1 122.9,81.84 ; H1.1 121.2,77.8 ; H1.1 124.6,77.8 ; H1.1 125.24,79.5 ; H1.1 124.6,81.2 ; JCRT1.17 230.42,104.99 ; JCRT1.17 230.42,107.51 ; JCRT1.17 228.66,104.99 ; JCRT1.17 228.66,106.25 ; JCRT1.17 229.54,107.51 ; JCRT1.17 228.66,107.51 ; JCRT1.17 230.42,106.25 ; JCRT1.17 229.54,104.99 ; 252.95,46.32 H8.1 ; H8.1 254.44,46.86 ; H8.1 254.98,48.35 ; H8.1 251.46,46.86 ; H8.1 251.46,49.84 ; H8.1 250.92,48.35 ; H8.1 254.44,49.84 ; H8.1 252.95,50.38 ; JUSB1.10 15.4,78.25 ; JUSB1.10 15.4,76.35 ; JUSB1.10 12.28,77.3 ; JUSB1.10 13.84,78.25 ; JUSB1.10 12.28,76.35 ; JUSB1.10 15.4,77.3 ; JUSB1.10 13.84,76.35 ; 44.3,13.25 H17.1 ; H17.1 44.3,10.85 ; H17.1 46.7,10.85 ; H17.1 43.87,12.05 ; H17.1 47.13,12.05 ; H17.1 45.5,13.68 ; H17.1 45.5,10.42 ; H17.1 46.7,13.25 ; 291.5,60.48 JUSB3.7 ; JUSB3.7 292.19,59.79 ; JUSB3.7 292.73,61.02 ; JUSB3.7 292.19,61.17 ; JUSB3.7 292.88,60.48 ; JUSB3.7 292.73,59.94 ; JUSB3.7 291.65,59.94 ; JUSB3.7 291.65,61.02 ; 159.25,107.7 JDOCK1.155 ; JDOCK1.155 160.3,107.7 ; JDOCK1.155 158.2,108.67 ; JDOCK1.155 159.25,109.65 ; JDOCK1.155 158.2,107.7 ; JDOCK1.155 160.3,108.67 ; JDOCK1.155 160.3,109.65 ; JDOCK1.155 158.2,109.65 ; 293.62,3.35 H24.1 ; H24.1 295.25,1.72 ; H24.1 295.25,4.98 ; H24.1 296.45,2.15 ; H24.1 296.88,3.35 ; H24.1 294.05,2.15 ; H24.1 296.45,4.55 ; H24.1 294.05,4.55 ; JHDMI1.17 90.56,104.16 ; JHDMI1.17 89.64,103.23 ; JHDMI1.17 90.56,103.23 ; JHDMI1.17 90.1,104.28 ; JHDMI1.17 89.64,104.16 ; JHDMI1.17 90.1,103.11 ; 293.07,51.75 JUSB3.13 ; JUSB3.13 294.85,51.75 ; JUSB3.13 291.29,51.75 ; JUSB3.13 291.29,53.51 ; JUSB3.13 291.29,52.63 ; JUSB3.13 293.07,53.51 ; JUSB3.13 294.85,52.63 ; 250.5,98.35 SW1.4 ; SW1.4 250.5,96.83 ; SW1.4 252.02,96.83 ; SW1.4 251.26,98.59 ; SW1.4 250.26,97.59 ; SW1.4 252.27,97.59 ; SW1.4 252.02,98.35 ; SW1.4 251.26,96.59 ; H4.1 185.94,52.2 ; H4.1 183.6,54.54 ; H4.1 181.9,50.5 ; H4.1 185.3,53.9 ; H4.1 183.6,49.86 ; H4.1 181.9,53.9 ; H4.1 185.3,50.5 ; H4.1 181.26,52.2 ; JDOCK1.156 177.81,109.65 ; JDOCK1.156 175.75,107.7 ; JDOCK1.156 173.69,107.7 ; JDOCK1.156 175.75,109.65 ; JDOCK1.156 173.69,108.67 ; JDOCK1.156 177.81,107.7 ; JDOCK1.156 177.81,108.67 ; JDOCK1.156 173.69,109.65 ; 153.25,17.72 H15.1 ; H15.1 154.45,18.15 ; H15.1 152.05,18.15 ; H15.1 151.62,19.35 ; H15.1 154.88,19.35 ; H15.1 152.05,20.55 ; H15.1 154.45,20.55 ; H15.1 153.25,20.98 ; JUSB1.4 16.17,81.65 ; JUSB1.4 15.43,80.91 ; JUSB1.4 16,82.22 ; JUSB1.4 15.43,82.39 ; JUSB1.4 14.86,81.08 ; JUSB1.4 14.86,82.22 ; JUSB1.4 16,81.08 ; JUSB1.4 14.69,81.65 ; H16.1 137.25,87.33 ; H16.1 138.45,84.5 ; H16.1 138.88,85.7 ; H16.1 136.05,84.5 ; H16.1 136.05,86.9 ; H16.1 138.45,86.9 ; H16.1 137.25,84.07 ; H16.1 135.62,85.7 ; 146.2,101.8 JDOCK1.162 ; JDOCK1.162 147.25,99.85 ; JDOCK1.162 148.3,101.8 ; JDOCK1.162 146.2,100.82 ; JDOCK1.162 148.3,99.85 ; JDOCK1.162 147.25,101.8 ; JDOCK1.162 148.3,100.82 ; JDOCK1.162 146.2,99.85 ; 248.76,104.99 JCRT1.16 ; JCRT1.16 248.76,106.25 ; JCRT1.16 250.52,107.51 ; JCRT1.16 249.64,107.51 ; JCRT1.16 249.64,104.99 ; JCRT1.16 250.52,104.99 ; JCRT1.16 248.76,107.51 ; JCRT1.16 250.52,106.25 ; 158.2,100.82 JDOCK1.163 ; JDOCK1.163 160.3,99.85 ; JDOCK1.163 159.25,99.85 ; JDOCK1.163 158.2,99.85 ; JDOCK1.163 160.3,100.82 ; JDOCK1.163 158.2,101.8 ; JDOCK1.163 159.25,101.8 ; JHDMI1.23 96.93,111.35 ; JHDMI1.23 96.93,108.2 ; JHDMI1.23 96.93,109.78 ; JHDMI1.23 95.85,111.35 ; JHDMI1.23 94.77,111.35 ; JHDMI1.23 95.85,108.2 ; JHDMI1.23 94.77,108.2 ; JHDMI1.23 94.77,109.78 ; 185.05,106.55 H18.1 ; H18.1 184.62,105.35 ; H18.1 185.05,104.15 ; H18.1 187.88,105.35 ; H18.1 186.25,103.72 ; H18.1 186.25,106.98 ; H18.1 187.45,106.55 ; H18.1 187.45,104.15 ; 82.6,101.61 JHDMI1.2 ; JHDMI1.2 82.14,102.66 ; JHDMI1.2 82.02,102.2 ; JHDMI1.2 82.14,101.73 ; JHDMI1.2 83.06,101.73 ; JHDMI1.2 83.06,102.66 ; JHDMI1.2 82.6,102.78 ; JCRT1.7 236.67,107.67 ; JCRT1.7 236.67,106.63 ; JCRT1.7 236.15,106.49 ; JCRT1.7 235.64,107.67 ; JCRT1.7 236.15,107.81 ; JCRT1.7 235.64,106.63 ; H21.1 285.25,55.48 ; H21.1 285.25,52.22 ; H21.1 286.45,55.05 ; H21.1 284.05,55.05 ; H21.1 284.05,52.65 ; H21.1 286.88,53.85 ; H21.1 283.62,53.85 ; H21.1 286.45,52.65 ; 83.64,103.23 JHDMI1.5 ; JHDMI1.5 84.1,103.11 ; JHDMI1.5 84.1,104.28 ; JHDMI1.5 83.64,104.16 ; JHDMI1.5 84.56,103.23 ; JHDMI1.5 84.56,104.16 ; 121.2,53.9 H3.1 ; H3.1 125.24,52.2 ; H3.1 124.6,53.9 ; H3.1 124.6,50.5 ; H3.1 120.56,52.2 ; H3.1 122.9,49.86 ; H3.1 122.9,54.54 ; H3.1 121.2,50.5 ; 128.02,106.73 JDOCK1.145 ; JDOCK1.145 130.13,106.73 ; JDOCK1.145 129.07,102.77 ; JDOCK1.145 130.13,104.75 ; JDOCK1.145 128.02,104.75 ; JDOCK1.145 130.13,102.77 ; JDOCK1.145 128.02,102.77 ; JDOCK1.145 129.07,106.73 ; 12.28,93.95 JUSB1.11 ; JUSB1.11 15.4,93.95 ; JUSB1.11 13.84,93.95 ; JUSB1.11 15.4,92.05 ; JUSB1.11 15.4,93 ; JUSB1.11 13.84,92.05 ; JUSB1.11 12.28,93 ; 55.72,102.2 JUSB2.11 ; JUSB2.11 56.6,103.98 ; JUSB2.11 56.6,100.42 ; JUSB2.11 55.72,103.98 ; JUSB2.11 55.72,100.42 ; JUSB2.11 57.48,100.42 ; 250.26,91.29 SW1.5 ; SW1.5 251.26,90.29 ; SW1.5 251.26,92.29 ; SW1.5 250.5,92.05 ; SW1.5 252.27,91.29 ; SW1.5 252.02,92.05 ; SW1.5 250.5,90.53 ; SW1.5 252.02,90.53 ; 264.56,107.49 JLOM1.16 ; JLOM1.16 265.48,109.24 ; JLOM1.16 266.39,109.24 ; JLOM1.16 266.39,107.49 ; JLOM1.16 264.56,105.73 ; JLOM1.16 266.39,105.73 ; JLOM1.16 265.48,105.73 ; 244.17,106.49 JCRT1.5 ; JCRT1.5 244.69,106.63 ; JCRT1.5 244.17,107.81 ; JCRT1.5 243.65,106.63 ; JCRT1.5 244.69,107.67 ; JCRT1.5 243.65,107.67 ; JCRT1.5 244.83,107.15 ; JCRT1.8 238.96,107.67 ; JCRT1.8 238.45,107.81 ; JCRT1.8 238.45,106.49 ; JCRT1.8 237.93,106.63 ; JCRT1.8 237.93,107.67 ; JCRT1.8 238.96,106.63 ; 51.05,107.55 H13.1 ; H13.1 52.25,107.98 ; H13.1 53.88,106.35 ; H13.1 53.45,107.55 ; H13.1 50.62,106.35 ; H13.1 53.45,105.15 ; H13.1 51.05,105.15 ; H13.1 52.25,104.72 ; H19.1 224.88,108.95 ; H19.1 222.05,110.15 ; H19.1 223.25,110.58 ; H19.1 221.62,108.95 ; H19.1 224.45,107.75 ; H19.1 222.05,107.75 ; H19.1 223.25,107.32 ; H19.1 224.45,110.15
  VCC w0.203: JHDMI1.11 87.56,103.23 ; JHDMI1.11 86.64,103.23 ; JHDMI1.11 87.1,103.11 ; 60.95,98.94 JUSB2.4 ; JUSB2.4 61.78,99.77 ; JUSB2.4 60.12,99.77 ; JUSB2.4 61.58,99.13 ; JUSB2.4 61.58,100.4 ; JUSB2.4 60.31,99.13 ; 82.14,102.66 JHDMI1.2 ; JHDMI1.2 83.06,101.73 ; JHDMI1.2 82.6,102.78 ; JHDMI1.2 82.6,101.61 ; JHDMI1.2 82.02,102.2 ; JHDMI1.2 83.06,102.66 ; JHDMI1.2 82.14,101.73 ; JHDMI1.21 94.73,102.8 ; JHDMI1.21 94.73,101.04 ; JHDMI1.21 92.97,101.04 ; JHDMI1.21 92.97,102.8 ; JHDMI1.21 93.85,101.04 ; JUSB1.10 15.4,76.35 ; JUSB1.10 12.28,76.35 ; JUSB1.10 13.84,76.35 ; JUSB1.10 15.4,77.3 ; JUSB1.10 15.4,78.25 ; 78.47,101.04 JHDMI1.20 ; JHDMI1.20 79.35,101.04 ; JHDMI1.20 78.47,102.8 ; JHDMI1.20 80.23,102.8 ; JHDMI1.20 80.23,101.04 ; 84.1,103.11 JHDMI1.5 ; JHDMI1.5 84.56,103.23 ; JHDMI1.5 83.64,103.23 ; 85.6,101.61 JHDMI1.8 ; JHDMI1.8 86.06,101.73 ; JHDMI1.8 85.14,101.73 ; JHDMI1.8 85.6,102.78 ; JHDMI1.8 85.14,102.66 ; JHDMI1.8 86.06,102.66 ; JUSB2.13 73.18,107.67 ; JUSB2.13 73.18,110.33 ; JUSB2.13 73.18,109 ; JUSB1.13 7.8,93.95 ; JUSB1.13 6.34,93.95 ; JUSB1.13 4.88,93.95 ; 95.85,108.2 JHDMI1.23 ; JHDMI1.23 96.93,109.78 ; JHDMI1.23 96.93,108.2 ; JUSB1.11 13.84,93.95 ; JUSB1.11 12.28,93.95 ; JUSB1.11 15.4,92.05 ; JUSB1.11 15.4,93 ; JUSB1.11 15.4,93.95 ; JUSB2.11 57.48,100.42 ; JUSB2.11 55.72,103.98 ; JUSB2.11 55.72,102.2 ; JUSB2.11 56.6,100.42 ; JUSB2.11 55.72,100.42 ; 45.5,10.42 H17.1 ; H17.1 47.13,12.05 ; H17.1 45.5,13.68 ; H17.1 46.7,10.85 ; H17.1 44.3,13.25 ; H17.1 44.3,10.85 ; H17.1 43.87,12.05 ; H17.1 46.7,13.25 ; H3.1 122.9,54.54 ; H3.1 125.24,52.2 ; H3.1 120.56,52.2 ; H3.1 121.2,50.5 ; H3.1 121.2,53.9 ; H3.1 124.6,53.9 ; H3.1 124.6,50.5 ; H3.1 122.9,49.86 ; H12.1 154.45,10.2 ; H12.1 154.45,12.6 ; H12.1 152.05,10.2 ; H12.1 151.62,11.4 ; H12.1 154.88,11.4 ; H12.1 153.25,13.03 ; H12.1 152.05,12.6 ; 76.27,109.78 JHDMI1.22 ; JHDMI1.22 76.27,108.2 ; JHDMI1.22 77.35,108.2 ; 55.72,110.33 JUSB2.12 ; JUSB2.12 55.72,109 ; JUSB2.12 55.72,107.67 ; H15.1 154.45,18.15 ; H15.1 152.05,18.15 ; H15.1 151.62,19.35 ; H15.1 154.45,20.55 ; H15.1 153.25,20.98 ; H15.1 154.88,19.35 ; H15.1 152.05,20.55 ; H15.1 153.25,17.72 ; H11.1 11.2,99.05 ; H11.1 8.37,97.85 ; H11.1 10,96.22 ; H11.1 10,99.48 ; H11.1 8.8,96.65 ; H11.1 8.8,99.05 ; H11.1 11.63,97.85 ; H11.1 11.2,96.65 ; JUSB1.4 16,81.08 ; JUSB1.4 14.86,82.22 ; JUSB1.4 16,82.22 ; JUSB1.4 15.43,80.91 ; JUSB1.4 16.17,81.65 ; JUSB1.4 15.43,82.39 ; JUSB1.4 14.69,81.65 ; JUSB1.4 14.86,81.08 ; 90.1,103.11 JHDMI1.17 ; JHDMI1.17 90.56,103.23 ; JHDMI1.17 89.64,103.23 ; 71.42,100.42 JUSB2.10 ; JUSB2.10 73.18,100.42 ; JUSB2.10 73.18,103.98 ; JUSB2.10 72.3,100.42 ; JUSB2.10 73.18,102.2 ; H13.1 53.45,107.55 ; H13.1 52.25,104.72 ; H13.1 50.62,106.35 ; H13.1 51.05,105.15 ; H13.1 51.05,107.55 ; H13.1 53.88,106.35 ; H13.1 53.45,105.15 ; H13.1 52.25,107.98 ; JUSB1.7 14.5,85.72 ; JUSB1.7 14.67,85.15 ; JUSB1.7 14.5,84.58 ; JUSB2.7 65.08,100.64 ; JUSB2.7 64.45,100.44 ; JUSB2.7 63.81,100.64
  GND3 w0.203: 51.05,105.15 H13.1 ; H13.1 53.45,107.55 ; H13.1 53.45,105.15 ; H13.1 52.25,107.98 ; H13.1 52.25,104.72 ; H13.1 53.88,106.35 ; H13.1 51.05,107.55 ; H13.1 50.62,106.35 ; 15.43,80.91 JUSB1.4 ; JUSB1.4 16,81.08 ; JUSB1.4 16.17,81.65 ; JUSB1.4 15.43,82.39 ; JUSB1.4 14.86,82.22 ; JUSB1.4 14.69,81.65 ; JUSB1.4 14.86,81.08 ; JUSB1.4 16,82.22 ; 128.02,102.77 JDOCK1.145 ; JDOCK1.145 130.13,104.75 ; JDOCK1.145 129.07,106.73 ; JDOCK1.145 128.02,106.73 ; JDOCK1.145 130.13,102.77 ; JDOCK1.145 128.02,104.75 ; JDOCK1.145 129.07,102.77 ; JDOCK1.145 130.13,106.73 ; JHDMI1.23 96.93,109.78 ; JHDMI1.23 94.77,108.2 ; JHDMI1.23 96.93,108.2 ; JHDMI1.23 96.93,111.35 ; JHDMI1.23 95.85,111.35 ; JHDMI1.23 94.77,109.78 ; JHDMI1.23 94.77,111.35 ; JHDMI1.23 95.85,108.2 ; 181.26,79.5 H2.1 ; H2.1 185.3,77.8 ; H2.1 185.3,81.2 ; H2.1 181.9,81.2 ; H2.1 183.6,81.84 ; H2.1 185.94,79.5 ; H2.1 181.9,77.8 ; H2.1 183.6,77.16 ; JDOCK1.153 132.81,109.65 ; JDOCK1.153 128.69,109.65 ; JDOCK1.153 132.81,108.67 ; JDOCK1.153 128.69,107.7 ; JDOCK1.153 130.75,109.65 ; JDOCK1.153 128.69,108.67 ; JDOCK1.153 130.75,107.7 ; JDOCK1.153 132.81,107.7 ; 243.02,106.49 JCRT1.10 ; JCRT1.10 242.51,107.67 ; JCRT1.10 243.54,107.67 ; JCRT1.10 243.54,106.63 ; JCRT1.10 242.51,106.63 ; JCRT1.10 243.02,107.81 ; JDOCK1.160 171.25,105.8 ; JDOCK1.160 170.45,103.95 ; JDOCK1.160 170.45,105.55 ; JDOCK1.160 172.05,105.55 ; JDOCK1.160 172.05,103.95 ; JDOCK1.160 171.25,103.7 ; JDOCK1.160 172.3,104.75 ; H20.1 255.36,108.96 ; H20.1 253.74,110.58 ; H20.1 254.94,107.76 ; H20.1 252.54,107.76 ; H20.1 252.54,110.16 ; H20.1 252.11,108.96 ; H20.1 254.94,110.16 ; H20.1 253.74,107.33 ; 158.2,100.82 JDOCK1.163 ; JDOCK1.163 159.25,101.8 ; JDOCK1.163 158.2,99.85 ; JDOCK1.163 159.25,99.85 ; JDOCK1.163 160.3,100.82 ; JDOCK1.163 158.2,101.8 ; JDOCK1.163 160.3,99.85 ; 159.25,103.49 JDOCK1.159 ; JDOCK1.159 159.25,106.01 ; JDOCK1.159 160.51,104.75 ; JDOCK1.159 158.31,103.81 ; JDOCK1.159 160.19,105.69 ; JDOCK1.159 157.99,104.75 ; JDOCK1.159 160.19,103.81 ; JDOCK1.159 158.31,105.69 ; H8.1 254.98,48.35 ; H8.1 251.46,49.84 ; H8.1 252.95,50.38 ; H8.1 250.92,48.35 ; H8.1 254.44,46.86 ; H8.1 254.44,49.84 ; H8.1 252.95,46.32 ; H8.1 251.46,46.86 ; 176.37,106.73 JDOCK1.152 ; JDOCK1.152 176.37,104.75 ; JDOCK1.152 178.48,106.73 ; JDOCK1.152 177.42,102.77 ; JDOCK1.152 178.48,104.75 ; JDOCK1.152 178.48,102.77 ; JDOCK1.152 176.37,102.77 ; JDOCK1.152 177.42,106.73 ; 228.66,104.99 JCRT1.17 ; JCRT1.17 229.54,107.51 ; JCRT1.17 230.42,106.25 ; JCRT1.17 230.42,104.99 ; JCRT1.17 228.66,107.51 ; JCRT1.17 229.54,104.99 ; JCRT1.17 228.66,106.25 ; JCRT1.17 230.42,107.51 ; 6.34,76.35 JUSB1.12 ; JUSB1.12 4.88,77.3 ; JUSB1.12 7.8,76.35 ; JUSB1.12 7.8,77.3 ; 152.05,18.15 H15.1 ; H15.1 152.05,20.55 ; H15.1 151.62,19.35 ; H15.1 154.88,19.35 ; H15.1 153.25,17.72 ; H15.1 154.45,18.15 ; H15.1 154.45,20.55 ; H15.1 153.25,20.98 ; 300.17,51.75 JUSB3.12 ; JUSB3.12 298.75,51.75 ; JUSB3.12 301.59,51.75 ; JUSB3.12 301.59,52.63 ; JUSB3.12 298.75,52.63 ; H19.1 224.45,110.15 ; H19.1 222.05,107.75 ; H19.1 223.25,107.32 ; H19.1 221.62,108.95 ; H19.1 224.88,108.95 ; H19.1 224.45,107.75 ; H19.1 222.05,110.15 ; H19.1 223.25,110.58 ; JHDMI1.20 80.23,101.04 ; JHDMI1.20 78.47,101.04 ; JHDMI1.20 79.35,104.55 ; JHDMI1.20 80.23,102.8 ; JHDMI1.20 78.47,102.8 ; JHDMI1.20 79.35,101.04 ; JHDMI1.20 80.23,104.55 ; 43.87,12.05 H17.1 ; H17.1 44.3,13.25 ; H17.1 46.7,10.85 ; H17.1 44.3,10.85 ; H17.1 47.13,12.05 ; H17.1 45.5,13.68 ; H17.1 45.5,10.42 ; H17.1 46.7,13.25 ; H16.1 138.45,84.5 ; H16.1 136.05,86.9 ; H16.1 137.25,87.33 ; H16.1 138.45,86.9 ; H16.1 135.62,85.7 ; H16.1 138.88,85.7 ; H16.1 136.05,84.5 ; H16.1 137.25,84.07 ; H3.1 125.24,52.2 ; H3.1 124.6,53.9 ; H3.1 121.2,50.5 ; H3.1 120.56,52.2 ; H3.1 122.9,54.54 ; H3.1 122.9,49.86 ; H3.1 121.2,53.9 ; H3.1 124.6,50.5 ; H23.1 105.52,86.88 ; H23.1 106.08,88.4 ; H23.1 104,86.32 ; H23.1 101.92,88.4 ; H23.1 102.48,89.92 ; H23.1 104,90.48 ; H23.1 102.48,86.88 ; H23.1 105.52,89.92 ; 4.88,93.95 JUSB1.13 ; JUSB1.13 7.8,93.95 ; JUSB1.13 6.34,93.95 ; JUSB1.13 7.8,93 ; JUSB1.13 4.88,93 ; 55.72,100.42 JUSB2.11 ; JUSB2.11 56.6,103.98 ; JUSB2.11 55.72,103.98 ; JUSB2.11 57.48,100.42 ; JUSB2.11 56.6,100.42 ; JUSB2.11 55.72,102.2 ; H22.1 232.88,54.35 ; H22.1 231.25,55.98 ; H22.1 230.05,55.55 ; H22.1 231.25,52.72 ; H22.1 229.62,54.35 ; H22.1 232.45,53.15 ; H22.1 230.05,53.15 ; H22.1 232.45,55.55 ; 158.2,109.65 JDOCK1.155 ; JDOCK1.155 160.3,108.67 ; JDOCK1.155 158.2,107.7 ; JDOCK1.155 159.25,107.7 ; JDOCK1.155 159.25,109.65 ; JDOCK1.155 158.2,108.67 ; JDOCK1.155 160.3,109.65 ; JDOCK1.155 160.3,107.7 ; 128.69,101.8 JDOCK1.161 ; JDOCK1.161 130.75,99.85 ; JDOCK1.161 128.69,100.82 ; JDOCK1.161 132.81,99.85 ; JDOCK1.161 132.81,100.82 ; JDOCK1.161 130.75,101.8 ; JDOCK1.161 132.81,101.8 ; 248.76,107.51 JCRT1.16 ; JCRT1.16 250.52,104.99 ; JCRT1.16 249.64,104.99 ; JCRT1.16 250.52,107.51 ; JCRT1.16 250.52,106.25 ; JCRT1.16 249.64,107.51 ; JCRT1.16 248.76,106.25 ; JCRT1.16 248.76,104.99 ; JUSB3.7 292.73,61.02 ; JUSB3.7 292.19,61.17 ; JUSB3.7 292.73,59.94 ; JUSB3.7 291.5,60.48 ; JUSB3.7 292.88,60.48 ; JUSB3.7 291.65,59.94 ; JUSB3.7 291.65,61.02 ; JUSB3.7 292.19,59.79 ; 87.1,103.11 JHDMI1.11 ; JHDMI1.11 87.1,104.28 ; JHDMI1.11 86.64,103.23 ; JHDMI1.11 86.64,104.16 ; JHDMI1.11 87.56,104.16 ; JHDMI1.11 87.56,103.23 ; JUSB1.7 14.67,85.15 ; JUSB1.7 13.93,85.89 ; JUSB1.7 13.93,84.41 ; JUSB1.7 14.5,85.72 ; 72.3,100.42 JUSB2.10 ; JUSB2.10 73.18,103.98 ; JUSB2.10 72.3,103.98 ; JUSB2.10 73.18,102.2 ; JUSB2.10 71.42,100.42 ; JUSB2.10 73.18,100.42 ; 283.61,105.73 JLOM1.14 ; JLOM1.14 283.61,109.24 ; JLOM1.14 284.53,109.24 ; JLOM1.14 285.44,107.49 ; JLOM1.14 283.61,107.49 ; JLOM1.14 285.44,109.24 ; JLOM1.14 284.53,105.73 ; JLOM1.14 285.44,105.73 ; JHDMI1.5 84.56,103.23 ; JHDMI1.5 83.64,103.23 ; JHDMI1.5 84.1,103.11 ; JHDMI1.5 83.64,104.16 ; JHDMI1.5 84.1,104.28 ; JHDMI1.5 84.56,104.16 ; H1.1 124.6,77.8 ; H1.1 124.6,81.2 ; H1.1 121.2,77.8 ; H1.1 125.24,79.5 ; H1.1 120.56,79.5 ; H1.1 122.9,81.84 ; H1.1 121.2,81.2 ; H1.1 122.9,77.16 ; JCRT1.6 234.38,107.67 ; JCRT1.6 234.38,106.63 ; JCRT1.6 233.35,107.67 ; JCRT1.6 233.86,107.81 ; JCRT1.6 233.86,106.49 ; JCRT1.6 233.35,106.63 ; JCRT1.6 233.2,107.15 ; 82.14,102.66 JHDMI1.2 ; JHDMI1.2 83.06,101.73 ; JHDMI1.2 82.6,102.78 ; JHDMI1.2 82.6,101.61 ; JHDMI1.2 82.14,101.73 ; JHDMI1.2 82.02,102.2 ; JHDMI1.2 83.06,102.66 ; JHDMI1.22 78.43,111.35 ; JHDMI1.22 76.27,111.35 ; JHDMI1.22 78.43,109.78 ; JHDMI1.22 77.35,108.2 ; JHDMI1.22 76.27,108.2 ; JHDMI1.22 78.43,108.2 ; JHDMI1.22 76.27,109.78 ; JHDMI1.22 77.35,111.35 ; 89.64,104.16 JHDMI1.17 ; JHDMI1.17 90.1,103.11 ; JHDMI1.17 89.64,103.23 ; JHDMI1.17 90.1,104.28 ; JHDMI1.17 90.56,103.23 ; JHDMI1.17 90.56,104.16 ; H12.1 154.88,11.4 ; H12.1 153.25,13.03 ; H12.1 153.25,9.77 ; H12.1 154.45,12.6 ; H12.1 152.05,12.6 ; H12.1 154.45,10.2 ; H12.1 151.62,11.4 ; H12.1 152.05,10.2 ; JUSB3.4 291.38,63.98 ; JUSB3.4 290.15,63.44 ; JUSB3.4 290.15,64.52 ; JUSB3.4 290.69,63.29 ; JUSB3.4 290,63.98 ; JUSB3.4 290.69,64.67 ; JUSB3.4 291.23,64.52 ; JUSB3.4 291.23,63.44 ; 60.95,98.94 JUSB2.4 ; JUSB2.4 60.12,99.77 ; JUSB2.4 60.31,99.13 ; JUSB2.4 61.58,100.4 ; JUSB2.4 61.58,99.13 ; JUSB2.4 61.78,99.77 ; JLOM1.16 266.39,105.73 ; JLOM1.16 266.39,107.49 ; JLOM1.16 266.39,109.24 ; JLOM1.16 265.48,105.73 ; JLOM1.16 264.56,107.49 ; JLOM1.16 264.56,105.73 ; JLOM1.16 265.48,109.24 ; H4.1 185.94,52.2 ; H4.1 181.9,53.9 ; H4.1 181.26,52.2 ; H4.1 183.6,49.86 ; H4.1 185.3,53.9 ; H4.1 181.9,50.5 ; H4.1 183.6,54.54 ; H4.1 185.3,50.5 ; H11.1 11.63,97.85 ; H11.1 11.2,96.65 ; H11.1 8.8,99.05 ; H11.1 8.37,97.85 ; H11.1 11.2,99.05 ; H11.1 10,96.22 ; H11.1 10,99.48 ; H11.1 8.8,96.65 ; 284.05,55.05 H21.1 ; H21.1 284.05,52.65 ; H21.1 286.88,53.85 ; H21.1 285.25,52.22 ; H21.1 286.45,52.65 ; H21.1 283.62,53.85 ; H21.1 286.45,55.05 ; H21.1 285.25,55.48 ; JCRT1.5 244.69,107.67 ; JCRT1.5 244.83,107.15 ; JCRT1.5 244.17,106.49 ; JCRT1.5 243.65,107.67 ; JCRT1.5 244.17,107.81 ; JCRT1.5 244.69,106.63 ; JCRT1.5 243.65,106.63 ; SW1.5 252.27,91.29 ; SW1.5 251.26,92.29 ; SW1.5 252.02,92.05 ; SW1.5 251.26,90.29 ; SW1.5 250.5,90.53 ; SW1.5 250.26,91.29 ; SW1.5 250.5,92.05 ; SW1.5 252.02,90.53 ; JUSB3.10 294.85,68.33 ; JUSB3.10 294.85,69.21 ; JUSB3.10 291.29,67.45 ; JUSB3.10 293.07,69.21 ; JUSB3.10 293.07,67.45 ; JUSB3.10 291.29,68.33 ; JUSB3.10 291.29,69.21 ; JDOCK1.154 148.3,109.65 ; JDOCK1.154 147.25,109.65 ; JDOCK1.154 147.25,107.7 ; JDOCK1.154 148.3,108.67 ; JDOCK1.154 146.2,107.7 ; JDOCK1.154 146.2,109.65 ; JDOCK1.154 148.3,107.7 ; JDOCK1.154 146.2,108.67 ; 184.62,105.35 H18.1 ; H18.1 185.05,104.15 ; H18.1 186.25,103.72 ; H18.1 187.45,106.55 ; H18.1 187.45,104.15 ; H18.1 186.25,106.98 ; H18.1 185.05,106.55 ; H18.1 187.88,105.35 ; JHDMI1.8 86.06,102.66 ; JHDMI1.8 86.06,101.73 ; JHDMI1.8 85.6,102.78 ; JHDMI1.8 85.14,102.66 ; JHDMI1.8 85.14,101.73 ; JHDMI1.8 85.6,101.61 ; JUSB1.10 15.4,76.35 ; JUSB1.10 15.4,78.25 ; JUSB1.10 15.4,77.3 ; JUSB1.10 12.28,77.3 ; JUSB1.10 13.84,78.25 ; JUSB1.10 13.84,76.35 ; JUSB1.10 12.28,76.35 ; JUSB3.13 293.07,53.51 ; JUSB3.13 294.85,52.63 ; JUSB3.13 291.29,51.75 ; JUSB3.13 291.29,52.63 ; JUSB3.13 293.07,51.75 ; JUSB3.13 294.85,51.75 ; JUSB3.13 291.29,53.51 ; H24.1 296.45,2.15 ; H24.1 295.25,4.98 ; H24.1 294.05,4.55 ; H24.1 296.88,3.35 ; H24.1 296.45,4.55 ; H24.1 295.25,1.72 ; H24.1 294.05,2.15 ; H24.1 293.62,3.35 ; 146.31,103.81 JDOCK1.158 ; JDOCK1.158 145.99,104.75 ; JDOCK1.158 148.19,103.81 ; JDOCK1.158 146.31,105.69 ; JDOCK1.158 147.25,106.01 ; JDOCK1.158 148.51,104.75 ; JDOCK1.158 148.19,105.69 ; JDOCK1.158 147.25,103.49 ; H25.1 240.05,10.15 ; H25.1 240.05,13.55 ; H25.1 236.65,13.55 ; H25.1 238.35,14.19 ; H25.1 236.65,10.15 ; H25.1 238.35,9.51 ; H25.1 236.01,11.85 ; H25.1 240.69,11.85 ; SW1.4 252.02,96.83 ; SW1.4 251.26,98.59 ; SW1.4 250.5,96.83 ; SW1.4 252.27,97.59 ; SW1.4 252.02,98.35 ; SW1.4 250.5,98.35 ; SW1.4 251.26,96.59 ; SW1.4 250.26,97.59 ; 173.69,100.82 JDOCK1.164 ; JDOCK1.164 173.69,99.85 ; JDOCK1.164 175.75,99.85 ; JDOCK1.164 177.81,101.8 ; JDOCK1.164 173.69,101.8 ; JDOCK1.164 177.81,99.85 ; JDOCK1.164 177.81,100.82 ; JDOCK1.164 175.75,101.8 ; JUSB1.11 13.84,93.95 ; JUSB1.11 12.28,93 ; JUSB1.11 12.28,93.95 ; JUSB1.11 15.4,92.05 ; JUSB1.11 13.84,92.05 ; JUSB1.11 15.4,93.95 ; JUSB1.11 15.4,93 ; JUSB2.7 65.08,100.64 ; JUSB2.7 65.28,101.27 ; JUSB2.7 63.81,100.64 ; JUSB2.7 64.45,100.44 ; JUSB2.7 63.62,101.27 ; H14.1 121.45,107.95 ; H14.1 119.05,107.95 ; H14.1 121.88,106.75 ; H14.1 119.05,105.55 ; H14.1 120.25,105.12 ; H14.1 121.45,105.55 ; H14.1 120.25,108.38 ; H14.1 118.62,106.75 ; JUSB2.13 73.18,107.67 ; JUSB2.13 73.18,109 ; JUSB2.13 73.18,110.33 ; JUSB2.13 72.3,110.33 ; JUSB2.13 72.3,107.67 ; JCRT1.8 238.96,106.63 ; JCRT1.8 237.93,106.63 ; JCRT1.8 238.96,107.67 ; JCRT1.8 238.45,107.81 ; JCRT1.8 238.45,106.49 ; JCRT1.8 237.93,107.67 ; JDOCK1.156 177.81,109.65 ; JDOCK1.156 173.69,109.65 ; JDOCK1.156 173.69,107.7 ; JDOCK1.156 175.75,109.65 ; JDOCK1.156 175.75,107.7 ; JDOCK1.156 177.81,107.7 ; JDOCK1.156 173.69,108.67 ; JDOCK1.156 177.81,108.67 ; 277.93,66.81 H7.1 ; H7.1 277.93,69.79 ; H7.1 280.91,66.81 ; H7.1 281.45,68.3 ; H7.1 277.39,68.3 ; H7.1 279.42,70.33 ; H7.1 279.42,66.27 ; H7.1 280.91,69.79 ; JHDMI1.21 94.73,101.04 ; JHDMI1.21 92.97,101.04 ; JHDMI1.21 92.97,104.55 ; JHDMI1.21 93.85,104.55 ; JHDMI1.21 94.73,102.8 ; JHDMI1.21 93.85,101.04 ; JHDMI1.21 92.97,102.8 ; 134.45,103.95 JDOCK1.157 ; JDOCK1.157 136.05,103.95 ; JDOCK1.157 135.25,103.7 ; JDOCK1.157 136.05,105.55 ; JDOCK1.157 135.25,105.8 ; JDOCK1.157 134.2,104.75 ; JDOCK1.157 134.45,105.55 ; 235.64,107.67 JCRT1.7 ; JCRT1.7 235.64,106.63 ; JCRT1.7 236.15,107.81 ; JCRT1.7 236.15,106.49 ; JCRT1.7 236.67,106.63 ; JCRT1.7 236.67,107.67 ; 298.75,68.33 JUSB3.11 ; JUSB3.11 300.17,69.21 ; JUSB3.11 301.59,68.33 ; JUSB3.11 301.59,69.21 ; JUSB3.11 298.75,69.21 ; JDOCK1.162 148.3,101.8 ; JDOCK1.162 148.3,99.85 ; JDOCK1.162 146.2,99.85 ; JDOCK1.162 148.3,100.82 ; JDOCK1.162 147.25,101.8 ; JDOCK1.162 146.2,101.8 ; JDOCK1.162 146.2,100.82 ; JDOCK1.162 147.25,99.85 ; JUSB2.12 56.6,110.33 ; JUSB2.12 56.6,107.67 ; JUSB2.12 55.72,110.33 ; JUSB2.12 55.72,109 ; JUSB2.12 55.72,107.67
  GND3 w0.508: 14.66,85.13 13.95,85.13 JUSB1.7
  BOTTOM w0.102: 151.84,76.57 151.62,76.34 151.62,76.04 151.7,75.95 151.7,75.76 151.62,75.67 151.62,75.4 151.88,75.14
  BOTTOM w0.152: v2(131.96,73.13) 132.14,72.96 132.79,72.96 132.85,72.94 UC1.H71 ; UC1.BB60 139.48,54.84 139.48,53.97 v2(139.46,53.94)
  BOTTOM w0.178: UC1.AG71 132.37,63.34 132.14,63.34 v2(131.93,63.55) ; v2(162.98,53.93) 162.98,53.93 162.95,53.96 UC1.BB18 ; v2(159.26,53.9) 159.2,53.95 159.2,54.46 UC1.BB26 ; v2(151.91,53.87) 151.88,53.9 151.88,54.84 UC1.BB38 ; v2(131.95,58.33) 132.13,58.34 UC1.AT71 ; UC1.BB55 142.1,54.47 142.1,53.98 v2(142.14,53.94) ; v2(156.98,53.69) 156.85,53.82 156.85,54.21 UC1.BB30 ; v2(137.15,53.94) 137.15,53.94 137.15,54.33 UC1.BB64 ; UC1.AM71 132.74,60.7 132.72,60.71 132.41,60.71 132.41,60.71 v2(131.96,60.71) ; UC1.BB43 149.27,53.93 v2(149.24,53.9) ; v2(154.18,53.26) 154.22,53.3 154.22,54.59 UC1.BB34
  BOTTOM w0.203: v2(134.53,56.94) 134.72,57.13 UC1.AV68 ; UC1.AW49 146.14,56.81 146.17,56.84 146.46,56.84 146.49,56.81 UC1.AW47 147.3,56.81 147.33,56.84 147.63,56.84 147.66,56.81 UC1.AW45 148.53,56.81 148.56,56.84 148.85,56.84 148.89,56.8 149.36,56.8 UC1.AW43 ; UC1.BA1 173.19,55.16 UC1.BA2 ; UC1.B34 153.5,76.52 153.5,77.31 ; UC1.AL55 142.8,61.36 UC1.AM55 ; UC1.D34 153.16,75.13 153.69,74.6 153.69,74.15 UC1.F35 153.06,74.05 v2(152.87,74.05) 152.67,74.05 UC1.F37 151.88,74.31 151.88,75.14 ; v2(135.49,56.68) 135.68,56.68 UC1.AW66 136.03,56.86 137,56.86 UC1.AW64 137.53,56.81 137.56,56.84 137.86,56.84 137.89,56.81 UC1.AW62 138.76,56.81 138.79,56.84 139.08,56.84 139.11,56.81 UC1.AW60 139.98,56.81 140.02,56.84 140.31,56.84 140.34,56.81 UC1.AW57 ; v2(135.49,56.68) UC1.AY66 UC1.BA66 ; v2(135.49,56.68) 135.04,57.13 UC1.AV68 ; v2(173.96,56.88) 173.83,57.02 UC1.AV1 ; v2(152.13,77.75) 152.13,77.71 151.84,77.42 151.84,76.57 ; UC1.AL66 136.07,61 136.12,60.95 136.5,60.95 136.54,61 UC1.AL65 136.71,61 136.75,60.95 137.13,60.95 137.18,61 UC1.AL64 ; v2(165.7,57.36) 165.7,57.13 UC1.AW14 165.86,56.81 165.89,56.84 166.18,56.84 166.21,56.81 UC1.AW12 167.04,56.81 v2(167.52,57.29) 167.79,57.02 UC1.AW10 168.28,56.81 168.31,56.84 168.6,56.84 168.63,56.81 UC1.AW8 ; UC1.AM68 135,60.3 135.03,60.27 135.03,59.98 135,59.95 UC1.AP68 135,59.08 135.03,59.05 135.03,58.75 135,58.72 UC1.AT68 135,57.92 135.05,57.75 135.05,57.56 135,57.51 135,57.14 UC1.AV68 ; UC1.AM68 135,61.18 135.05,61.23 135.05,61.57 135.01,61.62 134.68,61.95 UC1.AK68 134.74,62.02 v2(135.08,62.36) 135.08,62.47 135.33,62.72 UC1.AH67 ; UC1.AM68 135.19,60.79 v2(135.49,60.49) ; UC1.AM13 166.12,61.26 165.69,61.68 165.69,62.13 v2(165.64,62.19) ; UC1.AW21 161.37,56.81 161.34,56.84 161.05,56.84 161.02,56.81 UC1.AW23 160.05,56.81 160.02,56.84 159.72,56.84 159.69,56.81 UC1.AW26 158.82,56.81 158.79,56.84 158.49,56.84 158.46,56.81 UC1.AW28 157.59,56.81 157.56,56.84 157.27,56.84 157.24,56.81 UC1.AW30 156.37,56.81 156.33,56.84 156.04,56.84 156.01,56.81 UC1.AW32 155.16,56.81 v2(154.67,57.3) 154.32,56.96 UC1.AW34 153.84,56.81 153.81,56.84 153.51,56.84 153.48,56.81 UC1.AW36 152.61,56.81 152.58,56.84 152.29,56.84 152.26,56.81 UC1.AW38 ; UC1.AB16 164.62,65.82 165.19,65.82 UC1.AB15 ; UC1.AL45 148.29,61.36 UC1.AM43 ; UC1.AH63 UC1.AF63 ; UC1.AU15 164.37,56.81 UC1.AW16 163.79,56.81 163.76,56.84 163.47,56.84 163.44,56.81 UC1.AW18 162.52,56.81 162.49,56.84 ; UC1.AL52 v2(144.63,62.21) ; v2(194.78,89.11) 194.78,88.95 194.65,88.82 UV26.11 ; UV26.19 197.85,88.49 198.11,88.75 198.31,88.75 v2(198.72,89.16) ; UV26.52 189.49,84.13 189.22,83.86 189.22,83.59 189.44,83.37 189.44,83.14 v2(189.5,83.09) ; UC1.AW55 142.49,56.81 142.52,56.84 142.81,56.84 142.84,56.81 UC1.AW53 143.71,56.81 143.74,56.84 144.04,56.84 144.07,56.81 UC1.AW51 ; UC1.AL48 146.46,61.36 UC1.AM46
  BOTTOM w0.229: JDOCK1.91 158,99.81 158.23,99.58 159.04,99.58 159.39,99.23 v2(159.39,99.26) ; v2(171.06,106.79) 171.06,107.4 170.63,107.82 170.63,107.82 170.5,107.96 JDOCK1.138 ; v2(164.35,101.98) 164.5,101.83 JDOCK1.113 ; JDOCK1.102 161.5,109.98 v2(161.53,110.01) ; v2(165.9,107.4) 166,107.5 JDOCK1.120 ; v2(143.42,99.32) 143.42,99.67 143.5,99.75 JDOCK1.37 ; JDOCK1.13 v2(137.5,99.35) ; v2(135.57,102.54) 135.47,102.54 134.5,101.57 JDOCK1.1 ; v2(162.93,102.04) 162.95,102.01 162.95,100.8 JDOCK1.107 ; JDOCK1.31 142,99.55 v2(141.79,99.34) ; JDOCK1.58 149.5,110.42 v2(149.78,110.7) ; v2(135.83,110.21) 136,110.04 JDOCK1.8 ; v2(155.99,110.06) 155.5,109.57 JDOCK1.82 ; JDOCK1.63 151,99.47 v2(150.54,99.01) ; v2(150.21,102.25) 150.21,101.82 150.5,101.53 JDOCK1.61 ; v2(145.4,102.29) 145.74,102.29 146,102.03 JDOCK1.47 ; v2(171.39,103.31) 170.5,102.42 JDOCK1.137 ; JDOCK1.25 v2(140.5,99.37) ; v2(155.56,102.01) 155.56,102.04 155.5,101.97 JDOCK1.81 ; v2(149.05,98.95) 149.05,98.98 149.5,99.43 JDOCK1.57 ; JDOCK1.20 v2(139,110.16) ; JDOCK1.101 161.5,101.94 v2(161.43,102.01) ; JDOCK1.43 v2(145,99.47) ; v2(157.57,102.62) 157.57,102.24 157,101.67 JDOCK1.87 ; JDOCK1.32 142,110.19 v2(142.07,110.27) ; v2(150.66,110.73) 151,110.39 JDOCK1.64 ; v2(168.95,102.01) 169,101.96 JDOCK1.131 ; v2(168.75,106.63) 168.76,106.64 168.76,107.15 169,107.4 JDOCK1.132 ; JDOCK1.7 136,99.65 136.02,99.63 136.02,99.53 v2(136.18,99.36) ; v2(167.37,107.22) 167.37,107.45 167.5,107.57 JDOCK1.126 ; JDOCK1.14 v2(137.5,110.11) ; v2(144.71,110.16) 144.74,110.16 145,109.9 JDOCK1.44 ; JDOCK1.69 152.5,101.78 v2(151.89,102.39) ; JDOCK1.38 v2(143.5,110.19) ; JDOCK1.26 v2(140.5,110.16) ; JDOCK1.19 v2(139,99.42)
  BOTTOM w0.254: UC1.K67 135.31,71.8 v2(135.62,71.48) 135.96,71.81 UC1.K66 ; UC1.E6 169.77,74.44 169.43,74.1 v2(169.3,74.1) 169.17,74.1 UC1.F8 168.8,73.79 168.44,74.15 v2(168.39,74.15) ; UC1.AR43 v2(149.21,59.22) UC1.AP42 ; UC1.D39 150.86,75.35 v2(150.86,75.72) 150.86,76 UC1.B39 ; v2(235.29,75.26) 235.29,75.26 235.29,75.26 235.08,75.05 JNGFF2.11 ; UC1.AD62 138.8,64.67 138.8,63.94 138.56,63.7 UC1.AF63 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 ; JDIMM2.18 165.12,13.73 v2(165.06,13.8) ; v2(160.79,68) 161.16,68.37 UC1.T21 ; UC1.BA62 v2(138.32,56.3) UC1.AW62 ; UC1.AN28 156.98,60.15 156.64,59.86 v2(156.52,59.86) UC1.AN30 ; 161.96,65 UC1.AD20 ; 161.96,65 161.96,65 162.29,64.67 ; 161.96,65 161.34,65 UC1.AD21 ; UC1.AD19 162.29,64.68 162.29,64.67 ; v2(186.5,22.31) 187.37,21.43 JDIMM2.107 ; UC1.AU32 155.12,57.65 v2(154.67,57.3) ; UC1.N6 170.93,70.55 v2(170.93,70.74) ; UC1.AP58 v2(140.06,59.22) ; UC1.AK16 164.49,61.66 164.06,62.09 163.7,62.09 ; UC1.D11 v2(166.81,74.87) UC1.E11 ; v2(143.72,58.59) UC1.AR52 v2(144.63,58.59) UC1.AR50 ; UC1.AR45 v2(147.38,58.59) UC1.AR46 ; 162.49,56.84 162.46,56.86 UC1.AU20 v2(162.01,57.95) UC1.AT20 ; UC1.AN23 v2(159.26,59.86) ; UC1.B14 v2(165.55,75.68) UC1.D14 ; v2(152.13,77.75) 152.13,79.08 152.26,79.21 152.26,79.54 152.67,79.95 152.67,81.18 152.11,81.74 v2(151.98,81.74) ; UC1.J13 UC1.J11 167.04,71.84 167.37,71.5 UC1.L11 167.37,71.17 167.7,70.84 167.7,70.57 168.02,70.25 ; UC1.W13 166.03,67.09 164.96,67.09 164.58,67.47 UC1.V16 ; UC1.G10 167.92,73.14 167.65,73.41 v2(167.47,73.41) ; v2(156.74,71.63) 156.74,71.84 156.52,72.06 UC1.J28 ; UC1.G63 137.74,73.2 ; 137.74,73.2 v2(138.14,73.6) ; 137.74,73.2 137.74,73.16 UC1.K61 ; UC1.AG16 UC1.AG17 163.93,63.45 163.6,63.77 v2(163.6,63.79) ; UC1.AN42 149.73,60.25 v2(150.12,59.86) UC1.AN40 ; JEDP1.15 90.25,87.27 90.51,87.53 v2(90.51,88.04) ; UC1.AR42 149.62,58.95 v2(149.17,58.59) 149.62,58.3 UC1.AT42 ; v2(276.82,16.29) 277,16.46 JSATA1.14 ; UC1.AW53 v2(143.28,56.3) UC1.BA53 ; v2(94.3,85.2) 94.3,85.17 94.75,85.62 JEDP1.6 ; v2(160.15,73.45) 160.06,73.45 UC1.F23 ; v2(160.15,73.45) 160.29,73.45 UC1.F22 ; v2(160.15,73.45) 160.46,73.14 UC1.G22 160.57,73.07 160.57,72.67 160.64,72.6 UC1.K22 ; JEDP1.4 95.75,85.35 v2(95.67,85.27) ; v2(148.29,60.51) UC1.AM43 ; UC1.F33 154.35,73.79 154.67,73.46 154.7,73.46 v2(154.72,73.44) ; UC1.A67 135.14,77.35 134.83,77.65 v2(134.83,77.75) ; UC1.AG19 162.47,63.34 162.46,63.35 162.08,63.35 162.07,63.34 UC1.AG20 161.98,63.29 161.64,62.95 v2(161.64,62.89) ; UC1.AG19 UC1.AG18 163.28,63.46 v2(163.6,63.79) ; UC1.AG19 162.63,63.2 163.28,62.55 UC1.AJ18 163.69,62.09 163.7,62.09 ; UC1.AR28 v2(156.52,58.59) UC1.AT28 ; UC1.B44 v2(148.2,75.7) UC1.D44 148.16,75.21 UC1.D45 ; UC1.AR23 v2(159.26,58.59) UC1.AT23 ; UC1.AR55 142.35,58.92 142.33,58.91 v2(141.89,58.56) ; v2(132.24,56.8) 132.24,56.86 132.33,56.94 UC1.AV71 UC1.AV70 UC1.AV69 v2(134.53,56.94) ; v2(162.95,72.72) 163.16,72.72 163.38,72.5 UC1.H18 163.26,72.37 163.26,71.74 UC1.K18 163.31,71.72 163.69,72.11 164.83,72.11 UC1.H15 ; v2(164.43,74.96) 164.95,74.44 UC1.E15 165.21,74.38 165.29,74.3 165.7,74.3 166.12,73.87 UC1.F13 ; UC1.AB18 162.85,66.28 v2(162.32,66.28) 162.32,66.39 UC1.Y19 163.01,67.07 163.55,67.07 UC1.Y17 ; UC1.N10 168.02,70.25 ; 168.02,70.25 168.02,70.22 168.35,69.9 v2(168.35,69.78) ; UC1.AR53 v2(142.8,58.59) ; UC1.P17 163.28,68.56 UC1.T18 ; UC1.P17 UC1.T17 ; UC1.P17 163.93,69.21 163.61,69.52 v2(163.61,69.6) ; UC1.AM27 v2(157.44,60.51) ; v2(84.92,88.47) 85.25,88.15 JEDP1.25 ; UC1.AW57 v2(140.8,56.3) UC1.BA57 ; CC21.2 150.85,83.81 150.85,86.63 151.29,87.06 154.98,87.06 155.24,86.81 155.24,84.03 155.97,83.29 155.97,82.01 155.52,81.56 155.14,81.56 154.4,80.82 154.4,78.38 153.5,77.47 153.5,77.31 ; v2(151.01,73.38) 151.03,73.36 UC1.J38 ; v2(151.01,73.38) 151.09,73.38 151.49,73.78 UC1.F38 ; v2(151.01,73.38) 150.99,73.38 150.59,73.79 UC1.F40 ; v2(137.58,62.33) UC1.AH63 ; v2(137.58,62.33) UC1.AK63 138.58,61.04 UC1.AM61 ; v2(137.58,62.33) 137.34,62.69 UC1.AH64 ; UC1.Y21 161.33,66.55 v2(161.63,66.25) ; v2(158.14,71.61) 158.35,71.82 UC1.J25 ; v2(166,102.04) 165.95,102.04 166,101.99 JDOCK1.119 ; UC1.C5 170.79,75.86 v2(170.62,75.7) 170.48,75.55 UC1.D6 ; UC1.AL38 151.95,62.13 152.01,62.18 v2(152.01,62.23) ; v2(154.49,102.42) 154.44,102.42 154,101.97 JDOCK1.75 ; v2(163.6,63.79) 163.6,63.87 163.91,64.18 UC1.AF17 ; UC1.AL66 135.98,60.98 v2(135.49,60.49) ; UC1.AF15 165.25,64.18 v2(165.67,64.6) 165.99,64.91 UC1.AD13 ; v2(161.09,60.49) 161.14,60.49 UC1.AM21 161.55,61.44 UC1.AK21 160.81,61.66 UC1.AK22 ; UC1.N65 136.63,70.04 v2(136.99,69.68) ; 137.26,71.87 137.29,71.9 UC1.K63 ; 137.26,71.87 UC1.K64 ; 137.26,71.87 136.94,71.56 v2(136.94,71.45) ; JNGFF2.63 234.78,60.05 v2(235.01,60.28) ; UC1.AJ20 161.64,62.84 v2(161.64,62.89) ; 162.29,64.67 v2(162.29,64.56) ; 162.98,56.12 162.95,56.08 UC1.BA18 ; 162.98,56.12 162.95,56.15 UC1.AW18 ; 162.98,56.12 v2(162.96,56.12) ; UC1.AF1 UC1.AF2 172.09,63.7 v2(171.89,63.5) 171.69,63.7 UC1.AF4 ; UC1.AM25 v2(158.35,60.51) ; v2(235.03,59.47) 234.94,59.55 JNGFF2.65 ; JDOCK1.88 v2(157,110.06) ; UC1.AK18 163.7,62.09 ; v2(169.33,73.44) 169.48,73.44 UC1.G6 170,73.36 170.47,73.36 UC1.G5 ; UC1.B58 UC1.D58 140.77,75.09 v2(141.08,74.78) 141.43,74.44 UC1.E56 ; v2(156.56,73.46) 156.56,73.57 156.78,73.79 UC1.F28 UC1.F27 ; UC1.AP35 v2(152.86,59.22) ; v2(168.29,63.4) 168.29,63.53 168.02,63.79 UC1.AF10 ; UC1.AL35 v2(153.78,62.03) ; UC1.BA10 v2(167.79,56.3) UC1.AW10 ; 170.64,69.18 171.23,69.18 UC1.T4 171.49,69.01 171.7,68.81 171.9,69.01 UC1.T2 ; 170.64,69.18 UC1.R6 ; 170.64,69.18 170.64,69.08 v2(170.27,68.71) ; UC1.AB21 161.33,65.94 v2(161.63,66.25) ; UC1.V16 164.54,67.49 163.97,67.49 ; UC1.V16 164.58,67.59 v2(164.91,67.92) 164.91,68.03 165.23,68.34 UC1.T15 ; UC1.F32 155.15,73.78 154.8,73.44 v2(154.72,73.44) ; UC1.N19 162.63,69.99 v2(162.31,69.67) 162.31,69.57 161.98,69.23 UC1.P20 UC1.P19 ; UC1.AM55 142.33,60.88 v2(141.89,60.51) ; UC1.K65 136.61,71.78 v2(136.31,71.48) ; UC1.AA65 136.63,66.33 v2(136.97,65.99) ; UC1.AK69 134.01,62.02 134.19,62.19 134.5,62.19 UC1.AK68 ; UC1.AL2 172.11,61.05 v2(171.92,61.24) 171.73,61.05 UC1.AL4 UC1.AJ4 171.36,61.72 170.9,62.18 170.63,62.64 UC1.AH6 ; UC1.BA14 v2(165.37,56.15) UC1.AW14 ; UC1.U67 135.47,68.13 135.47,67.97 v2(135.65,67.8) 135.83,67.97 135.83,68.12 UC1.U66 ; UC1.G55 142.19,73.14 v2(141.9,73.44) ; UC1.AP20 162.26,59.6 v2(161.93,59.93) 162.25,60.25 UC1.AN20 ; UC1.B66 UC1.D66 135.81,75.12 v2(136.18,74.76) 136.45,74.76 UC1.E65 ; UC1.AD8 169.32,64.62 v2(169.53,64.42) ; v2(85.56,88.85) 85.75,88.66 JEDP1.24 ; JDOCK1.114 164.5,107.47 v2(164.4,107.37) ; UC1.AD16 164.46,65.02 164.25,65.23 v2(164.25,65.41) 164.25,65.52 UC1.AB16 ; UC1.AB8 169.32,65.92 v2(169.71,65.54) ; UC1.AP68 v2(134.39,59.51) UC1.AP70 ; UC1.L18 UC1.L17 164.02,70.79 164.49,70.79 UC1.L16 164.59,70.88 164.83,71.12 v2(164.83,71.3) 164.83,71.47 UC1.K16 ; UC1.AN33 v2(153.78,59.86) ; UC1.AR48 145.99,58.95 145.72,59.22 v2(145.55,59.22) ; UC1.AP18 163.03,59.31 163.03,59.31 v2(163.01,59.29) ; v2(168.95,66.53) 168.67,66.8 UC1.W9 168.02,67.7 UC1.U10 ; UC1.AW28 v2(158.03,56.3) UC1.BA28 ; UC1.AL32 155.61,62.21 155.33,62.49 v2(155.33,62.92) ; UC1.E50 144.96,74.44 v2(144.59,74.81) ; UC1.B30 v2(155.64,75.67) UC1.D30 ; UC1.J32 154.75,72.73 154.75,73.41 v2(154.72,73.44) ; UC1.AT2 172.07,58.4 v2(171.89,58.22) 171.71,58.4 UC1.AT4 ; UC1.E21 161.23,74.76 161.01,74.76 UC1.D22 160.59,75.65 160.64,75.69 ; v2(281.7,80.92) 281.7,81.16 281.96,81.41 281.96,81.88 CL16.2 281.83,82.01 CL17.2 ; UC1.AA2 UC1.AA4 171.35,66.36 v2(171,66.7) 170.66,67.05 UC1.W6 ; JSATA1.12 276,15.9 275.75,15.65 v2(275.65,15.65) ; UC1.AM60 139.54,60.96 138.75,60.96 UC1.AM61 ; UC1.AP23 v2(159.26,59.22) ; UC1.BA36 v2(153.05,56.3) UC1.AW36 ; v2(161.93,58.61) 162.36,58.95 UC1.AR20 ; UC1.AW6 170.17,56.34 v2(170.21,56.3) ; UC1.L2 172.36,71.64 v2(171.89,71.64) 171.42,71.64 UC1.L4 ; UC1.AL58 v2(140.98,62.2) ; UC1.AP38 v2(151.03,59.22) ; JDOCK1.55 149,99.01 v2(149.05,98.95) ; UC1.V17 163.97,67.49 ; 163.97,67.49 163.32,67.49 UC1.V18 163.28,67.55 162.98,67.85 v2(162.98,67.95) ; UC1.AM8 169.32,61.36 UC1.AK8 169.32,61.91 v2(168.96,62.27) 168.42,62.27 168.37,62.22 167.69,62.22 167.37,61.91 UC1.AK11 ; UC1.BB6 170.21,54.99 170.21,54.99 170.21,55.45 170.21,55.45 UC1.BA6 v2(170.21,56.3) ; UC1.AR8 168.81,58.95 168.54,59.22 v2(168.44,59.22) ; UC1.AP32 v2(154.69,59.22) ; 160.64,75.69 v2(160.61,75.69) ; 160.64,75.69 160.64,75.7 160.59,75.74 UC1.B22 ; UC1.AU10 167.95,57.6 v2(167.52,57.29) ; UC1.D62 138.47,75.34 138.47,75.52 v2(138.54,75.59) 138.54,75.57 138.34,75.77 138.34,76.13 UC1.B62 ; v2(170.21,56.3) 170.46,56.55 170.97,56.55 171.22,56.3 171.43,56.3 171.91,55.82 UC1.AY3 UC1.BA2 ; UC1.AT35 v2(152.86,58.59) UC1.AR35 ; v2(150.57,56.3) UC1.BA41 ; v2(134.82,53.78) 135.14,54.1 UC1.BB67 ; UC1.J35 152.87,72.68 v2(152.87,74.05) ; v2(146.46,60.51) UC1.AM46 ; v2(131,54.74) 131,54.9 131.33,55.22 131.33,55.34 131.73,55.74 132.63,55.74 UC1.AY71 ; PU402.6 199.04,70.37 v2(198.84,70.57) ; UC1.AW49 v2(145.68,56.3) UC1.BA49 ; UC1.BA32 v2(155.52,56.3) UC1.AW32 ; UC1.AN38 v2(151.95,59.86) UC1.AN37 ; v2(251.04,20.77) 250.95,20.86 JNGFF1.22 ; v2(135.01,69.68) 134.68,70.01 UC1.N68 ; v2(143.75,74.71) 143.48,74.44 UC1.E53 143.26,75.16 UC1.D53 v2(143.25,75.66) UC1.B53 ; v2(137.32,59.86) 137.5,60.01 137.52,60.01 137.66,60.15 UC1.AN63 ; UC1.AN35 v2(152.86,59.86) ; v2(143.75,73.44) 144.05,73.14 UC1.G52 ; UC1.AR11 167.04,59.02 167.32,59.31 v2(167.53,59.31) 167.6,59.37 167.88,59.6 UC1.AP10 ; UC1.AR16 164.66,58.59 v2(164.75,58.59) UC1.AR15 ; UC1.AU38 151.08,57.35 v2(151.09,57.35) ; v2(145.55,73.41) 145.83,73.14 UC1.G48 ; v2(165.7,57.36) 165.44,57.36 165.21,57.59 UC1.AU15 ; UC1.E18 163.11,74.71 162.98,74.71 v2(162.95,74.68) ; JDOCK1.123 167,99.84 166.82,99.65 v2(166.82,99.26) 167.34,99.26 167.5,99.43 JDOCK1.125 ; UC1.D18 v2(163.07,75.69) UC1.B18 ; JSATA1.18 279,18.74 279.31,19.05 v2(279.31,19.36) ; v2(153.88,110.09) 153.96,110.01 153.96,109.75 154,109.71 JDOCK1.76 ; UC1.AP63 v2(137.32,59.22) ; UC1.D10 168.03,75.62 v2(167.98,75.67) 168.03,75.72 UC1.B10 ; v2(171.17,77.75) 171.09,77.67 UC1.A5 ; v2(131.74,75.01) 131.94,74.81 132.6,74.81 132.66,74.75 UC1.E71 ; v2(173.77,76.51) 173.46,76.19 UC1.C1 ; UC1.B48 145.73,75.9 v2(145.91,75.72) 145.77,75.58 145.77,75.21 ; v2(170.21,58.64) 170.41,58.79 170.45,58.79 170.61,58.95 UC1.AR5 ; UC1.E46 146.69,74.44 v2(146.44,74.68) 146.4,74.72 UC1.D47 145.77,75.21 ; UC1.B34 v2(153.16,75.68) UC1.D34 ; UC1.AT58 v2(140.06,58.59) UC1.AR58 ; 145.77,75.21 UC1.D48 ; v2(136.21,74.17) 136.21,73.79 135.69,73.28 UC1.G66 ; UC1.Y20 161.98,66.59 v2(161.63,66.25) ; UC1.G60 139.74,73.14 v2(140.04,73.44) 140.34,73.14 UC1.G58 ; UC1.D69 134.11,74.82 v2(133.97,74.68) 134.48,74.17 UC1.F68 ; UC1.U69 133.9,68.14 133.9,68 v2(133.69,67.8) 133.49,68 133.49,68.16 UC1.U70 ; UC1.BA23 v2(160.51,56.3) UC1.AW23 ; UC1.AA68 134.81,66.31 134.81,66.17 v2(135.01,65.97) ; UC1.AH13 166.07,62.78 165.64,62.35 v2(165.64,62.19) 165.32,62.5 UC1.AJ15 ; v2(173.54,74.44) 173.42,74.31 UC1.F1 ; UC1.U63 137.93,68.2 137.65,67.92 v2(137.65,67.8) 137.28,68.17 UC1.U64 ; UC1.AP28 v2(156.52,59.22) ; UC1.L20 161.33,70.23 UC1.N21 161.33,69.95 v2(160.97,69.6) 161.31,69.26 161.31,69.22 UC1.P21 ; UC1.A70 133.18,77.16 132.94,77.4 v2(132.4,77.4) ; v2(132.07,71.25) 132.32,71.5 132.96,71.5 UC1.K71 UC1.K70 134.59,71.59 UC1.K68 ; JEDP1.8 93.75,87.57 v2(93.84,87.66) ; JSATA1.1 v2(270.5,18.52) ; UC1.AM45 v2(147.38,60.51) ; UC1.BB70 132.22,54.53 132.17,54.59 132.17,54.94 v2(131.99,55.12) 132.46,55.12 132.49,55.09 132.63,55.09 UC1.BA71 ; UC1.D25 UC1.C25 158.7,75.77 158.06,75.77 157.92,75.64 v2(157.92,75.72) 157.89,75.69 157.89,75.67 158.12,75.44 UC1.D26 ; UC1.L8 169.32,71.38 168.87,71.84 UC1.J8 168.87,71.87 168.62,72.11 168.42,72.11 v2(168.41,72.12) ; UC1.AN32 v2(154.69,59.86) ; v2(163.21,107.32) 163,107.52 163,107.9 163,107.91 JDOCK1.108 ; v2(161.64,62.89) 161.33,63.2 UC1.AG21 ; v2(138.23,60.51) UC1.AM61 ; UC1.AL28 157.44,61.38 157.52,61.47 UC1.AK27 v2(157.89,62.75) ; UC1.AT63 v2(137.32,58.59) UC1.AR63 ; v2(132.02,76.56) 132.18,76.72 132.7,76.72 UC1.B71 ; UC1.AN58 v2(140.06,59.86) ; JEDP1.23 86.25,87.39 v2(86.57,87.71) ; UC1.BA45 v2(148.09,56.3) ; UC1.F2 v2(171.89,74.31) UC1.F4 ; UC1.AT56 v2(140.98,57.95) ; JSATA1.4 v2(272,18.57)
  BOTTOM w0.279: JNGFF1.21 v2(250.7,13.72) ; JNGFF1.15 249.2,13.73 249.18,13.71 v2(249.18,13.69) ; JNGFF1.31 v2(253.2,13.64) ; JNGFF1.25 v2(251.7,13.67)
  BOTTOM w0.305: JDIMM2.30 168.12,13.28 v2(168.16,13.31) ; JDIMM1.60 v2(93.62,12.98) ; JDIMM2.102 186.12,13 v2(186.02,13.11) ; JNGFF1.61 260.7,13.73 v2(260.59,13.62) ; v2(123.53,18.7) 123.37,18.86 JDIMM1.171 ; JDIMM2.189 209.87,18.38 v2(208.67,17.17) ; JDIMM1.36 v2(87.62,12.96) ; JDIMM1.197 129.87,16.91 129.09,16.13 v2(129.07,16.13) ; JDIMM2.235 221.37,18.09 v2(222.31,17.15) ; v2(139.94,14.58) 139.12,13.77 JDIMM1.234 ; JNGFF3.9 264.55,7.8 v2(264.5,7.75) ; v2(225.56,18.73) 225.37,18.92 JDIMM2.251 ; v2(174.13,13.47) 174.13,13.16 173.62,12.66 JDIMM2.52 ; v2(171.92,13.26) 171.62,12.97 JDIMM2.44 ; v2(224.12,21.16) 224.37,20.9 JDIMM2.247 ; JNGFF1.1 v2(243.7,13.57) ; JDIMM2.69 177.87,18.1 v2(178.62,17.35) ; v2(262.37,13.67) 262.2,13.84 JNGFF1.67 ; v2(217.41,13.06) 217.12,12.77 JDIMM2.218 ; JNGFF1.37 254.7,13.87 253.91,13.08 v2(253.4,13.08) ; JDIMM2.172 v2(205.62,12.98) ; v2(260.46,7.7) 260.05,8.11 JNGFF3.27 ; JDIMM2.39 170.37,18.22 v2(170.4,18.19) ; v2(167.17,13.31) 167.12,13.27 JDIMM2.26 ; JDIMM2.193 210.87,18.55 v2(210.8,18.48) ; v2(208.53,21.61) 207.87,20.95 JDIMM2.181 ; JDIMM2.201 212.87,19.12 212.48,18.72 212.46,18.72 v2(212.43,18.7) ; v2(176.16,14.08) 175.62,13.54 JDIMM2.60 ; JDIMM2.196 211.62,10.47 v2(211.7,10.4) ; v2(165.85,17.4) 165.23,18.02 165.23,18.62 165.37,18.77 JDIMM2.19 ; v2(97.42,18.7) 97.22,18.7 96.87,19.04 JDIMM1.73 ; JDIMM2.103 186.37,18.9 v2(185.97,18.5) ; JDIMM2.231 220.37,18.98 220.48,18.88 220.48,16.89 v2(219.87,16.29) ; JDIMM1.89 v2(100.87,18.57) ; JDIMM1.223 136.37,17.47 v2(135.29,16.39) ; v2(257.24,7.95) 257.24,8.08 257.05,8.27 JNGFF3.39 ; v2(225.28,10.41) 225.28,10.5 225.62,10.84 JDIMM2.252 ; JDIMM2.106 v2(187.12,10.37) ; JDIMM1.247 142.37,20.85 v2(142.91,21.39) ; JDIMM2.214 v2(216.12,10.38) ; JDIMM1.94 102.12,13.28 v2(101.48,13.92) ; v2(162.77,10.34) 163.12,10.69 JDIMM2.10 ; JDIMM2.222 v2(218.12,12.98) ; JDIMM1.56 92.62,13.8 93.37,14.55 v2(93.66,14.55) ; JDIMM2.197 211.87,17.99 211.38,17.49 ; v2(228.85,91.71) 229.14,92 UV28.5 ; v2(124.04,14.05) 123.56,13.57 123.56,12.45 123.62,12.38 JDIMM1.172 ; v2(181.49,13.26) 181.12,12.89 JDIMM2.82 ; JDIMM1.1 v2(78.87,18.72) ; v2(265.67,7.75) 266.05,8.13 JNGFF3.3 ; v2(235.29,69.47) 235.21,69.55 JNGFF2.25 ; v2(131.1,13.21) 131.12,13.19 JDIMM1.202 ; JDIMM2.2 v2(161.12,10.32) ; JDIMM1.52 91.62,10.85 91.48,10.7 91.48,10.7 v2(91.27,10.49) ; v2(249.26,20.74) 249.26,21.26 249.45,21.45 JNGFF1.16 ; JDIMM1.31 86.37,16.92 v2(85.69,16.23) ; JDIMM1.19 v2(83.37,18.67) ; v2(139.94,17.63) 139.37,18.2 JDIMM1.235 ; JNGFF3.57 252.55,8.17 252.72,8 253.28,8 v2(253.33,8.06) ; JNGFF2.49 235.13,63.55 v2(235.29,63.71) ; v2(266.58,7.57) 266.58,7.77 266.55,7.8 JNGFF3.1 ; v2(223.33,13.01) 223.62,12.71 JDIMM2.244 ; v2(185.08,10.32) 185.12,10.36 JDIMM2.98 ; UL2.3 281.21,72.5 v2(281.42,72.29) ; JNGFF2.43 233.08,65.05 232.75,64.72 v2(232.62,64.72) ; v2(174.89,14.81) 174.62,14.55 JDIMM2.56 ; v2(204.43,13.08) 204.62,12.89 JDIMM2.168 ; JDIMM2.23 166.37,16.41 v2(165.85,15.88) ; v2(204.37,18.55) JDIMM2.167 ; v2(163.18,14.18) 163.31,14.18 164.12,13.36 JDIMM2.14 ; JDIMM2.192 210.62,13.57 v2(211.08,14.03) ; v2(99.87,18.66) JDIMM1.85 ; JDIMM2.78 v2(180.12,13.26) ; v2(204.37,16.88) 205.37,17.88 JDIMM2.171 ; v2(232.63,66.5) 232.58,66.5 232.63,66.55 JNGFF2.37 ; v2(87.49,17.56) 87.37,17.67 JDIMM1.35 ; v2(134.17,14.38) 135.12,13.43 JDIMM1.218 ; v2(206.72,17.94) 206.37,18.29 JDIMM2.175 ; JDIMM2.99 v2(185.37,18.52) ; v2(203.72,92.03) 203.72,91.57 RC182.1 ; JDIMM1.68 v2(95.62,10.32) ; JDIMM1.238 v2(140.12,13.08) ; JNGFF1.43 256.2,13.84 v2(256.48,13.57) ; JNGFF3.21 261.55,8.2 v2(261.1,7.75) ; v2(152.53,106.05) 152.53,108.75 JDOCK1.70 ; JDIMM1.14 82.12,12.93 v2(82.23,13.03) ; v2(178.7,15.83) 179.11,16.23 179.11,18.75 178.87,18.98 JDIMM2.73 ; v2(163.28,18.19) 162.87,18.6 JDIMM2.9 ; JDIMM2.230 220.12,13.34 219.82,13.65 v2(219.59,13.65) ; JDIMM2.185 208.87,18.9 v2(208.67,18.7) ; JDIMM1.192 v2(128.62,10.27) ; JDIMM1.168 122.62,13.13 v2(121.91,13.85) ; JDIMM2.213 215.87,18.13 v2(214.84,17.1) ; v2(252.51,23.65) 252.45,23.59 JNGFF1.28 ; v2(181.88,17.1) 180.87,18.1 JDIMM2.81 ; v2(258.41,7.8) 258.55,7.95 JNGFF3.33 ; JDIMM1.210 133.12,10.49 v2(133.08,10.44) ; v2(223.84,17.86) 223.37,18.32 JDIMM2.243 ; JNGFF3.45 255.55,8.02 v2(255.43,7.9) ; JDIMM2.90 183.12,13.1 v2(183.34,13.32) ; JDIMM1.206 v2(132.12,10.41) ; JDIMM2.206 214.12,13.24 214.68,13.8 v2(215,13.8) ; JDIMM1.243 v2(141.37,18.41) ; v2(170.62,10.34) JDIMM2.40 ; v2(139.99,16.11) 140.42,16.54 140.42,18.65 140.37,18.7 JDIMM1.239 ; v2(104.02,13.67) 103.81,13.67 103.12,12.99 JDIMM1.98 ; JDIMM2.64 v2(176.62,10.4) ; JDIMM1.244 v2(141.62,13.01) ; v2(254.06,10.37) 254.05,10.36 JNGFF3.51 ; JDIMM2.36 169.62,13.25 v2(169.58,13.29) ; JDIMM2.77 179.87,15.64 v2(180.1,15.42) ; v2(208.67,10.37) 208.62,10.42 JDIMM2.184 ; v2(219.9,17.81) 219.37,18.33 JDIMM2.227 ; JDIMM2.210 v2(215.12,10.37) ; v2(232.62,71.05) JNGFF2.19 ; JDIMM2.94 184.12,13.71 v2(184.59,14.18) ; JDIMM1.184 v2(126.62,10.27) ; JNGFF2.3 v2(235.08,77.05) ; v2(232.7,68.53) 232.73,68.53 232.87,68.39 232.87,68.38 233.1,68.14 233.12,68.14 233.21,68.05 JNGFF2.31 ; JDIMM2.238 222.12,12.97 221.45,13.64 221.22,13.64 v2(221.07,13.8) ; v2(216.88,18.7) 216.87,18.71 JDIMM2.217 ; JDIMM1.201 v2(130.87,18.67) ; v2(135.09,18.75) 134.87,18.96 JDIMM1.217 ; v2(124.85,13.97) 125.62,13.2 JDIMM1.180 ; JDIMM2.31 168.37,17.44 167.6,16.67 v2(167.35,16.67) ; v2(97.62,15.65) 98.03,16.06 98.03,18.96 97.87,19.12 JDIMM1.77 ; v2(124.9,13.16) 124.62,12.88 JDIMM1.176 ; v2(97.55,17.17) 97.01,17.17 95.87,18.31 JDIMM1.69 ; JDIMM2.202 v2(213.12,13.01) ; JNGFF2.5 234.83,76.55 235.05,76.33 v2(235.09,76.33) ; v2(81.52,13.24) 81.52,13.14 81.12,12.74 JDIMM1.10 ; JNGFF3.15 v2(263.05,7.77) ; JDIMM1.214 v2(134.12,10.42) ; JDIMM1.222 v2(136.12,13.46) ; JDIMM2.223 218.37,17.32 217.42,16.36 v2(216.83,16.36) ; JDIMM2.35 169.37,16.94 167.58,15.14 v2(167.4,15.14) ; JNGFF1.10 247.95,21 v2(247.69,20.74) ; JDIMM1.57 v2(92.87,18.32) ; JDIMM1.26 85.12,10.42 ; JDIMM2.27 v2(167.37,18.19) ; JDIMM2.234 221.12,10.4 v2(221.12,10.39) ; UC1.T15 165.23,68.6 165.81,69.18 UC1.R13 166.07,69.38 v2(166.51,69.81) UC1.N13 ; JDIMM1.22 v2(84.12,10.42) ; CI7.2 v2(18.21,87.48) ; JDIMM2.180 207.62,13.02 v2(207.35,13.29) ; JDIMM1.90 101.12,12.88 v2(101.41,13.16) ; v2(222.37,18.71) JDIMM2.239 ; JDIMM2.209 v2(214.87,18.63) ; JDIMM2.22 v2(166.12,10.45) ; v2(208.6,13.82) 209.62,12.79 JDIMM2.188 ; v2(142.62,14.27) JDIMM1.248 ; JDIMM1.107 105.37,18.98 105.02,18.62 v2(104.35,18.62) ; JDIMM2.205 213.87,18.27 212.78,17.17 v2(212.38,17.17) ; JDIMM1.65 v2(94.87,18.72) ; JNGFF1.7 v2(245.2,13.54) ; JDIMM2.176 v2(206.62,13.38) ; JDIMM2.226 219.12,10.68 v2(219.44,10.37) ; JDIMM1.196 v2(129.62,13.24) ; v2(224.12,13.82) 224.62,13.31 JDIMM2.248
  BOTTOM w0.356: v2(257.57,13.69) 257.7,13.83 JNGFF1.49 ; JNGFF1.55 259.2,13.83 v2(259.07,13.69)
  BOTTOM w0.381: PC1004.2 113.47,75.1 v2(113.47,74.78) ; CC23.1 181.24,60.71 v2(181.27,60.68) 181.24,60.65 CC26.1 ; v2(191.1,56.09) 189.91,54.91 CC10.2 ; v2(149.14,92.38) 148.96,92.21 CV121.2 ; v2(114.87,77.96) 114.87,78.27 PC1005.2 ; v2(117.5,64.85) 117.5,65.28 PC1026.2 ; CV118.2 126.8,89.65 v2(126.25,90.2) ; v2(112.08,71.61) 112.08,71.92 PC1008.2 ; PC1176.2 113.78,68 v2(113.78,67.59) ; PC1006.2 112.08,75.1 v2(112.08,74.78) ; RC113.1 125.32,85.99 v2(124.9,85.58) ; v2(228.27,91.84) 228.27,91.42 228.32,91.37 CV615.2 ; v2(166.82,84.99) 166.76,84.99 166.76,85.09 167.31,85.64 UZ21.5 ; PC1081.2 114.87,71.92 v2(114.87,71.61) ; CZ85.2 176.11,85.64 v2(176.11,86.19) ; v2(97.27,85.14) 97.46,85.14 98.29,84.32 CV9.2 ; PC1025.2 113.8,62.73 v2(113.8,62.31) ; v2(120.46,71.61) 120.46,71.92 PC1174.2 ; RV606.1 192.94,80.94 192.91,80.94 192.84,81 192.32,81 v2(192.29,81.03) ; CE3.2 251.67,88.27 251.47,88.47 v2(251.47,88.9) ; PC1080.2 113.47,78.27 v2(113.47,77.96) ; v2(213.17,88.85) 213.17,89.51 CV89.2 CV86.2 ; v2(112.31,62.36) 112.31,62.75 PC1024.2 ; v2(117.55,67.56) 117.55,67.98 PC1175.2 ; PC1177.2 116.12,65.42 v2(116.12,64.93) ; v2(207.61,89.77) 207.63,89.74 CV114.2 ; v2(179.46,92.7) 179.46,92.71 179.87,92.31 RC227.2 ; v2(113.47,71.61) 113.47,71.92 PC1007.2 ; RC268.2 180.48,68.62 v2(180.81,68.62) 181.35,68.62 RC342.2 ; v2(144.49,86.09) 144.49,85.99 144.08,85.58 UV12.7 ; v2(116.27,71.61) 116.27,71.92 PC1002.2 ; PC1172.2 119.06,71.92 v2(119.06,71.61) ; CL10.2 262.02,93.31 CL4.2 261.41,94.43 CL19.2 260.72,94.83 259.92,94.03 v2(259.45,94.03) ; v2(117.66,71.61) 117.66,71.92 PC1173.2 ; v2(180.89,91.16) 181.36,90.69 UC12.3 ; PC1009.2 114.87,75.1 v2(114.87,74.78) ; PC1010.2 112.08,78.27 v2(112.08,77.96) ; RV600.2 200.05,88.94 198.93,88.94 v2(198.72,89.16) ; PC1023.2 112.36,65.35 v2(112.36,64.88) ; PC1178.2 116.12,68.1 v2(116.12,67.57) ; v2(112.28,67.57) 112.28,67.95 PC1179.2 ; PC1022.2 113.8,65.29 v2(113.8,64.88) ; UV11.7 120.71,94.59 120.36,94.94 v2(120.36,95.13) ; UZ20.5 v2(172.18,88.65) ; v2(167.4,84.61) CZ84.2
  BOTTOM w0.457: v2(163.03,82.83) 163.03,82.93 163.36,83.27 CC195.2 ; CV604.2 189.44,91.34 188.26,92.52 188.26,93.52 188.35,93.61 188.35,93.98 v2(188.58,94.21) ; PC207.1 92.66,49.29 92.14,49.81 v2(91.93,49.81) 91.58,49.46 CC32.2 ; CV58.2 v2(243.59,103.92) ; v2(158.51,81.87) 159.4,82.76 CC220.2 ; CV57.2 v2(244.46,103.97) ; DI1.3 v2(20.41,81.39) ; CV50.2 v2(241.82,103.99) ; DI5.1 284.06,62.41 v2(284.76,61.71)
  BOTTOM w0.508: 90.66,79.02 90.66,78.95 90.44,78.72 90.44,78.71 90.21,78.49 90.21,78.49 89.88,78.16 PR662.2 ; 90.66,79.02 90.79,78.9 90.79,78.87 91.12,78.54 91.15,78.54 v2(91.27,78.41) ; 90.66,79.02 CV374.2 ; v2(270.21,31.16) JSD1.6 ; CZ78.2 164.46,83.53 v2(164.98,83.01) 165.06,83.09 165.09,83.09 166.05,84.05 CC219.2 ; v2(281.75,14.61) 281.05,13.91 JSATA1.22 ; v2(180.53,66.43) 180.53,65.94 179.96,65.37 ; JNGFF3.68 267.65,6.3 v2(267.3,5.95) ; v2(168.22,95.13) 168.22,94.51 168.47,94.26 CZ87.2 ; v2(199.39,92.78) 199.15,92.53 199.15,91.5 CV605.2 ; v2(94.3,82) 94.23,81.93 94.23,81.64 93.49,80.9 CV10.2 ; v2(98.75,82.77) 99.02,82.5 RV3.1 ; PC126.2 221.25,57.26 v2(221.25,56.86) ; QV11.3 203.03,90.42 v2(203.03,89.59) ; v2(288.15,90.53) CL18.2 288.6,91.3 v2(288.89,91.01) ; v2(126.48,88.42) 126.4,88.35 CC301.2 ; v2(97.09,53.34) 96.82,53.34 96.74,53.27 96.66,53.27 96.43,53.04 PC214.2 ; PQ902.1 255.22,94.68 255.71,95.18 v2(255.89,95.18) ; PR505.2 v2(208.05,110.7) ; v2(199.55,80.55) 199.55,80.15 199.25,79.85 RV607.1 ; v2(96.77,82.43) 96.37,82.43 95.86,81.91 UV24.2 ; PQ906.3 38.16,81.78 v2(38.16,82.4) ; v2(66.36,72.32) 66.36,72.32 65.77,71.73 JFAN1.1 ; v2(203.28,55.84) 203.21,55.91 PR412.2 ; v2(272.07,6) 272.18,5.89 JRTC1.2 ; CC222.2 179.85,65.26 179.96,65.37 ; CMOS1.2 262.04,27.38 v2(261.87,27.56) ; v2(187.23,94.17) 186.32,93.26 186.32,92.72 ; v2(17.74,84.03) 17.99,84.28 DI2.1 ; v2(222.46,96.73) 222.6,96.86 PR510.2 ; PC621.1 76.64,61.59 76.57,61.67 76.57,61.93 v2(76.39,62.11) ; JEDP1.45 v2(75.35,90.53) ; CV97.2 221.78,87.19 v2(222.01,87.41) ; v2(270.27,14.69) 270.27,14.24 JSATA1.23 ; CC22.2 v2(153.55,83.06) ; 179.96,65.37 CC212.2 ; v2(239,103.97) 239.16,103.81 CV59.2 ; PQ902.4 256.5,92.36 256.5,92.61 256.46,92.65 256.46,92.68 256.31,92.83 256.31,93.25 v2(256.33,93.27) ; QV10.3 141.3,87.74 141.36,87.59 RV509.1 ; JSIM1.13 288.08,76.58 v2(288.12,76.54) ; CV99.2 219.43,89.52 v2(219.43,90.12) ; PR310.2 224.42,48.71 PR311.2 224.42,47.79 v2(224.12,47.48) ; v2(269.33,18.6) 269.45,18.47 JSATA1.24 ; PR829.2 68.15,91.38 PC828.2 69.15,90.81 v2(69.05,90.71) ; v2(275.2,3.1) 275.31,2.99 JRTC1.4 ; v2(215.53,87.52) 214.2,87.52 CV92.2 ; RV619.2 RV620.2 188.38,87.56 v2(188.43,87.61) ; PC507.2 v2(217.82,107.56) ; v2(232.26,56.11) 234.11,57.95 JNGFF2.69 ; v2(198.84,70.57) 198.33,70.57 198.26,70.64 PR424.2 198.21,71.11 198.33,71.23 PC420.2 197.46,71.48 PR428.2 ; RL9.2 259.8,90.52 259.42,90.9 259.42,94.01 v2(259.45,94.03) ; v2(220.73,88.82) 221.39,88.15 CV101.2 ; v2(179.65,86.06) CC302.2 ; v2(234.41,98.22) 234.3,98.1 CV55.2 ; PC813.2 v2(65.28,84.28) ; v2(231.05,95.16) 231.05,95.31 231.3,95.56 CV51.2 RV32.2 ; RV609.1 202.83,82.73 203.26,83.16 v2(203.26,83.62) ; 186.32,92.72 RV621.2 ; 186.32,92.72 v3(186.33,92.73) ; v2(156.35,84.43) 156.54,84.24 CC226.2 ; v2(256.12,89.18) 256.12,89.45 CL28.2 ; JSIM1.14 289.61,74.62 v2(289.15,75.08) ; v2(223.35,66.58) 223.35,67.19 PR103.2 ; CV56.2 236.49,97.76 v2(236.49,98.21) ; PR509.2 v2(218.75,107.57) ; JSIM1.12 286.92,87.94 v2(286.91,87.95) ; PH601.1 98.16,69.35 97.4,69.35 96.99,68.94 v2(96.99,68.63) ; PC119.2 v2(220.31,56.86) ; v2(284.01,88.52) CL22.1 284.69,87.33 285.08,87.71 v2(285.08,88.47) ; CE36.2 134.1,89.01 v2(133.66,88.56) ; CC210.2 170.62,84.54 171.02,84.93 v2(171.02,85.94) ; PR427.1 PC410.2 204.59,60.29 204.92,59.96 204.92,58.56 v2(204.79,58.42) 204.79,57.76 PR415.2 ; v2(225.82,95.16) 225.11,94.45 CV616.2 ; CC271.2 171.97,95.01 v2(171.95,95.04) ; PC908.2 v2(25.87,73.54) ; DV5.1 233.67,99.15 v2(233.67,98.2) 233.06,97.6 CV54.2 ; UC5.4 194.91,75.16 v2(193.86,74.12) ; v2(50.06,98.32) 50.06,98.19 50.71,97.54 PD7.1 ; PC505.2 v2(208.97,110.66) ; DA7.1 v2(288.5,13.24) ; v2(194.32,61.17) 194.91,60.58 UC6.4 ; JUART1.5 25.62,86 v2(26.2,85.42) ; PC128.2 v2(227.21,57.92) ; v2(111.43,88.88) 111.43,89.68 DV4.1 ; v2(218.55,66.32) 218.91,66.32 PC111.2 ; JUART1.6 25.62,92.14 v2(24.63,93.13) ; PC829.1 68.21,85.86 v2(68.21,85.4) ; RZ27.2 285.41,75.42 v2(285.71,75.11) ; v2(188.64,84.79) 188.5,84.64 RV617.2 RV618.2 ; v2(189.67,60.71) 190.13,61.17 CC272.2 ; PC661.2 v2(96.05,76.79) ; PR908.1 116.6,97.84 v2(115.81,98.63) ; v2(102.13,68.43) 102,68.3 PC677.2 ; v2(122.47,87.56) 122.26,87.35 CC300.2 ; RV608.1 202.3,84.76 202.58,85.04 204.05,85.04 204.56,84.54 v2(204.58,84.54) ; UI1.2 v2(20.33,89.67) ; v2(89.39,64.85) 89.14,64.6 PC651.1 ; JSD1.23 284.82,21.53 v2(284.95,21.4) ; CC216.2 170.7,83.32 171.06,83.67 v2(171.06,84) ; H4.1 184.03,52.63 RC4.2 ; DA6.1 v2(284.44,13.26) ; v2(295.29,49.73) JSD1.26 293.1,49.73 ; RV616.2 192.67,92.16 193.1,92.59 v2(193.1,92.76) ; JNGFF1.68 v2(242.6,13.87) ; DI3.1 v2(73.09,90.66) ; PC831.2 68.44,87.79 v2(68.36,87.86) ; PR647.1 v2(87.82,60.07) ; v2(238.34,95.89) 237.89,95.44 CV53.2 RV34.2 ; PC647.1 89.24,65.49 v2(89.45,65.69) ; v2(281.55,51.06) 281.05,50.56 JSD1.24 ; UC13.3 172.2,90.96 171.39,90.96 171.13,91.22 v2(171.03,91.22) ; v2(272.22,3.1) 272.11,2.99 JRTC1.3 ; v2(124.17,87) 124.22,86.95 RC110.1 ; CC21.2 151.57,82.85 151.94,82.48 151.94,81.78 v2(151.98,81.74) ; RV33.2 CV52.2 235.86,95.56 v2(236,95.42) ; PH603.1 93.03,78.49 v2(93.03,79.05) ; v2(208.62,104.35) 208.3,104.02 PR506.2 ; v2(97.11,49.56) 97.08,49.53 96.39,49.53 PC209.2 ; CC25.2 260.95,27.51 v2(260.87,27.59) ; PR116.2 v2(225.06,58.45) ; v2(262.32,16.79) 262.32,16.58 JNGFF1.69 ; v2(70.67,72.98) 70.47,72.98 70.21,72.71 DE1.2 ; JSD1.20 273.87,22.99 v2(273.42,22.53) ; v2(272.43,38.87) 272.43,38.66 272.83,38.25 JSD1.3 ; v2(25.05,87.96) 24.97,87.89 JUART1.4 ; JSD1.22 273.87,49.57 274.25,49.94 275.04,49.94 v2(275.22,49.76) ; PC645.2 87.28,68.15 87.22,68.22 87.07,68.22 87.06,68.23 v2(86.93,68.23) ; PC605.1 v2(74,64.72) ; CC221.2 v2(156.62,87.06) ; v2(237.88,98.19) 238.06,98.36 DV6.1 ; CE32.2 v2(70.94,72.36) ; JEDP1.44 v2(78.6,91.52) ; v2(271.97,35.46) 271.97,35.44 272,35.41 JSD1.21 ; PC814.2 v2(58.15,82.83) ; JSPK1.5 v2(278.67,3.1) ; v2(123.23,86.9) RC112.1
  vias: v2(0.45,92.35) v2(6.12,95.38) v2(7.22,98.65) v2(7.89,76.15) v2(8.4,77.97) v2(8.98,99.61) v2(8.98,96.09) v2(10.07,100.65) v2(10.09,92.34) v2(10.58,72.67) v2(11.01,99.61) v2(11.01,96.09) v2(13.68,100.64) v2(14.01,78.92) v2(14.26,72.5) v2(17.11,84.28) v2(17.68,82.45) v2(18.63,75.62) v2(20,99.24) v2(20,75.49) v2(20.43,94.82) v2(20.67,94.19) v2(21.04,86.11) v2(21.8,86.19) v2(21.93,87.46) v2(21.93,86.87) v2(21.91,72.5) v2(22.97,85.2) v2(23.71,95.56) v2(26.48,82.78) v2(26.45,79.96) v2(26.68,81.29) v2(27.16,82.78) v2(27.32,79.99) v2(28.08,80.8) v2(29.02,93.91) v2(29.5,72.5) v2(36.64,93.91) v2(37.17,72.5) v2(41.44,85.35) v2(41.49,84.64) v2(42,85.02) v2(42.53,84.66) v2(42.61,85.32) v2(42.69,12.13) v2(43.22,72.27) v2(43.47,12.05) v2(43.93,88.04) v2(44.26,93.91) v2(44.48,13.81) v2(44.48,10.29) v2(44.56,88.01) v2(46.51,13.81) v2(46.51,10.29) v2(47.53,12.05) v2(47.96,15.83) v2(49.03,96.32) v2(49.06,102.44) v2(49.16,70.87) v2(49.29,109.81) v2(50.22,106.35) v2(50.28,9.25) v2(51.23,108.11) v2(51.23,104.59) v2(53.26,108.11) v2(53.26,104.59) v2(53.45,18.15) v2(54.28,106.35) v2(54.41,69.02) v2(54.52,80.9) v2(54.52,80.32) v2(54.49,79.68) v2(54.47,79.07) v2(54.47,78.41) v2(55.25,80.82) v2(55.24,80.12) v2(55.18,78.34) v2(55.33,15.83) v2(55.33,15.19) v2(55.33,14.56) v2(55.84,16.46) v2(55.97,15.83) v2(55.97,15.19) v2(55.97,14.56) v2(56.65,15.88) v2(56.65,15.24) v2(56.65,14.61) v2(57.02,112.01) v2(57.06,104.7) v2(57.29,15.88) v2(57.29,15.24) v2(57.29,14.61) v2(57.38,69.07) v2(57.82,9.25) v2(58.09,101.25) v2(58.3,78.38) v2(58.51,81.21) v2(58.49,80.63) v2(58.48,79.99) v2(58.72,21.9) v2(59.14,81.27) v2(59.81,81.6) v2(60.13,66.34) v2(60.32,81.17) v2(60.77,81.65) v2(61,89.49) v2(61,88.57) v2(61.39,94.9) v2(61.7,88.53) v2(61.66,87.63) v2(61.81,89.49) v2(61.97,94.87) v2(62.25,73.3) v2(62.62,89.46) v2(62.57,88.5) v2(62.57,87.63) v2(62.73,72.85) v2(63.14,72.42) v2(63.41,86.54) v2(63.57,62.91) v2(63.99,86.54) v2(64.25,27.19) v2(65.17,59.02) v2(65.39,66.91) v2(65.49,9.25) v2(65.83,90.96) v2(65.8,66.48) v2(66.23,66.02) v2(66.56,53.42) v2(66.75,34.28) v2(68.01,46.84) v2(68.05,40.64) v2(69.09,95.52) v2(70.06,95.44) v2(70.66,95.47) v2(70.82,76.99) v2(70.93,101.22) v2(71.13,94.19) v2(71.18,93.48) v2(71.44,76.99) v2(71.87,112.04) v2(72.6,76.99) v2(73.06,9.25) v2(73.21,76.99) v2(73.57,50.83) v2(73.57,50.24) v2(73.57,49.64) v2(73.57,49.03) v2(73.57,48.44) v2(73.57,47.81) v2(73.95,85.14) v2(74.09,86.66) v2(74.36,76.99) v2(74.61,67.11) v2(74.94,50.73) v2(74.94,50.12) v2(74.94,49.48) v2(74.94,48.87) v2(75.04,76.99) v2(74.97,66.02) v2(74.97,48.29) v2(74.97,47.68) v2(75.25,68) v2(75.73,91.06) v2(75.93,75.95) v2(76,73.06) v2(76.62,75.95) v2(76.8,82.87) v2(77.09,76.99) v2(77.28,66.76) v2(77.28,65.59) v2(77.36,58.87) v2(77.56,87.84) v2(77.68,76.99) v2(77.99,91.52) v2(78.1,66.82) v2(78.12,58.88) v2(78.4,112.04) v2(78.7,87.58) v2(78.73,82.46) v2(78.87,17.2) v2(79.36,74.6) v2(79.77,76.99) v2(80.05,74.6) v2(80.53,82.46) v2(80.45,76.99) v2(80.61,15.4) v2(80.62,13.82) v2(80.73,74.6) v2(80.71,9.25) v2(80.79,104.6) v2(80.83,26.12) v2(80.83,25.51) v2(81.04,76.99) v2(81.34,18.57) v2(81.49,92.23) v2(81.49,74.6) v2(81.49,15.93) v2(81.7,76.99) v2(81.7,67.01) v2(81.7,66.3) v2(81.7,65.66) v2(82.28,14.79) v2(82.41,67.01) v2(82.41,66.3) v2(82.43,65.67) v2(82.59,76.99) v2(82.85,93.49) v2(83.12,67.01) v2(83.12,66.3) v2(83.12,65.66) v2(83.22,51.97) v2(83.3,76.99) v2(83.4,88.98) v2(83.4,17.12) v2(83.48,92.55) v2(83.53,87.71) v2(83.45,15.32) v2(83.55,64.75) v2(83.6,51.46) v2(83.66,88.46) v2(83.76,67.01) v2(83.76,66.3) v2(83.78,65.66) v2(83.81,13.85) v2(83.96,53.22) v2(83.96,52.61) v2(83.96,51.95) v2(84.26,51.41) v2(84.59,51.95) v2(84.95,51.41) v2(85.15,53.22) v2(85.18,52.63) v2(85.2,52.02) v2(85.46,92.19) v2(85.48,13.82) v2(85.66,51.59) v2(85.66,17.76) v2(86.12,52) v2(86.42,53.22) v2(86.45,52.63) v2(86.55,91.96) v2(87.01,89.28) v2(87.69,89.31) v2(87.69,15.17) v2(88.23,91.94) v2(88.33,9.25) v2(88.45,104.63) v2(88.65,10.51) v2(88.86,17.89) v2(88.86,16.36) v2(89.52,14.69) v2(89.78,85.09) v2(89.83,10.37) v2(89.97,72.32) v2(89.95,71.56) v2(90.36,85.12) v2(90.65,76.66) v2(90.65,76.03) v2(90.63,75.4) v2(91.22,92.01) v2(91.24,75.38) v2(91.25,18.52) v2(91.17,17) v2(91.26,76.66) v2(91.26,76.03) v2(91.29,74.74) v2(91.29,74.16) v2(91.29,73.55) v2(91.63,71.05) v2(91.6,70.46) v2(91.55,51.52) v2(91.58,14.2) v2(91.84,76.05) v2(91.83,75.38) v2(91.87,76.66) v2(91.87,74.74) v2(91.87,74.16) v2(91.87,73.55) v2(91.93,54.74) v2(91.93,53.8) v2(91.97,51.93) v2(92.22,85.23) v2(92.34,56.71) v2(92.48,54.31) v2(92.89,16.08) v2(93.03,54.79) v2(93.03,53.8) v2(93.23,81.59) v2(93.53,88.52) v2(94.8,112.04) v2(94.86,17.2) v2(95.01,104.54) v2(95.59,14.2) v2(95.8,88.9) v2(95.95,9.25) v2(96.3,89.23) v2(96.33,63.4) v2(96.33,62.79) v2(96.37,62.21) v2(96.43,60.63) v2(96.63,66.83) v2(96.63,66.25) v2(96.63,65.66) v2(96.63,65.03) v2(96.63,64.42) v2(96.71,15.4) v2(96.79,13.11) v2(96.92,61.64) v2(96.89,61.03) v2(97.45,66.25) v2(97.4,65.64) v2(97.4,65) v2(97.4,64.39) v2(97.47,66.83) v2(98.16,66.25) v2(98.16,65.64) v2(98.16,64.98) v2(98.16,64.37) v2(98.23,10.32) v2(98.26,88.93) v2(98.34,13.72) v2(98.61,89.41) v2(99.94,17.12) v2(100.04,10.29) v2(100.34,82.05) v2(100.34,42.8) v2(100.42,96.45) v2(100.52,14.15) v2(100.9,17.43) v2(101.05,96.43) v2(100.98,42.82) v2(101.08,82.05) v2(101.21,111.94) v2(101.41,104.47) v2(101.72,88.4) v2(101.81,10.29) v2(102.5,83.8) v2(102.86,90.38) v2(102.86,86.42) v2(103.08,83.8) v2(103.57,9.27) v2(103.67,83.8) v2(104.13,98.81) v2(104.28,83.81) v2(104.86,83.81) v2(105.14,90.38) v2(105.14,86.42) v2(105.17,15.07) v2(105.47,83.82) v2(105.75,16.97) v2(106.28,88.4) v2(107.28,17.48) v2(108.01,76.25) v2(108.09,66.11) v2(108.15,79.53) v2(108.16,69.22) v2(108.67,16.46) v2(108.77,79.55) v2(108.75,69.22) v2(108.83,66.11) v2(108.8,14.94) v2(108.85,76.25) v2(109.41,69.22) v2(109.46,66.08) v2(110.02,69.22) v2(110.15,33.68) v2(110.2,16.21) v2(110.4,78.97) v2(110.43,78.11) v2(110.58,34.12) v2(111.19,9.25) v2(112.01,15.19) v2(112.2,13.8) v2(112.83,55.43) v2(112.83,54.82) v2(112.83,54.19) v2(112.83,53.6) v2(113.22,98) v2(114.22,16.17) v2(114.91,88.68) v2(115.81,16.74) v2(115.81,15.21) v2(116.75,102.47) v2(116.85,87.23) v2(117.21,87.76) v2(117.51,87.23) v2(117.79,87.76) v2(118.1,87.25) v2(118.19,107.8) v2(118.22,105.35) v2(118.2,95.15) v2(118.22,17.63) v2(118.22,15.34) v2(118.4,87.76) v2(118.81,9.25) v2(119.53,16.56) v2(119.52,15.02) v2(120.18,109.26) v2(121.58,18.11) v2(121.58,16.56) v2(121.55,15.02) v2(122.27,107.79) v2(122.28,105.35) v2(122.69,17.96) v2(122.77,72.93) v2(123.28,14.69) v2(123.53,16.18) v2(124.35,112.46) v2(125.13,60.28) v2(125.36,16.31) v2(125.49,18.7) v2(125.74,58.4) v2(125.77,62.87) v2(126.43,9.25) v2(126.68,14.15) v2(126.88,58.73) v2(126.94,18.65) v2(127.01,60.33) v2(126.96,17.12) v2(127.09,62.79) v2(128.21,63.91) v2(128.38,62.79) v2(128.66,14.08) v2(128.97,60.33) v2(129.04,17.66) v2(130.11,63.86) v2(130.26,62.82) v2(130.52,49.74) v2(130.54,47.88) v2(130.94,51.45) v2(130.87,17.15) v2(131.64,112.66) v2(131.58,92.92) v2(132.17,92.97) v2(132.19,14.25) v2(132.57,93.53) v2(132.78,49.61) v2(133.11,51.31) v2(133.56,17.78) v2(133.56,17.2) v2(134.1,9.25) v2(135.06,48.7) v2(135.24,14.76) v2(135.32,106.35) v2(135.34,50.55) v2(136.82,46.61) v2(137.12,13.09) v2(137.12,10.4) v2(137.2,51.31) v2(137.2,49.46) v2(137.2,47.68) v2(137.25,14.66) v2(137.5,106.18) v2(137.71,17.6) v2(137.68,16.06) v2(138.12,10.42) v2(138.62,91.29) v2(138.98,106.07) v2(139.2,103.79) v2(139.28,112.65) v2(139.69,91.16) v2(139.81,50.63) v2(139.79,48.75) v2(139.79,46.89) v2(140.22,103.76) v2(140.68,91.75) v2(140.85,105.59) v2(141.57,45.05) v2(141.64,9.25) v2(141.67,15.37) v2(141.97,49.94) v2(142,48.11) v2(142,46.21) v2(142.23,105.46) v2(142.58,91.7) v2(143.17,51.12) v2(143.17,49.17) v2(143.17,47.22) v2(143.27,80.85) v2(143.29,27.69) v2(143.34,27.08) v2(143.34,26.42) v2(143.34,25.73) v2(144.26,81.97) v2(144.31,79.96) v2(144.49,91.67) v2(144.66,45.52) v2(145.22,81.16) v2(145.22,49.94) v2(145.17,48.54) v2(145.17,46.59) v2(145.27,51.85) v2(145.66,93.48) v2(146.27,93.54) v2(146.54,80.62) v2(146.54,79.04) v2(146.52,10.49) v2(146.75,62.95) v2(146.87,112.65) v2(147.18,69.37) v2(147.2,68.18) v2(147.15,66.02) v2(147.15,65.26) v2(147.15,64.11) v2(147.43,68.79) v2(147.64,70.77) v2(147.74,66.2) v2(147.74,65.61) v2(147.74,65.03) v2(147.75,63.96) v2(147.89,49.71) v2(147.89,47.78) v2(147.89,46.45) v2(148.11,102.37) v2(148.42,69.19) v2(148.4,68.56) v2(148.5,105.59) v2(148.61,80.64) v2(149.34,81.42) v2(149.31,51.97) v2(149.29,9.25) v2(149.47,50.04) v2(149.47,48.49) v2(150.05,80.09) v2(150,70.53) v2(150,69.88) v2(150,68.71) v2(150.2,104.96) v2(150.79,81.72) v2(150.96,78.7) v2(151.22,65.76) v2(151.19,65) v2(151.19,63.99) v2(151.22,19.35) v2(151.22,11.4) v2(151.4,104.99) v2(151.62,80.52) v2(152.01,51.85) v2(152.03,48.01) v2(152.06,49.81) v2(152.23,21.11) v2(152.23,17.59) v2(152.23,13.16) v2(152.37,70.53) v2(153.4,51.62) v2(153.4,49.81) v2(153.38,47.93) v2(153.38,46.71) v2(153.66,94.11) v2(154.26,21.11) v2(154.26,17.59) v2(154.26,13.16) v2(154.46,112.66) v2(154.67,66.6) v2(154.67,65.76) v2(154.67,65) v2(154.67,63.99) v2(154.75,70.63) v2(154.85,106) v2(154.85,77.8) v2(155.13,104.86) v2(155.06,103.37) v2(155.13,79.33) v2(155.28,19.35) v2(155.28,11.4) v2(155.43,94.11) v2(155.76,50.65) v2(155.79,48.72) v2(155.82,46.79) v2(155.84,45.55) v2(156.93,104.6) v2(156.88,103.28) v2(156.96,66.27) v2(157.31,94.06) v2(157.47,79.12) v2(157.59,50.58) v2(157.59,48.64) v2(157.59,46.71) v2(157.9,67.64) v2(158.36,9.25) v2(158.89,50.83) v2(158.89,48.98) v2(158.86,47.1) v2(159.02,67.64) v2(158.96,66.88) v2(159.02,17.56) v2(159.19,79.94) v2(160.39,25.07) v2(160.54,17.56) v2(160.64,48.7) v2(160.64,46.82) v2(160.67,49.94) v2(161.05,81.61) v2(161.05,25.05) v2(161.07,79.66) v2(161.17,14.81) v2(161.73,25.07) v2(162.07,112.66) v2(162.29,105.34) v2(162.34,25.02) v2(162.85,89.87) v2(162.98,79.2) v2(163.21,15.85) v2(163.54,105.34) v2(163.79,89.92) v2(164.71,89.82) v2(164.89,105.32) v2(164.95,80.21) v2(164.98,81.16) v2(165.09,15.33) v2(165.77,79.53) v2(165.95,9.25) v2(166.16,78.38) v2(166.28,14.08) v2(168.08,78.08) v2(168.62,81.18) v2(169.28,79.43) v2(169.74,112.65) v2(169.86,81.18) v2(170.44,16.65) v2(170.5,14.1) v2(171.89,14.99) v2(172.07,18.22) v2(172.1,16.69) v2(172.17,50.66) v2(173.62,9.25) v2(173.85,50.59) v2(174.03,18.16) v2(174.03,15.85) v2(175.31,60.7) v2(175.33,41.04) v2(175.58,16.84) v2(176.01,49.47) v2(176.39,15.37) v2(176.77,61.74) v2(177.32,112.67) v2(177.44,57.19) v2(177.76,14.18) v2(181.22,9.25) v2(181.52,14.79) v2(181.85,32.7) v2(182.05,15.5) v2(182.3,112.1) v2(182.43,32.7) v2(183.02,32.7) v2(183.26,17.07) v2(183.65,32.7) v2(184.09,105.35) v2(184.47,18.65) v2(185.17,107.22) v2(185.17,103.48) v2(187.06,16.06) v2(187.33,107.22) v2(187.33,103.48) v2(188.41,105.35) v2(188.4,15.45) v2(188.86,9.25) v2(189.28,108.54) v2(189.65,67.42) v2(189.75,102.44) v2(189.85,80.95) v2(190,92.82) v2(190.23,79.3) v2(190.87,16.59) v2(190.87,15.07) v2(191.15,80.55) v2(191.71,72.18) v2(192.49,79.96) v2(193.15,86.44) v2(193.23,84.66) v2(193.35,79.82) v2(194.05,81.54) v2(194.35,62.35) v2(194.83,97.29) v2(194.83,61.74) v2(194.91,62.93) v2(194.91,15.32) v2(194.96,62.32) v2(195.11,92.76) v2(195.24,84.69) v2(195.25,79.69) v2(195.36,86.44) v2(195.39,61.55) v2(195.69,61.01) v2(195.77,17.76) v2(196.03,60.29) v2(196.13,61.52) v2(196.23,15.68) v2(196.33,80.45) v2(196.3,60.86) v2(196.48,9.25) v2(196.68,84.66) v2(196.71,61.55) v2(196.68,14.94) v2(196.79,86.44) v2(196.91,60.89) v2(196.91,47.43) v2(197.04,92.77) v2(197.19,17.96) v2(197.27,13.8) v2(197.62,60.84) v2(198.6,16.61) v2(198.84,57.41) v2(199.07,15.32) v2(199.07,13.8) v2(199.43,57.41) v2(199.45,17.35) v2(200.04,57.41) v2(200.29,58.8) v2(200.62,57.41) v2(200.76,13.89) v2(200.88,48.61) v2(201.05,70.06) v2(201.25,63.12) v2(201.47,70.62) v2(201.6,50.32) v2(201.83,63.12) v2(201.81,49) v2(201.87,17.66) v2(201.99,70.11) v2(202.26,50.32) v2(202.3,48.67) v2(202.45,14.53) v2(202.54,63.12) v2(202.6,15.85) v2(202.78,13.03) v2(202.86,69.37) v2(202.86,50.32) v2(202.88,48.68) v2(203,53.58) v2(203.13,63.12) v2(203.24,99.7) v2(203.25,52.56) v2(203.31,17.89) v2(203.31,16.34) v2(203.47,69.4) v2(203.56,53.12) v2(203.77,70.13) v2(203.84,63.12) v2(203.92,80.75) v2(204.08,53.57) v2(204.08,9.25) v2(204.42,63.12) v2(204.37,15.35) v2(204.71,73.92) v2(204.77,70.75) v2(205.12,105.52) v2(205.07,92.94) v2(205.07,69.75) v2(205.19,70.34) v2(205.32,73.89) v2(205.57,14.51) v2(205.73,111.92) v2(205.69,80.88) v2(206.13,71.4) v2(206.18,72.62) v2(206.16,72.04) v2(206.21,70.72) v2(206.21,70.11) v2(206.16,69.22) v2(206.16,68.61) v2(206.44,52.23) v2(206.67,73.04) v2(206.72,15.5) v2(207,58.8) v2(207.02,52.23) v2(207.31,73.04) v2(207.65,91) v2(207.61,58.8) v2(207.68,92.87) v2(207.73,69.22) v2(207.73,68.63) v2(207.78,72.5) v2(207.78,71.89) v2(207.76,70.72) v2(207.76,70.11) v2(209.1,15.78) v2(209.11,15.15) v2(209.33,94.03) v2(209.26,58.86) v2(209.43,92.13) v2(209.37,90.1) v2(209.79,57.21) v2(209.92,109.71) v2(209.87,58.83) v2(209.87,10.42) v2(210.25,56.85) v2(210.5,109.71) v2(210.68,92.03) v2(210.73,90.12) v2(210.7,57.26) v2(210.78,82.81) v2(210.81,16.95) v2(210.93,48.48) v2(211.03,56.75) v2(211.06,50.22) v2(211.39,82.81) v2(211.36,57.24) v2(211.64,50.22) v2(211.59,48.48) v2(211.68,9.24) v2(212.04,90.44) v2(212,82.81) v2(212.08,92.21) v2(212.3,48.48) v2(212.36,96.8) v2(212.46,50.22) v2(212.45,15.63) v2(212.97,48.48) v2(213.07,50.22) v2(213.35,111.92) v2(213.52,96.8) v2(214.82,15.35) v2(215.01,104.63) v2(215.07,101.3) v2(215.29,96.88) v2(215.6,104.63) v2(215.76,101.3) v2(216.09,34.6) v2(216.32,15.55) v2(216.37,13.87) v2(216.8,96.85) v2(218.22,14.53) v2(218.27,97.72) v2(218.6,70.69) v2(218.76,71.28) v2(219.31,9.23) v2(220.08,85.57) v2(220.05,61.4) v2(220.46,61.88) v2(220.64,110.19) v2(220.94,107.32) v2(220.94,15.32) v2(221.22,108.95) v2(221.18,71.38) v2(221.58,84.41) v2(221.63,27.46) v2(221.88,15.62) v2(222.11,45.98) v2(222.24,110.71) v2(222.24,107.19) v2(222.21,34.01) v2(222.59,54.72) v2(222.69,45.98) v2(222.91,62.08) v2(223.07,15.5) v2(223.24,111.88) v2(223.2,54.72) v2(223.25,56.42) v2(223.37,57.1) v2(223.55,71.8) v2(223.56,99.56) v2(223.7,71.24) v2(223.79,54.72) v2(223.91,70.69) v2(223.92,70.04) v2(223.93,69.44) v2(223.89,16.34) v2(223.99,57.1) v2(224.09,15.57) v2(224.19,99.56) v2(224.18,71.62) v2(224.26,110.71) v2(224.26,107.19) v2(224.4,71.07) v2(224.42,70.41) v2(224.47,69.69) v2(224.7,10.49) v2(224.94,70.15) v2(224.88,56.34) v2(224.88,55.71) v2(225.17,73.11) v2(225.21,72.52) v2(225.21,71.94) v2(225.23,70.67) v2(225.28,108.95) v2(225.27,62.73) v2(225.26,62.12) v2(225.54,107.27) v2(225.46,64.32) v2(225.56,18.11) v2(225.74,110.27) v2(225.85,62.1) v2(225.85,62.7) v2(225.89,10.37) v2(226.07,64.32) v2(226.44,62.69) v2(226.44,62.07) v2(226.68,64.32) v2(226.92,9.25) v2(227.04,62.68) v2(227.04,62.09) v2(227.88,48.62) v2(228.28,30.61) v2(228.56,111.85) v2(228.72,67.23) v2(228.76,66.59) v2(228.88,107.82) v2(229.22,54.35) v2(229.32,31.2) v2(229.3,30.56) v2(229.4,35.92) v2(230.23,56.11) v2(230.23,52.59) v2(230.2,31.13) v2(230.21,30.53) v2(230.24,29.77) v2(230.24,29.14) v2(230.6,100.16) v2(230.58,96.82) v2(230.58,96.23) v2(231,98.33) v2(231.09,35.83) v2(231.18,100.16) v2(231.18,63.05) v2(231.42,62.44) v2(232.3,77.32) v2(232.26,52.59) v2(232.98,91.6) v2(233.28,54.35) v2(234.1,91.62) v2(234.59,9.25) v2(235.01,91.63) v2(234.96,81.51) v2(235.27,67.34) v2(235.37,81.03) v2(235.42,66.12) v2(235.6,11.08) v2(235.75,81.54) v2(235.81,11.85) v2(235.93,91.65) v2(236.16,13.57) v2(236.59,66.61) v2(236.66,74.12) v2(236.94,91.67) v2(237.08,14.05) v2(237.08,9.65) v2(237.37,43.13) v2(238.47,64.7) v2(238.57,66.5) v2(238.59,46.38) v2(239.05,46.82) v2(239.15,43.1) v2(239.25,47.55) v2(239.56,30.18) v2(239.58,29.14) v2(239.58,28.07) v2(239.62,14.05) v2(239.62,9.65) v2(240.31,52.55) v2(240.36,44.24) v2(240.35,10.24) v2(240.55,28.1) v2(240.6,30.15) v2(240.58,29.14) v2(240.85,13.31) v2(240.89,11.85) v2(241.47,55.07) v2(241.64,30.18) v2(241.62,29.11) v2(241.62,28.13) v2(241.79,87.53) v2(242.15,89.01) v2(242.4,9.23) v2(242.89,78.55) v2(242.87,77.97) v2(243.2,81.63) v2(244.18,33.61) v2(244.44,23.75) v2(245.02,23.75) v2(245.29,107.7) v2(245.51,8.98) v2(245.96,1.32) v2(246.14,17.89) v2(246.87,102.24) v2(247.23,100.59) v2(247.46,102.21) v2(247.64,84.54) v2(247.64,82.5) v2(247.64,80.62) v2(247.81,100.59) v2(248.12,7.98) v2(248.09,7.32) v2(248.17,17.91) v2(248.37,12.7) v2(248.47,19.84) v2(248.78,7.95) v2(248.75,7.32) v2(248.86,50.22) v2(249.57,84.41) v2(249.64,82.63) v2(249.72,80.65) v2(249.85,25.05) v2(249.97,12.7) v2(250.18,19.84) v2(250.67,48.35) v2(250.74,23.96) v2(250.81,52.23) v2(250.86,26.7) v2(251.04,111.9) v2(251.07,46.99) v2(251.42,110.65) v2(251.42,107.19) v2(251.47,84.51) v2(251.5,82.6) v2(251.57,80.7) v2(251.74,109) v2(251.81,50.33) v2(251.81,46.37) v2(251.75,19.82) v2(251.85,11.64) v2(252.01,16.74) v2(252.21,26.85) v2(252.41,12.68) v2(252.75,110.75) v2(252.75,107.24) v2(252.94,50.68) v2(252.89,26.83) v2(252.95,0.48) v2(253.25,46.08) v2(253.68,25.78) v2(253.82,111.9) v2(253.78,106.1) v2(253.96,6.58) v2(254.09,50.33) v2(254.09,46.37) v2(254.44,20.45) v2(254.78,110.75) v2(254.78,107.24) v2(254.8,49.71) v2(255.03,47.45) v2(255.23,48.35) v2(255.23,18.65) v2(255.8,109) v2(255.87,107.04) v2(256.27,110.32) v2(256.78,111.8) v2(256.81,95.75) v2(257.03,38.87) v2(257.06,12.17) v2(257.77,10.88) v2(259.07,94.97) v2(259.12,11.92) v2(260.44,18.99) v2(260.52,70.3) v2(260.51,16.74) v2(260.57,0.48) v2(260.69,17.76) v2(261.2,47.55) v2(261.3,23.63) v2(261.35,25.18) v2(261.53,42.63) v2(261.53,41.61) v2(261.65,40.79) v2(261.89,45.17) v2(262.39,13.01) v2(262.52,42.63) v2(262.52,41.64) v2(262.6,40.69) v2(262.88,47.45) v2(262.85,25.23) v2(262.88,23.7) v2(263.11,88.02) v2(263.1,85.93) v2(263.51,42.6) v2(263.48,41.64) v2(263.51,40.67) v2(263.92,107.71) v2(263.94,63.28) v2(263.94,61.24) v2(263.98,59.16) v2(264.83,85.96) v2(264.79,30.72) v2(264.99,88.04) v2(265.39,112.18) v2(265.87,63.15) v2(265.95,61.37) v2(266.05,59.21) v2(266.26,109.67) v2(266.26,104.18) v2(266.36,70.05) v2(266.94,70.06) v2(267.78,63.25) v2(267.78,61.34) v2(267.82,59.3) v2(267.93,51.31) v2(268.21,0.51) v2(269.46,7.1) v2(269.64,24.93) v2(269.63,10.21) v2(269.96,7.65) v2(270.14,24.62) v2(270.2,30.5) v2(270.5,22.23) v2(270.52,20.93) v2(273.06,1.58) v2(274.13,16.54) v2(274.48,78.74) v2(274.53,77.27) v2(274.48,76.05) v2(274.74,81.69) v2(274.76,16.67) v2(274.76,16.08) v2(275.14,78.72) v2(275.6,77.27) v2(275.6,76.08) v2(275.75,81.72) v2(276.24,50.06) v2(276.82,50.07) v2(277.14,68.3) v2(277.41,41.2) v2(277.99,41.2) v2(278.07,74.43) v2(278.28,70.28) v2(278.28,66.32) v2(278.5,1.58) v2(278.57,41.2) v2(278.73,31.86) v2(278.75,33.35) v2(278.93,80.32) v2(278.88,34.29) v2(279.08,77.25) v2(279.16,41.2) v2(279.56,80.29) v2(279.59,79.15) v2(279.64,31.8) v2(279.74,41.2) v2(279.69,33.38) v2(279.95,76.18) v2(279.95,74.45) v2(279.87,35.31) v2(280.07,78.06) v2(280.61,81) v2(280.56,70.28) v2(280.56,66.32) v2(280.83,35.34) v2(281.01,33.48) v2(281.01,31.83) v2(281.7,68.3) v2(282.49,63.12) v2(282.75,58.12) v2(282.92,63.53) v2(283.37,53.7) v2(283.73,105.73) v2(283.78,81.61) v2(283.78,80.65) v2(283.88,83.44) v2(283.88,82.68) v2(284.23,55.61) v2(284.23,52.09) v2(284.31,69.06) v2(284.72,112.22) v2(285.28,1.58) v2(285.43,104.14) v2(285.43,98.33) v2(286.26,55.61) v2(286.26,52.09) v2(287.28,53.85) v2(288.32,64.25) v2(288.28,42.73) v2(288.89,64.49) v2(290.74,93.81) v2(290.82,2.45) v2(290.78,1.26) v2(292.54,66.94) v2(292.47,2.49) v2(293.03,55.07) v2(294.23,5.11) v2(294.23,1.59) v2(295.16,0.55) v2(295.9,88.34) v2(296.26,5.11) v2(296.26,1.59) v2(297.2,72.36) v2(297.28,3.35) v2(297.38,52.09) v2(297.38,1.47) v2(297.7,38.78) v2(297.71,38) v2(298.44,5.68) v2(298.58,87.76) v2(298.84,93.8) v2(299.76,7.26) v2(302.5,89.42) v2(302.53,50.4) v2(303.01,67.69) v2(303.03,53.27) v2(303.31,49.74) v2(303.55,91.25) v2(304.42,21.65) v2(304.42,21.02) v2(304.56,71.09) v2(304.96,82.88) v2(304.96,80.62) v2(304.96,76.66) v2(305.39,50.3) v2(305.55,19.33) v2(305.85,42.17) v2(305.85,34.57) v2(305.85,26.88) v3(16.59,74.83) v3(22.47,94.89) v3(40.64,84.39) v3(50.51,11.27) v3(53.36,100.83) v3(60.09,73.12) v3(61.51,81.65) v3(77.38,75.75) v3(80.62,18.66) v3(83.25,52.59) v3(85.72,50.78) v3(105.83,67.28) v3(111.83,34.94) v3(118.96,87.75) v3(135.86,19.5) v3(146.83,93.54) v3(161.01,11.38) v3(165.42,102.02) v3(182.32,18.67) v3(184.52,100.87) v3(186.29,32.39) v3(201.59,48.48) v3(205.32,74.51) v3(209.31,56.38) v3(214.16,81.36) v3(215.99,102.56) v3(223.64,62.07) v3(227.8,62.75) v3(233.42,80.61) v3(263.61,101.12) v3(265.47,51.07) v3(267.66,19) v3(275.61,50.44) v3(282.35,57.67) v3(285.89,13.97) v3(287.35,17.83) v3(290.99,49.55) v3(292.51,71.1)
